*.OPTIONS RESMIN=5.000000e-07

* Resistance Unit: Kohm
* Current Unit: mA

* Capacitance Unit: pF

* Voltage Unit: V

*** P/G parasitics
R1 1 722 8.997102e-04k $ src node: 49200 53100 50755 53100
R2 717 1 1.330761e-03k $ 5 46900 53100 49200 53100
R3 2 717 1.099324e-03k $ 5 45000 53100 46900 53100
R4 3 2 5.438763e-03k $ 5 35600 53100 45000 53100
R5 4 3 2.545804e-03k $ 5 31200 53100 35600 53100
R6 5 4 8.100285e-04k $ 5 29800 53100 31200 53100
R7 6 5 5.785918e-04k $ 5 28800 53100 29800 53100
R8 7 6 5.785918e-04k $ 5 27800 53100 28800 53100
R9 642 7 9.836060e-04k $ 5 26100 53100 27800 53100
R10 8 642 1.000000e-06k $ 5 26100 53100 26100 53100
R11 9 8 6.364509e-04k $ 5 25000 53100 26100 53100
R12 10 9 2.082930e-03k $ 5 21400 53100 25000 53100
R13 11 10 3.355832e-03k $ 5 15600 53100 21400 53100
R14 12 11 2.314367e-03k $ 5 11600 53100 15600 53100
R15 13 12 8.100285e-04k $ 5 10200 53100 11600 53100
R16 14 13 8.100285e-04k $ 5 8800 53100 10200 53100
R17 15 14 6.943101e-04k $ 5 7600 53100 8800 53100
R18 16 15 5.785918e-04k $ 5 6600 53100 7600 53100
R19 567 16 7.521693e-04k $ 5 5300 53100 6600 53100
R20 17 567 5.785918e-05k $ 5 5200 53100 5300 53100
R21 18 17 8.100285e-04k $ 5 3800 53100 5200 53100
R22 19 18 8.100285e-04k $ 5 2400 53100 3800 53100
R23 20 723 1.246865e-03k $ src node: 48600 49500 50755 49500
R24 712 20 9.836060e-04k $ 5 46900 49500 48600 49500
R25 21 712 1.735775e-04k $ 5 46600 49500 46900 49500
R26 22 21 9.257468e-04k $ 5 45000 49500 46600 49500
R27 23 22 1.909353e-03k $ 5 41700 49500 45000 49500
R28 24 23 1.562198e-03k $ 5 39000 49500 41700 49500
R29 25 24 1.272902e-03k $ 5 36800 49500 39000 49500
R30 26 25 1.041465e-03k $ 5 35000 49500 36800 49500
R31 27 26 1.620057e-03k $ 5 32200 49500 35000 49500
R32 28 27 4.628734e-04k $ 5 31400 49500 32200 49500
R33 637 28 3.066536e-03k $ 5 26100 49500 31400 49500
R34 29 637 1.000000e-06k $ 5 26100 49500 26100 49500
R35 30 29 2.892959e-04k $ 5 25600 49500 26100 49500
R36 31 30 1.967212e-03k $ 5 22200 49500 25600 49500
R37 32 31 2.314367e-04k $ 5 21800 49500 22200 49500
R38 33 32 2.892959e-03k $ 5 16800 49500 21800 49500
R39 34 33 4.628734e-04k $ 5 16000 49500 16800 49500
R40 35 34 3.471551e-04k $ 5 15400 49500 16000 49500
R41 36 35 8.100285e-04k $ 5 14000 49500 15400 49500
R42 37 36 8.100285e-04k $ 5 12600 49500 14000 49500
R43 38 37 1.157184e-04k $ 5 12400 49500 12600 49500
R44 39 38 8.100285e-04k $ 5 11000 49500 12400 49500
R45 40 39 8.100285e-04k $ 5 9600 49500 11000 49500
R46 41 40 5.785918e-04k $ 5 8600 49500 9600 49500
R47 42 41 5.785918e-04k $ 5 7600 49500 8600 49500
R48 562 42 1.330761e-03k $ 5 5300 49500 7600 49500
R49 43 562 1.735775e-04k $ 5 5000 49500 5300 49500
R50 44 43 6.943101e-04k $ 5 3800 49500 5000 49500
R51 45 44 1.272902e-03k $ 5 1600 49500 3800 49500
R52 707 724 2.230471e-03k $ src node: 46900 45900 50755 45900
R53 46 707 1.041465e-03k $ 5 45100 45900 46900 45900
R54 47 46 6.364509e-04k $ 5 44000 45900 45100 45900
R55 48 47 6.075213e-03k $ 5 33500 45900 44000 45900
R56 49 48 7.521693e-04k $ 5 32200 45900 33500 45900
R57 632 49 3.529410e-03k $ 5 26100 45900 32200 45900
R58 50 632 1.000000e-06k $ 5 26100 45900 26100 45900
R59 51 50 5.785918e-05k $ 5 26000 45900 26100 45900
R60 52 51 4.050142e-03k $ 5 19000 45900 26000 45900
R61 53 52 1.157184e-04k $ 5 18800 45900 19000 45900
R62 54 53 1.967212e-03k $ 5 15400 45900 18800 45900
R63 55 54 6.943101e-04k $ 5 14200 45900 15400 45900
R64 56 55 1.388620e-03k $ 5 11800 45900 14200 45900
R65 57 56 1.793634e-03k $ 5 8700 45900 11800 45900
R66 557 57 1.967212e-03k $ 5 5300 45900 8700 45900
R67 58 557 4.050142e-04k $ 5 4600 45900 5300 45900
R68 59 58 4.628734e-04k $ 5 3800 45900 4600 45900
R69 60 725 8.997102e-04k $ src node: 49200 42300 50755 42300
R70 702 60 1.330761e-03k $ 5 46900 42300 49200 42300
R71 61 702 1.000000e-06k $ 5 46900 42300 46900 42300
R72 62 61 1.041465e-03k $ 5 45100 42300 46900 42300
R73 63 62 2.661522e-03k $ 5 40500 42300 45100 42300
R74 64 63 1.272902e-03k $ 5 38300 42300 40500 42300
R75 65 64 2.025071e-03k $ 5 34800 42300 38300 42300
R76 66 65 2.892959e-04k $ 5 34300 42300 34800 42300
R77 67 66 5.785918e-04k $ 5 33300 42300 34300 42300
R78 627 67 4.165861e-03k $ 5 26100 42300 33300 42300
R79 68 627 1.000000e-06k $ 5 26100 42300 26100 42300
R80 69 68 1.000000e-06k $ 5 26100 42300 26100 42300
R81 70 69 2.025071e-03k $ 5 22600 42300 26100 42300
R82 71 70 6.943101e-04k $ 5 21400 42300 22600 42300
R83 72 71 2.661522e-03k $ 5 16800 42300 21400 42300
R84 73 72 8.100285e-04k $ 5 15400 42300 16800 42300
R85 74 73 1.272902e-03k $ 5 13200 42300 15400 42300
R86 75 74 6.943101e-04k $ 5 12000 42300 13200 42300
R87 76 75 6.943101e-04k $ 5 10800 42300 12000 42300
R88 77 76 5.785918e-04k $ 5 9800 42300 10800 42300
R89 78 77 1.157184e-04k $ 5 9600 42300 9800 42300
R90 79 78 5.785918e-04k $ 5 8600 42300 9600 42300
R91 552 79 1.909353e-03k $ 5 5300 42300 8600 42300
R92 80 552 1.000000e-06k $ 5 5300 42300 5300 42300
R93 81 80 8.678877e-04k $ 5 3800 42300 5300 42300
R94 82 81 4.628734e-04k $ 5 3000 42300 3800 42300
R95 83 82 8.100285e-04k $ 5 1600 42300 3000 42300
R96 697 726 2.230471e-03k $ src node: 46900 38700 50755 38700
R97 84 697 2.314367e-04k $ 5 46500 38700 46900 38700
R98 85 84 8.678876e-04k $ 5 45000 38700 46500 38700
R99 86 85 2.082930e-03k $ 5 41400 38700 45000 38700
R100 87 86 8.100285e-04k $ 5 40000 38700 41400 38700
R101 88 87 1.504339e-03k $ 5 37400 38700 40000 38700
R102 89 88 1.215043e-03k $ 5 35300 38700 37400 38700
R103 90 89 6.364509e-04k $ 5 34200 38700 35300 38700
R104 91 90 4.628734e-04k $ 5 33400 38700 34200 38700
R105 92 91 1.157184e-04k $ 5 33200 38700 33400 38700
R106 93 92 5.207326e-04k $ 5 32300 38700 33200 38700
R107 94 93 9.257468e-04k $ 5 30700 38700 32300 38700
R108 95 94 1.562198e-03k $ 5 28000 38700 30700 38700
R109 96 95 5.785918e-04k $ 5 27000 38700 28000 38700
R110 622 96 5.207326e-04k $ 5 26100 38700 27000 38700
R111 97 622 1.000000e-06k $ 5 26100 38700 26100 38700
R112 98 97 9.257468e-04k $ 5 24500 38700 26100 38700
R113 99 98 8.678876e-04k $ 5 23000 38700 24500 38700
R114 100 99 2.082930e-03k $ 5 19400 38700 23000 38700
R115 101 100 5.207326e-04k $ 5 18500 38700 19400 38700
R116 102 101 3.240114e-03k $ 5 12900 38700 18500 38700
R117 103 102 5.785918e-05k $ 5 12800 38700 12900 38700
R118 104 103 2.082930e-03k $ 5 9200 38700 12800 38700
R119 105 104 4.628734e-04k $ 5 8400 38700 9200 38700
R120 547 105 1.793634e-03k $ 5 5300 38700 8400 38700
R121 106 547 1.000000e-06k $ 5 5300 38700 5300 38700
R122 107 106 6.364510e-04k $ 5 4200 38700 5300 38700
R123 692 727 2.230471e-03k $ src node: 46900 35100 50755 35100
R124 108 692 1.735775e-04k $ 5 46600 35100 46900 35100
R125 109 108 1.562198e-03k $ 5 43900 35100 46600 35100
R126 110 109 2.025071e-03k $ 5 40400 35100 43900 35100
R127 111 110 3.471551e-04k $ 5 39800 35100 40400 35100
R128 112 111 5.785918e-05k $ 5 39700 35100 39800 35100
R129 113 112 5.207326e-04k $ 5 38800 35100 39700 35100
R130 114 113 1.000000e-06k $ 5 38800 35100 38800 35100
R131 115 114 6.364509e-04k $ 5 37700 35100 38800 35100
R132 116 115 1.157184e-04k $ 5 37500 35100 37700 35100
R133 117 116 6.364509e-04k $ 5 36400 35100 37500 35100
R134 118 117 1.157184e-04k $ 5 36200 35100 36400 35100
R135 119 118 4.628734e-04k $ 5 35400 35100 36200 35100
R136 120 119 1.000000e-06k $ 5 35400 35100 35400 35100
R137 121 120 3.471551e-04k $ 5 34800 35100 35400 35100
R138 122 121 1.157184e-04k $ 5 34600 35100 34800 35100
R139 123 122 4.628734e-04k $ 5 33800 35100 34600 35100
R140 124 123 1.157184e-04k $ 5 33600 35100 33800 35100
R141 125 124 4.628734e-04k $ 5 32800 35100 33600 35100
R142 126 125 5.785918e-05k $ 5 32700 35100 32800 35100
R143 127 126 4.628734e-04k $ 5 31900 35100 32700 35100
R144 128 127 6.943101e-04k $ 5 30700 35100 31900 35100
R145 129 128 7.521693e-04k $ 5 29400 35100 30700 35100
R146 617 129 1.909353e-03k $ 5 26100 35100 29400 35100
R147 130 617 1.000000e-06k $ 5 26100 35100 26100 35100
R148 131 130 1.562198e-03k $ 5 23400 35100 26100 35100
R149 132 131 4.628734e-04k $ 5 22600 35100 23400 35100
R150 133 132 6.943101e-04k $ 5 21400 35100 22600 35100
R151 134 133 5.785918e-04k $ 5 20400 35100 21400 35100
R152 135 134 1.099324e-03k $ 5 18500 35100 20400 35100
R153 136 135 8.678876e-04k $ 5 17000 35100 18500 35100
R154 137 136 2.082930e-03k $ 5 13400 35100 17000 35100
R155 138 137 9.836060e-04k $ 5 11700 35100 13400 35100
R156 139 138 4.628734e-04k $ 5 10900 35100 11700 35100
R157 542 139 3.240114e-03k $ 5 5300 35100 10900 35100
R158 140 542 1.000000e-06k $ 5 5300 35100 5300 35100
R159 141 140 1.000000e-06k $ 5 5300 35100 5300 35100
R160 142 141 1.330761e-03k $ 5 3000 35100 5300 35100
R161 143 142 8.100285e-04k $ 5 1600 35100 3000 35100
R162 144 143 1.000000e-06k $ 5 1600 35100 1600 35100
R163 145 728 1.015429e-03k $ src node: 49000 31500 50755 31500
R164 687 145 1.215043e-03k $ 5 46900 31500 49000 31500
R165 146 687 1.000000e-06k $ 5 46900 31500 46900 31500
R166 147 146 1.000000e-06k $ 5 46900 31500 46900 31500
R167 148 147 6.943101e-04k $ 5 45700 31500 46900 31500
R168 149 148 6.943101e-04k $ 5 44500 31500 45700 31500
R169 150 149 6.943101e-04k $ 5 43300 31500 44500 31500
R170 151 150 5.785918e-05k $ 5 43200 31500 43300 31500
R171 152 151 4.628734e-04k $ 5 42400 31500 43200 31500
R172 153 152 1.735775e-04k $ 5 42100 31500 42400 31500
R173 154 153 4.050142e-04k $ 5 41400 31500 42100 31500
R174 155 154 2.892959e-04k $ 5 40900 31500 41400 31500
R175 156 155 5.785918e-04k $ 5 39900 31500 40900 31500
R176 157 156 5.785918e-05k $ 5 39800 31500 39900 31500
R177 158 157 5.785918e-04k $ 5 38800 31500 39800 31500
R178 159 158 1.000000e-06k $ 5 38800 31500 38800 31500
R179 160 159 6.364509e-04k $ 5 37700 31500 38800 31500
R180 161 160 5.207326e-04k $ 5 36800 31500 37700 31500
R181 162 161 5.207326e-04k $ 5 35900 31500 36800 31500
R182 163 162 1.000000e-06k $ 5 35900 31500 35900 31500
R183 164 163 5.207326e-04k $ 5 35000 31500 35900 31500
R184 165 164 9.836060e-04k $ 5 33300 31500 35000 31500
R185 166 165 5.785918e-05k $ 5 33200 31500 33300 31500
R186 167 166 7.521693e-04k $ 5 31900 31500 33200 31500
R187 168 167 6.943101e-04k $ 5 30700 31500 31900 31500
R188 169 168 1.000000e-06k $ 5 30700 31500 30700 31500
R189 170 169 5.207326e-04k $ 5 29800 31500 30700 31500
R190 171 170 1.157184e-04k $ 5 29600 31500 29800 31500
R191 172 171 2.314367e-04k $ 5 29200 31500 29600 31500
R192 173 172 3.471551e-04k $ 5 28600 31500 29200 31500
R193 174 173 1.000000e-06k $ 5 28600 31500 28600 31500
R194 175 174 5.207326e-04k $ 5 27700 31500 28600 31500
R195 176 175 1.157184e-04k $ 5 27500 31500 27700 31500
R196 612 176 8.100285e-04k $ 5 26100 31500 27500 31500
R197 177 612 1.000000e-06k $ 5 26100 31500 26100 31500
R198 178 177 6.943101e-04k $ 5 24900 31500 26100 31500
R199 179 178 5.785918e-05k $ 5 24800 31500 24900 31500
R200 180 179 6.364509e-04k $ 5 23700 31500 24800 31500
R201 181 180 6.943101e-04k $ 5 22500 31500 23700 31500
R202 182 181 1.157184e-04k $ 5 22300 31500 22500 31500
R203 183 182 5.785918e-04k $ 5 21300 31500 22300 31500
R204 184 183 2.892959e-04k $ 5 20800 31500 21300 31500
R205 185 184 1.735775e-03k $ 5 17800 31500 20800 31500
R206 186 185 7.521693e-04k $ 5 16500 31500 17800 31500
R207 187 186 1.330761e-03k $ 5 14200 31500 16500 31500
R208 188 187 1.041465e-03k $ 5 12400 31500 14200 31500
R209 189 188 8.100285e-04k $ 5 11000 31500 12400 31500
R210 190 189 2.314367e-04k $ 5 10600 31500 11000 31500
R211 191 190 2.198649e-03k $ 5 6800 31500 10600 31500
R212 537 191 8.678876e-04k $ 5 5300 31500 6800 31500
R213 192 537 1.000000e-06k $ 5 5300 31500 5300 31500
R214 193 192 5.207326e-04k $ 5 4400 31500 5300 31500
R215 194 193 8.100285e-04k $ 5 3000 31500 4400 31500
R216 195 194 1.000000e-06k $ 5 3000 31500 3000 31500
R217 196 195 8.100285e-04k $ 5 1600 31500 3000 31500
R218 197 196 1.000000e-06k $ 5 1600 31500 1600 31500
R219 198 729 1.246865e-03k $ src node: 48600 27900 50755 27900
R220 682 198 9.836060e-04k $ 5 46900 27900 48600 27900
R221 199 682 1.000000e-06k $ 5 46900 27900 46900 27900
R222 200 199 8.678876e-04k $ 5 45400 27900 46900 27900
R223 201 200 5.207326e-04k $ 5 44500 27900 45400 27900
R224 202 201 7.521693e-04k $ 5 43200 27900 44500 27900
R225 203 202 6.943101e-04k $ 5 42000 27900 43200 27900
R226 204 203 4.628734e-04k $ 5 41200 27900 42000 27900
R227 205 204 2.314367e-04k $ 5 40800 27900 41200 27900
R228 206 205 1.099324e-03k $ 5 38900 27900 40800 27900
R229 207 206 5.207326e-04k $ 5 38000 27900 38900 27900
R230 208 207 2.892959e-04k $ 5 37500 27900 38000 27900
R231 209 208 6.364509e-04k $ 5 36400 27900 37500 27900
R232 210 209 5.207326e-04k $ 5 35500 27900 36400 27900
R233 211 210 1.000000e-06k $ 5 35500 27900 35500 27900
R234 212 211 4.628734e-04k $ 5 34700 27900 35500 27900
R235 213 212 5.785918e-04k $ 5 33700 27900 34700 27900
R236 214 213 5.785918e-04k $ 5 32700 27900 33700 27900
R237 215 214 2.892959e-04k $ 5 32200 27900 32700 27900
R238 216 215 1.735775e-04k $ 5 31900 27900 32200 27900
R239 217 216 3.471551e-04k $ 5 31300 27900 31900 27900
R240 218 217 2.892959e-04k $ 5 30800 27900 31300 27900
R241 219 218 2.892959e-04k $ 5 30300 27900 30800 27900
R242 220 219 4.050142e-04k $ 5 29600 27900 30300 27900
R243 221 220 5.785918e-04k $ 5 28600 27900 29600 27900
R244 222 221 6.364509e-04k $ 5 27500 27900 28600 27900
R245 607 222 8.100285e-04k $ 5 26100 27900 27500 27900
R246 223 607 1.000000e-06k $ 5 26100 27900 26100 27900
R247 224 223 1.000000e-06k $ 5 26100 27900 26100 27900
R248 225 224 4.628734e-04k $ 5 25300 27900 26100 27900
R249 226 225 7.521693e-04k $ 5 24000 27900 25300 27900
R250 227 226 5.785918e-04k $ 5 23000 27900 24000 27900
R251 228 227 1.000000e-06k $ 5 23000 27900 23000 27900
R252 229 228 6.364509e-04k $ 5 21900 27900 23000 27900
R253 230 229 5.785918e-05k $ 5 21800 27900 21900 27900
R254 231 230 9.257468e-04k $ 5 20200 27900 21800 27900
R255 232 231 8.678876e-04k $ 5 18700 27900 20200 27900
R256 233 232 8.100285e-04k $ 5 17300 27900 18700 27900
R257 234 233 2.892959e-04k $ 5 16800 27900 17300 27900
R258 235 234 5.785918e-04k $ 5 15800 27900 16800 27900
R259 236 235 2.314367e-04k $ 5 15400 27900 15800 27900
R260 237 236 1.215043e-03k $ 5 13300 27900 15400 27900
R261 238 237 3.471551e-04k $ 5 12700 27900 13300 27900
R262 239 238 1.157184e-03k $ 5 10700 27900 12700 27900
R263 240 239 3.471551e-04k $ 5 10100 27900 10700 27900
R264 241 240 2.892959e-04k $ 5 9600 27900 10100 27900
R265 242 241 9.257468e-04k $ 5 8000 27900 9600 27900
R266 243 242 8.100285e-04k $ 5 6600 27900 8000 27900
R267 532 243 7.521693e-04k $ 5 5300 27900 6600 27900
R268 244 532 1.000000e-06k $ 5 5300 27900 5300 27900
R269 245 244 1.330761e-03k $ 5 3000 27900 5300 27900
R270 246 245 1.157184e-04k $ 5 2800 27900 3000 27900
R271 247 246 6.943101e-04k $ 5 1600 27900 2800 27900
R272 248 730 1.015429e-03k $ src node: 49000 24300 50755 24300
R273 677 248 1.215043e-03k $ 5 46900 24300 49000 24300
R274 249 677 3.471551e-04k $ 5 46300 24300 46900 24300
R275 250 249 6.364509e-04k $ 5 45200 24300 46300 24300
R276 251 250 1.909353e-03k $ 5 41900 24300 45200 24300
R277 252 251 6.364509e-04k $ 5 40800 24300 41900 24300
R278 253 252 2.892959e-04k $ 5 40300 24300 40800 24300
R279 254 253 6.364509e-04k $ 5 39200 24300 40300 24300
R280 255 254 9.836060e-04k $ 5 37500 24300 39200 24300
R281 256 255 1.157184e-04k $ 5 37300 24300 37500 24300
R282 257 256 2.892959e-04k $ 5 36800 24300 37300 24300
R283 258 257 4.050142e-04k $ 5 36100 24300 36800 24300
R284 259 258 1.157184e-04k $ 5 35900 24300 36100 24300
R285 260 259 4.050142e-04k $ 5 35200 24300 35900 24300
R286 261 260 1.157184e-04k $ 5 35000 24300 35200 24300
R287 262 261 2.892959e-04k $ 5 34500 24300 35000 24300
R288 263 262 4.050142e-04k $ 5 33800 24300 34500 24300
R289 264 263 1.157184e-04k $ 5 33600 24300 33800 24300
R290 265 264 2.892959e-04k $ 5 33100 24300 33600 24300
R291 266 265 1.157184e-04k $ 5 32900 24300 33100 24300
R292 267 266 3.471551e-04k $ 5 32300 24300 32900 24300
R293 268 267 1.735775e-04k $ 5 32000 24300 32300 24300
R294 269 268 4.050142e-04k $ 5 31300 24300 32000 24300
R295 270 269 8.678876e-04k $ 5 29800 24300 31300 24300
R296 602 270 2.140790e-03k $ 5 26100 24300 29800 24300
R297 271 602 1.000000e-06k $ 5 26100 24300 26100 24300
R298 272 271 1.000000e-06k $ 5 26100 24300 26100 24300
R299 273 272 1.272902e-03k $ 5 23900 24300 26100 24300
R300 274 273 1.735775e-04k $ 5 23600 24300 23900 24300
R301 275 274 5.207326e-04k $ 5 22700 24300 23600 24300
R302 276 275 2.892959e-04k $ 5 22200 24300 22700 24300
R303 277 276 4.050142e-04k $ 5 21500 24300 22200 24300
R304 278 277 1.677916e-03k $ 5 18600 24300 21500 24300
R305 279 278 1.157184e-03k $ 5 16600 24300 18600 24300
R306 280 279 2.025071e-03k $ 5 13100 24300 16600 24300
R307 281 280 5.207326e-04k $ 5 12200 24300 13100 24300
R308 282 281 2.314367e-04k $ 5 11800 24300 12200 24300
R309 283 282 8.100285e-04k $ 5 10400 24300 11800 24300
R310 284 283 1.000000e-06k $ 5 10400 24300 10400 24300
R311 285 284 7.521693e-04k $ 5 9100 24300 10400 24300
R312 286 285 1.735775e-04k $ 5 8800 24300 9100 24300
R313 287 286 8.100285e-04k $ 5 7400 24300 8800 24300
R314 527 287 1.215043e-03k $ 5 5300 24300 7400 24300
R315 288 527 1.000000e-06k $ 5 5300 24300 5300 24300
R316 289 288 1.000000e-06k $ 5 5300 24300 5300 24300
R317 290 289 5.207326e-04k $ 5 4400 24300 5300 24300
R318 291 290 8.100285e-04k $ 5 3000 24300 4400 24300
R319 292 291 4.628734e-04k $ 5 2200 24300 3000 24300
R320 293 292 3.471551e-04k $ 5 1600 24300 2200 24300
R321 294 731 8.997102e-04k $ src node: 49200 20700 50755 20700
R322 295 294 1.000000e-06k $ 5 49200 20700 49200 20700
R323 672 295 1.330761e-03k $ 5 46900 20700 49200 20700
R324 296 672 9.836060e-04k $ 5 45200 20700 46900 20700
R325 297 296 2.892959e-04k $ 5 44700 20700 45200 20700
R326 298 297 1.735775e-03k $ 5 41700 20700 44700 20700
R327 299 298 4.050142e-04k $ 5 41000 20700 41700 20700
R328 300 299 1.157184e-04k $ 5 40800 20700 41000 20700
R329 301 300 2.314367e-04k $ 5 40400 20700 40800 20700
R330 302 301 2.314367e-04k $ 5 40000 20700 40400 20700
R331 303 302 4.628734e-04k $ 5 39200 20700 40000 20700
R332 304 303 1.000000e-06k $ 5 39200 20700 39200 20700
R333 305 304 9.836060e-04k $ 5 37500 20700 39200 20700
R334 306 305 5.785918e-05k $ 5 37400 20700 37500 20700
R335 307 306 5.785918e-04k $ 5 36400 20700 37400 20700
R336 308 307 3.471551e-04k $ 5 35800 20700 36400 20700
R337 309 308 3.471551e-04k $ 5 35200 20700 35800 20700
R338 310 309 4.628734e-04k $ 5 34400 20700 35200 20700
R339 311 310 1.157184e-04k $ 5 34200 20700 34400 20700
R340 312 311 5.207326e-04k $ 5 33300 20700 34200 20700
R341 313 312 4.628734e-04k $ 5 32500 20700 33300 20700
R342 314 313 1.157184e-04k $ 5 32300 20700 32500 20700
R343 315 314 5.207326e-04k $ 5 31400 20700 32300 20700
R344 316 315 1.735775e-04k $ 5 31100 20700 31400 20700
R345 317 316 4.050142e-04k $ 5 30400 20700 31100 20700
R346 318 317 1.735775e-04k $ 5 30100 20700 30400 20700
R347 319 318 4.050142e-04k $ 5 29400 20700 30100 20700
R348 597 319 1.909353e-03k $ 5 26100 20700 29400 20700
R349 320 597 1.000000e-06k $ 5 26100 20700 26100 20700
R350 321 320 1.735775e-04k $ 5 25800 20700 26100 20700
R351 322 321 1.735775e-03k $ 5 22800 20700 25800 20700
R352 323 322 1.157184e-04k $ 5 22600 20700 22800 20700
R353 324 323 5.207326e-04k $ 5 21700 20700 22600 20700
R354 325 324 6.364509e-04k $ 5 20600 20700 21700 20700
R355 326 325 8.678876e-04k $ 5 19100 20700 20600 20700
R356 327 326 1.099324e-03k $ 5 17200 20700 19100 20700
R357 328 327 5.207326e-04k $ 5 16300 20700 17200 20700
R358 329 328 2.140790e-03k $ 5 12600 20700 16300 20700
R359 330 329 2.314367e-03k $ 5 8600 20700 12600 20700
R360 522 330 1.909353e-03k $ 5 5300 20700 8600 20700
R361 331 522 1.000000e-06k $ 5 5300 20700 5300 20700
R362 332 331 1.000000e-06k $ 5 5300 20700 5300 20700
R363 333 332 1.793634e-03k $ 5 2200 20700 5300 20700
R364 334 333 3.471551e-04k $ 5 1600 20700 2200 20700
R365 335 334 2.314367e-04k $ 5 1200 20700 1600 20700
R366 336 732 8.997102e-04k $ src node: 49200 17100 50755 17100
R367 337 336 8.100285e-04k $ 5 47800 17100 49200 17100
R368 667 337 5.207326e-04k $ 5 46900 17100 47800 17100
R369 338 667 1.000000e-06k $ 5 46900 17100 46900 17100
R370 339 338 2.140790e-03k $ 5 43200 17100 46900 17100
R371 340 339 1.272902e-03k $ 5 41000 17100 43200 17100
R372 341 340 1.562198e-03k $ 5 38300 17100 41000 17100
R373 342 341 5.207326e-04k $ 5 37400 17100 38300 17100
R374 343 342 1.504339e-03k $ 5 34800 17100 37400 17100
R375 344 343 1.157184e-04k $ 5 34600 17100 34800 17100
R376 345 344 1.041465e-03k $ 5 32800 17100 34600 17100
R377 346 345 6.943101e-04k $ 5 31600 17100 32800 17100
R378 347 346 5.785918e-04k $ 5 30600 17100 31600 17100
R379 348 347 1.272902e-03k $ 5 28400 17100 30600 17100
R380 349 348 9.257468e-04k $ 5 26800 17100 28400 17100
R381 592 349 4.050142e-04k $ 5 26100 17100 26800 17100
R382 350 592 1.000000e-06k $ 5 26100 17100 26100 17100
R383 351 350 4.050142e-04k $ 5 25400 17100 26100 17100
R384 352 351 6.943101e-04k $ 5 24200 17100 25400 17100
R385 353 352 6.364509e-04k $ 5 23100 17100 24200 17100
R386 354 353 2.892959e-04k $ 5 22600 17100 23100 17100
R387 355 354 3.471551e-04k $ 5 22000 17100 22600 17100
R388 356 355 1.967212e-03k $ 5 18600 17100 22000 17100
R389 357 356 5.785918e-05k $ 5 18500 17100 18600 17100
R390 358 357 6.364509e-04k $ 5 17400 17100 18500 17100
R391 359 358 6.943101e-04k $ 5 16200 17100 17400 17100
R392 360 359 6.943101e-04k $ 5 15000 17100 16200 17100
R393 361 360 1.272902e-03k $ 5 12800 17100 15000 17100
R394 362 361 8.100285e-04k $ 5 11400 17100 12800 17100
R395 363 362 1.388620e-03k $ 5 9000 17100 11400 17100
R396 364 363 6.943101e-04k $ 5 7800 17100 9000 17100
R397 365 364 1.157184e-04k $ 5 7600 17100 7800 17100
R398 517 365 1.330761e-03k $ 5 5300 17100 7600 17100
R399 366 517 1.157184e-04k $ 5 5100 17100 5300 17100
R400 367 366 5.207326e-04k $ 5 4200 17100 5100 17100
R401 368 367 1.504339e-03k $ 5 1600 17100 4200 17100
R402 662 733 2.230471e-03k $ src node: 46900 13500 50755 13500
R403 369 662 1.000000e-06k $ 5 46900 13500 46900 13500
R404 370 369 1.000000e-06k $ 5 46900 13500 46900 13500
R405 371 370 4.050142e-04k $ 5 46200 13500 46900 13500
R406 372 371 5.207326e-04k $ 5 45300 13500 46200 13500
R407 373 372 6.943101e-04k $ 5 44100 13500 45300 13500
R408 374 373 3.471551e-04k $ 5 43500 13500 44100 13500
R409 375 374 4.628734e-04k $ 5 42700 13500 43500 13500
R410 376 375 2.314367e-04k $ 5 42300 13500 42700 13500
R411 377 376 6.943101e-04k $ 5 41100 13500 42300 13500
R412 378 377 6.943101e-04k $ 5 39900 13500 41100 13500
R413 379 378 5.207326e-04k $ 5 39000 13500 39900 13500
R414 380 379 1.735775e-04k $ 5 38700 13500 39000 13500
R415 381 380 1.735775e-04k $ 5 38400 13500 38700 13500
R416 382 381 4.050142e-04k $ 5 37700 13500 38400 13500
R417 383 382 1.388620e-03k $ 5 35300 13500 37700 13500
R418 384 383 1.215043e-03k $ 5 33200 13500 35300 13500
R419 385 384 5.785918e-04k $ 5 32200 13500 33200 13500
R420 386 385 6.943101e-04k $ 5 31000 13500 32200 13500
R421 587 386 2.835100e-03k $ 5 26100 13500 31000 13500
R422 387 587 1.000000e-06k $ 5 26100 13500 26100 13500
R423 388 387 4.050142e-04k $ 5 25400 13500 26100 13500
R424 389 388 1.330761e-03k $ 5 23100 13500 25400 13500
R425 390 389 2.140790e-03k $ 5 19400 13500 23100 13500
R426 391 390 3.471551e-04k $ 5 18800 13500 19400 13500
R427 392 391 1.677916e-03k $ 5 15900 13500 18800 13500
R428 393 392 6.943101e-04k $ 5 14700 13500 15900 13500
R429 394 393 5.785918e-05k $ 5 14600 13500 14700 13500
R430 395 394 1.967212e-03k $ 5 11200 13500 14600 13500
R431 396 395 1.157184e-04k $ 5 11000 13500 11200 13500
R432 512 396 3.297973e-03k $ 5 5300 13500 11000 13500
R433 397 512 5.785918e-05k $ 5 5200 13500 5300 13500
R434 398 397 1.000000e-06k $ 5 5200 13500 5200 13500
R435 399 398 2.082930e-03k $ 5 1600 13500 5200 13500
R436 400 399 1.000000e-06k $ 5 1600 13500 1600 13500
R437 657 734 2.230471e-03k $ src node: 46900 9900 50755 9900
R438 401 657 1.000000e-06k $ 5 46900 9900 46900 9900
R439 402 401 2.025071e-03k $ 5 43400 9900 46900 9900
R440 403 402 1.388620e-03k $ 5 41000 9900 43400 9900
R441 404 403 9.257468e-04k $ 5 39400 9900 41000 9900
R442 405 404 5.785918e-04k $ 5 38400 9900 39400 9900
R443 406 405 1.967212e-03k $ 5 35000 9900 38400 9900
R444 407 406 8.100285e-04k $ 5 33600 9900 35000 9900
R445 408 407 1.504339e-03k $ 5 31000 9900 33600 9900
R446 582 408 2.835100e-03k $ 5 26100 9900 31000 9900
R447 409 582 1.000000e-06k $ 5 26100 9900 26100 9900
R448 410 409 1.000000e-06k $ 5 26100 9900 26100 9900
R449 411 410 1.793634e-03k $ 5 23000 9900 26100 9900
R450 412 411 5.785918e-04k $ 5 22000 9900 23000 9900
R451 413 412 1.504339e-03k $ 5 19400 9900 22000 9900
R452 414 413 5.207326e-04k $ 5 18500 9900 19400 9900
R453 415 414 6.943101e-04k $ 5 17300 9900 18500 9900
R454 416 415 7.521693e-04k $ 5 16000 9900 17300 9900
R455 417 416 1.157184e-04k $ 5 15800 9900 16000 9900
R456 418 417 7.521693e-04k $ 5 14500 9900 15800 9900
R457 419 418 1.041465e-03k $ 5 12700 9900 14500 9900
R458 420 419 1.157184e-04k $ 5 12500 9900 12700 9900
R459 421 420 6.943101e-04k $ 5 11300 9900 12500 9900
R460 422 421 5.785918e-05k $ 5 11200 9900 11300 9900
R461 423 422 7.521693e-04k $ 5 9900 9900 11200 9900
R462 507 423 2.661522e-03k $ 5 5300 9900 9900 9900
R463 424 507 1.000000e-06k $ 5 5300 9900 5300 9900
R464 425 424 5.785918e-05k $ 5 5200 9900 5300 9900
R465 426 425 1.967212e-03k $ 5 1800 9900 5200 9900
R466 427 426 1.157184e-04k $ 5 1600 9900 1800 9900
R467 428 427 2.314367e-04k $ 5 1200 9900 1600 9900
R468 429 735 6.682735e-04k $ src node: 49600 6300 50755 6300
R469 652 429 1.562198e-03k $ 5 46900 6300 49600 6300
R470 430 652 1.735775e-04k $ 5 46600 6300 46900 6300
R471 431 430 3.471551e-04k $ 5 46000 6300 46600 6300
R472 432 431 3.702987e-03k $ 5 39600 6300 46000 6300
R473 433 432 4.628734e-04k $ 5 38800 6300 39600 6300
R474 434 433 1.157184e-04k $ 5 38600 6300 38800 6300
R475 435 434 2.082930e-03k $ 5 35000 6300 38600 6300
R476 436 435 1.735775e-04k $ 5 34700 6300 35000 6300
R477 437 436 1.272902e-03k $ 5 32500 6300 34700 6300
R478 438 437 9.836060e-04k $ 5 30800 6300 32500 6300
R479 439 438 1.157184e-04k $ 5 30600 6300 30800 6300
R480 577 439 2.603663e-03k $ 5 26100 6300 30600 6300
R481 440 577 1.000000e-06k $ 5 26100 6300 26100 6300
R482 441 440 7.521693e-04k $ 5 24800 6300 26100 6300
R483 442 441 8.100285e-04k $ 5 23400 6300 24800 6300
R484 443 442 1.272902e-03k $ 5 21200 6300 23400 6300
R485 444 443 1.041465e-03k $ 5 19400 6300 21200 6300
R486 445 444 5.785918e-04k $ 5 18400 6300 19400 6300
R487 446 445 4.628734e-04k $ 5 17600 6300 18400 6300
R488 447 446 1.157184e-04k $ 5 17400 6300 17600 6300
R489 448 447 9.257468e-04k $ 5 15800 6300 17400 6300
R490 449 448 9.257468e-04k $ 5 14200 6300 15800 6300
R491 450 449 1.041465e-03k $ 5 12400 6300 14200 6300
R492 451 450 1.157184e-04k $ 5 12200 6300 12400 6300
R493 452 451 5.785918e-04k $ 5 11200 6300 12200 6300
R494 453 452 3.471551e-04k $ 5 10600 6300 11200 6300
R495 454 453 5.785918e-04k $ 5 9600 6300 10600 6300
R496 455 454 6.943101e-04k $ 5 8400 6300 9600 6300
R497 502 455 1.793634e-03k $ 5 5300 6300 8400 6300
R498 456 502 1.000000e-06k $ 5 5300 6300 5300 6300
R499 457 456 8.678877e-04k $ 5 3800 6300 5300 6300
R500 458 736 1.015429e-03k $ src node: 49000 2700 50755 2700
R501 647 458 1.215043e-03k $ 5 46900 2700 49000 2700
R502 459 647 1.000000e-06k $ 5 46900 2700 46900 2700
R503 460 459 3.471551e-04k $ 5 46300 2700 46900 2700
R504 461 460 2.892959e-04k $ 5 45800 2700 46300 2700
R505 462 461 1.157184e-04k $ 5 45600 2700 45800 2700
R506 463 462 4.050142e-04k $ 5 44900 2700 45600 2700
R507 464 463 3.471551e-04k $ 5 44300 2700 44900 2700
R508 465 464 1.562198e-03k $ 5 41600 2700 44300 2700
R509 466 465 2.025071e-03k $ 5 38100 2700 41600 2700
R510 467 466 1.446479e-03k $ 5 35600 2700 38100 2700
R511 468 467 2.545804e-03k $ 5 31200 2700 35600 2700
R512 469 468 5.785918e-05k $ 5 31100 2700 31200 2700
R513 470 469 1.157184e-03k $ 5 29100 2700 31100 2700
R514 572 470 1.735775e-03k $ 5 26100 2700 29100 2700
R515 471 572 4.050142e-04k $ 5 25400 2700 26100 2700
R516 472 471 2.314367e-04k $ 5 25000 2700 25400 2700
R517 473 472 8.100285e-04k $ 5 23600 2700 25000 2700
R518 474 473 9.257468e-04k $ 5 22000 2700 23600 2700
R519 475 474 1.388620e-03k $ 5 19600 2700 22000 2700
R520 476 475 1.793634e-03k $ 5 16500 2700 19600 2700
R521 477 476 1.562198e-03k $ 5 13800 2700 16500 2700
R522 478 477 2.082930e-03k $ 5 10200 2700 13800 2700
R523 479 478 1.157184e-04k $ 5 10000 2700 10200 2700
R524 480 479 8.100285e-04k $ 5 8600 2700 10000 2700
R525 481 480 5.785918e-04k $ 5 7600 2700 8600 2700
R526 482 481 2.314367e-04k $ 5 7200 2700 7600 2700
R527 497 482 1.099324e-03k $ 5 5300 2700 7200 2700
R528 483 497 1.000000e-06k $ 5 5300 2700 5300 2700
R529 484 483 8.678877e-04k $ 5 3800 2700 5300 2700
R530 715 720 4.646607e-04k $ 13 46900 49500 46900 53100
R531 710 715 4.646607e-04k $ 13 46900 45900 46900 49500
R532 705 710 4.646607e-04k $ 13 46900 42300 46900 45900
R533 496 705 2.362025e-04k $ 13 46900 40470 46900 42300
R534 700 496 2.284582e-04k $ 13 46900 38700 46900 40470
R535 695 700 4.646607e-04k $ 13 46900 35100 46900 38700
R536 690 695 4.646607e-04k $ 13 46900 31500 46900 35100
R537 685 690 4.646607e-04k $ 13 46900 27900 46900 31500
R538 680 685 4.646607e-04k $ 13 46900 24300 46900 27900
R539 675 680 4.646607e-04k $ 13 46900 20700 46900 24300
R540 670 675 4.646607e-04k $ 13 46900 17100 46900 20700
R541 490 670 3.136460e-04k $ 13 46900 14670 46900 17100
R542 665 490 1.510147e-04k $ 13 46900 13500 46900 14670
R543 660 665 4.646607e-04k $ 13 46900 9900 46900 13500
R544 655 660 4.646607e-04k $ 13 46900 6300 46900 9900
R545 650 655 4.646607e-04k $ 13 46900 2700 46900 6300
R546 640 645 4.646607e-04k $ 13 26100 49500 26100 53100
R547 635 640 4.646607e-04k $ 13 26100 45900 26100 49500
R548 630 635 4.646607e-04k $ 13 26100 42300 26100 45900
R549 494 630 2.362025e-04k $ 13 26100 40470 26100 42300
R550 625 494 2.284582e-04k $ 13 26100 38700 26100 40470
R551 620 625 4.646607e-04k $ 13 26100 35100 26100 38700
R552 615 620 4.646607e-04k $ 13 26100 31500 26100 35100
R553 610 615 4.646607e-04k $ 13 26100 27900 26100 31500
R554 605 610 4.646607e-04k $ 13 26100 24300 26100 27900
R555 600 605 4.646607e-04k $ 13 26100 20700 26100 24300
R556 595 600 4.646607e-04k $ 13 26100 17100 26100 20700
R557 488 595 3.136460e-04k $ 13 26100 14670 26100 17100
R558 590 488 1.510147e-04k $ 13 26100 13500 26100 14670
R559 585 590 4.646607e-04k $ 13 26100 9900 26100 13500
R560 580 585 4.646607e-04k $ 13 26100 6300 26100 9900
R561 575 580 4.646607e-04k $ 13 26100 2700 26100 6300
R562 565 570 4.646607e-04k $ 13 5300 49500 5300 53100
R563 560 565 4.646607e-04k $ 13 5300 45900 5300 49500
R564 555 560 4.646607e-04k $ 13 5300 42300 5300 45900
R565 492 555 2.362025e-04k $ 13 5300 40470 5300 42300
R566 550 492 2.284582e-04k $ 13 5300 38700 5300 40470
R567 545 550 4.646607e-04k $ 13 5300 35100 5300 38700
R568 540 545 4.646607e-04k $ 13 5300 31500 5300 35100
R569 535 540 4.646607e-04k $ 13 5300 27900 5300 31500
R570 530 535 4.646607e-04k $ 13 5300 24300 5300 27900
R571 525 530 4.646607e-04k $ 13 5300 20700 5300 24300
R572 520 525 4.646607e-04k $ 13 5300 17100 5300 20700
R573 486 520 3.136460e-04k $ 13 5300 14670 5300 17100
R574 515 486 1.510147e-04k $ 13 5300 13500 5300 14670
R575 510 515 4.646607e-04k $ 13 5300 9900 5300 13500
R576 505 510 4.646607e-04k $ 13 5300 6300 5300 9900
R577 500 505 4.646607e-04k $ 13 5300 2700 5300 6300
R578 493 495 3.300684e-04k $ 15 26100 40470 46900 40470
R579 491 493 3.300684e-04k $ 15 5300 40470 26100 40470
R580 487 489 3.300684e-04k $ 15 26100 14670 46900 14670
R581 485 487 3.300684e-04k $ 15 5300 14670 26100 14670
R582 486 485 1.550000e-04k $ 14 5300 14670 5300 14670
R583 488 487 1.550000e-04k $ 14 26100 14670 26100 14670
R584 490 489 1.550000e-04k $ 14 46900 14670 46900 14670
R585 492 491 1.550000e-04k $ 14 5300 40470 5300 40470
R586 494 493 1.550000e-04k $ 14 26100 40470 26100 40470
R587 496 495 1.550000e-04k $ 14 46900 40470 46900 40470
R588 497 498 5.500000e-04k $ 6 5300 2700 5300 2700
R589 498 499 5.500000e-04k $ 8 5300 2700 5300 2700
R590 499 501 5.500000e-04k $ 10 5300 2700 5300 2700
R591 501 500 2.750000e-04k $ 12 5300 2700 5300 2700
R592 502 503 5.500000e-04k $ 6 5300 6300 5300 6300
R593 503 504 5.500000e-04k $ 8 5300 6300 5300 6300
R594 504 506 5.500000e-04k $ 10 5300 6300 5300 6300
R595 506 505 2.750000e-04k $ 12 5300 6300 5300 6300
R596 507 508 5.500000e-04k $ 6 5300 9900 5300 9900
R597 508 509 5.500000e-04k $ 8 5300 9900 5300 9900
R598 509 511 5.500000e-04k $ 10 5300 9900 5300 9900
R599 511 510 2.750000e-04k $ 12 5300 9900 5300 9900
R600 512 513 5.500000e-04k $ 6 5300 13500 5300 13500
R601 513 514 5.500000e-04k $ 8 5300 13500 5300 13500
R602 514 516 5.500000e-04k $ 10 5300 13500 5300 13500
R603 516 515 2.750000e-04k $ 12 5300 13500 5300 13500
R604 517 518 5.500000e-04k $ 6 5300 17100 5300 17100
R605 518 519 5.500000e-04k $ 8 5300 17100 5300 17100
R606 519 521 5.500000e-04k $ 10 5300 17100 5300 17100
R607 521 520 2.750000e-04k $ 12 5300 17100 5300 17100
R608 522 523 5.500000e-04k $ 6 5300 20700 5300 20700
R609 523 524 5.500000e-04k $ 8 5300 20700 5300 20700
R610 524 526 5.500000e-04k $ 10 5300 20700 5300 20700
R611 526 525 2.750000e-04k $ 12 5300 20700 5300 20700
R612 527 528 5.500000e-04k $ 6 5300 24300 5300 24300
R613 528 529 5.500000e-04k $ 8 5300 24300 5300 24300
R614 529 531 5.500000e-04k $ 10 5300 24300 5300 24300
R615 531 530 2.750000e-04k $ 12 5300 24300 5300 24300
R616 532 533 5.500000e-04k $ 6 5300 27900 5300 27900
R617 533 534 5.500000e-04k $ 8 5300 27900 5300 27900
R618 534 536 5.500000e-04k $ 10 5300 27900 5300 27900
R619 536 535 2.750000e-04k $ 12 5300 27900 5300 27900
R620 537 538 5.500000e-04k $ 6 5300 31500 5300 31500
R621 538 539 5.500000e-04k $ 8 5300 31500 5300 31500
R622 539 541 5.500000e-04k $ 10 5300 31500 5300 31500
R623 541 540 2.750000e-04k $ 12 5300 31500 5300 31500
R624 542 543 5.500000e-04k $ 6 5300 35100 5300 35100
R625 543 544 5.500000e-04k $ 8 5300 35100 5300 35100
R626 544 546 5.500000e-04k $ 10 5300 35100 5300 35100
R627 546 545 2.750000e-04k $ 12 5300 35100 5300 35100
R628 547 548 5.500000e-04k $ 6 5300 38700 5300 38700
R629 548 549 5.500000e-04k $ 8 5300 38700 5300 38700
R630 549 551 5.500000e-04k $ 10 5300 38700 5300 38700
R631 551 550 2.750000e-04k $ 12 5300 38700 5300 38700
R632 552 553 5.500000e-04k $ 6 5300 42300 5300 42300
R633 553 554 5.500000e-04k $ 8 5300 42300 5300 42300
R634 554 556 5.500000e-04k $ 10 5300 42300 5300 42300
R635 556 555 2.750000e-04k $ 12 5300 42300 5300 42300
R636 557 558 5.500000e-04k $ 6 5300 45900 5300 45900
R637 558 559 5.500000e-04k $ 8 5300 45900 5300 45900
R638 559 561 5.500000e-04k $ 10 5300 45900 5300 45900
R639 561 560 2.750000e-04k $ 12 5300 45900 5300 45900
R640 562 563 5.500000e-04k $ 6 5300 49500 5300 49500
R641 563 564 5.500000e-04k $ 8 5300 49500 5300 49500
R642 564 566 5.500000e-04k $ 10 5300 49500 5300 49500
R643 566 565 2.750000e-04k $ 12 5300 49500 5300 49500
R644 567 568 5.500000e-04k $ 6 5300 53100 5300 53100
R645 568 569 5.500000e-04k $ 8 5300 53100 5300 53100
R646 569 571 5.500000e-04k $ 10 5300 53100 5300 53100
R647 571 570 2.750000e-04k $ 12 5300 53100 5300 53100
R648 572 573 5.500000e-04k $ 6 26100 2700 26100 2700
R649 573 574 5.500000e-04k $ 8 26100 2700 26100 2700
R650 574 576 5.500000e-04k $ 10 26100 2700 26100 2700
R651 576 575 2.750000e-04k $ 12 26100 2700 26100 2700
R652 577 578 5.500000e-04k $ 6 26100 6300 26100 6300
R653 578 579 5.500000e-04k $ 8 26100 6300 26100 6300
R654 579 581 5.500000e-04k $ 10 26100 6300 26100 6300
R655 581 580 2.750000e-04k $ 12 26100 6300 26100 6300
R656 582 583 5.500000e-04k $ 6 26100 9900 26100 9900
R657 583 584 5.500000e-04k $ 8 26100 9900 26100 9900
R658 584 586 5.500000e-04k $ 10 26100 9900 26100 9900
R659 586 585 2.750000e-04k $ 12 26100 9900 26100 9900
R660 587 588 5.500000e-04k $ 6 26100 13500 26100 13500
R661 588 589 5.500000e-04k $ 8 26100 13500 26100 13500
R662 589 591 5.500000e-04k $ 10 26100 13500 26100 13500
R663 591 590 2.750000e-04k $ 12 26100 13500 26100 13500
R664 592 593 5.500000e-04k $ 6 26100 17100 26100 17100
R665 593 594 5.500000e-04k $ 8 26100 17100 26100 17100
R666 594 596 5.500000e-04k $ 10 26100 17100 26100 17100
R667 596 595 2.750000e-04k $ 12 26100 17100 26100 17100
R668 597 598 5.500000e-04k $ 6 26100 20700 26100 20700
R669 598 599 5.500000e-04k $ 8 26100 20700 26100 20700
R670 599 601 5.500000e-04k $ 10 26100 20700 26100 20700
R671 601 600 2.750000e-04k $ 12 26100 20700 26100 20700
R672 602 603 5.500000e-04k $ 6 26100 24300 26100 24300
R673 603 604 5.500000e-04k $ 8 26100 24300 26100 24300
R674 604 606 5.500000e-04k $ 10 26100 24300 26100 24300
R675 606 605 2.750000e-04k $ 12 26100 24300 26100 24300
R676 607 608 5.500000e-04k $ 6 26100 27900 26100 27900
R677 608 609 5.500000e-04k $ 8 26100 27900 26100 27900
R678 609 611 5.500000e-04k $ 10 26100 27900 26100 27900
R679 611 610 2.750000e-04k $ 12 26100 27900 26100 27900
R680 612 613 5.500000e-04k $ 6 26100 31500 26100 31500
R681 613 614 5.500000e-04k $ 8 26100 31500 26100 31500
R682 614 616 5.500000e-04k $ 10 26100 31500 26100 31500
R683 616 615 2.750000e-04k $ 12 26100 31500 26100 31500
R684 617 618 5.500000e-04k $ 6 26100 35100 26100 35100
R685 618 619 5.500000e-04k $ 8 26100 35100 26100 35100
R686 619 621 5.500000e-04k $ 10 26100 35100 26100 35100
R687 621 620 2.750000e-04k $ 12 26100 35100 26100 35100
R688 622 623 5.500000e-04k $ 6 26100 38700 26100 38700
R689 623 624 5.500000e-04k $ 8 26100 38700 26100 38700
R690 624 626 5.500000e-04k $ 10 26100 38700 26100 38700
R691 626 625 2.750000e-04k $ 12 26100 38700 26100 38700
R692 627 628 5.500000e-04k $ 6 26100 42300 26100 42300
R693 628 629 5.500000e-04k $ 8 26100 42300 26100 42300
R694 629 631 5.500000e-04k $ 10 26100 42300 26100 42300
R695 631 630 2.750000e-04k $ 12 26100 42300 26100 42300
R696 632 633 5.500000e-04k $ 6 26100 45900 26100 45900
R697 633 634 5.500000e-04k $ 8 26100 45900 26100 45900
R698 634 636 5.500000e-04k $ 10 26100 45900 26100 45900
R699 636 635 2.750000e-04k $ 12 26100 45900 26100 45900
R700 637 638 5.500000e-04k $ 6 26100 49500 26100 49500
R701 638 639 5.500000e-04k $ 8 26100 49500 26100 49500
R702 639 641 5.500000e-04k $ 10 26100 49500 26100 49500
R703 641 640 2.750000e-04k $ 12 26100 49500 26100 49500
R704 642 643 5.500000e-04k $ 6 26100 53100 26100 53100
R705 643 644 5.500000e-04k $ 8 26100 53100 26100 53100
R706 644 646 5.500000e-04k $ 10 26100 53100 26100 53100
R707 646 645 2.750000e-04k $ 12 26100 53100 26100 53100
R708 647 648 5.500000e-04k $ 6 46900 2700 46900 2700
R709 648 649 5.500000e-04k $ 8 46900 2700 46900 2700
R710 649 651 5.500000e-04k $ 10 46900 2700 46900 2700
R711 651 650 2.750000e-04k $ 12 46900 2700 46900 2700
R712 652 653 5.500000e-04k $ 6 46900 6300 46900 6300
R713 653 654 5.500000e-04k $ 8 46900 6300 46900 6300
R714 654 656 5.500000e-04k $ 10 46900 6300 46900 6300
R715 656 655 2.750000e-04k $ 12 46900 6300 46900 6300
R716 657 658 5.500000e-04k $ 6 46900 9900 46900 9900
R717 658 659 5.500000e-04k $ 8 46900 9900 46900 9900
R718 659 661 5.500000e-04k $ 10 46900 9900 46900 9900
R719 661 660 2.750000e-04k $ 12 46900 9900 46900 9900
R720 662 663 5.500000e-04k $ 6 46900 13500 46900 13500
R721 663 664 5.500000e-04k $ 8 46900 13500 46900 13500
R722 664 666 5.500000e-04k $ 10 46900 13500 46900 13500
R723 666 665 2.750000e-04k $ 12 46900 13500 46900 13500
R724 667 668 5.500000e-04k $ 6 46900 17100 46900 17100
R725 668 669 5.500000e-04k $ 8 46900 17100 46900 17100
R726 669 671 5.500000e-04k $ 10 46900 17100 46900 17100
R727 671 670 2.750000e-04k $ 12 46900 17100 46900 17100
R728 672 673 5.500000e-04k $ 6 46900 20700 46900 20700
R729 673 674 5.500000e-04k $ 8 46900 20700 46900 20700
R730 674 676 5.500000e-04k $ 10 46900 20700 46900 20700
R731 676 675 2.750000e-04k $ 12 46900 20700 46900 20700
R732 677 678 5.500000e-04k $ 6 46900 24300 46900 24300
R733 678 679 5.500000e-04k $ 8 46900 24300 46900 24300
R734 679 681 5.500000e-04k $ 10 46900 24300 46900 24300
R735 681 680 2.750000e-04k $ 12 46900 24300 46900 24300
R736 682 683 5.500000e-04k $ 6 46900 27900 46900 27900
R737 683 684 5.500000e-04k $ 8 46900 27900 46900 27900
R738 684 686 5.500000e-04k $ 10 46900 27900 46900 27900
R739 686 685 2.750000e-04k $ 12 46900 27900 46900 27900
R740 687 688 5.500000e-04k $ 6 46900 31500 46900 31500
R741 688 689 5.500000e-04k $ 8 46900 31500 46900 31500
R742 689 691 5.500000e-04k $ 10 46900 31500 46900 31500
R743 691 690 2.750000e-04k $ 12 46900 31500 46900 31500
R744 692 693 5.500000e-04k $ 6 46900 35100 46900 35100
R745 693 694 5.500000e-04k $ 8 46900 35100 46900 35100
R746 694 696 5.500000e-04k $ 10 46900 35100 46900 35100
R747 696 695 2.750000e-04k $ 12 46900 35100 46900 35100
R748 697 698 5.500000e-04k $ 6 46900 38700 46900 38700
R749 698 699 5.500000e-04k $ 8 46900 38700 46900 38700
R750 699 701 5.500000e-04k $ 10 46900 38700 46900 38700
R751 701 700 2.750000e-04k $ 12 46900 38700 46900 38700
R752 702 703 5.500000e-04k $ 6 46900 42300 46900 42300
R753 703 704 5.500000e-04k $ 8 46900 42300 46900 42300
R754 704 706 5.500000e-04k $ 10 46900 42300 46900 42300
R755 706 705 2.750000e-04k $ 12 46900 42300 46900 42300
R756 707 708 5.500000e-04k $ 6 46900 45900 46900 45900
R757 708 709 5.500000e-04k $ 8 46900 45900 46900 45900
R758 709 711 5.500000e-04k $ 10 46900 45900 46900 45900
R759 711 710 2.750000e-04k $ 12 46900 45900 46900 45900
R760 712 713 5.500000e-04k $ 6 46900 49500 46900 49500
R761 713 714 5.500000e-04k $ 8 46900 49500 46900 49500
R762 714 716 5.500000e-04k $ 10 46900 49500 46900 49500
R763 716 715 2.750000e-04k $ 12 46900 49500 46900 49500
R764 717 718 5.500000e-04k $ 6 46900 53100 46900 53100
R765 718 719 5.500000e-04k $ 8 46900 53100 46900 53100
R766 719 721 5.500000e-04k $ 10 46900 53100 46900 53100
R767 721 720 2.750000e-04k $ 12 46900 53100 46900 53100
C0 1 0 2.016155e-01pF $ CtiIntAck_5__ATdrc_i0000084 49200 53100
C1 2 0 2.578019e-03pF $ RegCtiINTACK_reg_5_ 45000 53100
C2 3 0 5.689391e-03pF $ CTWDataQ_reg_6_ 35600 53100
C3 4 0 2.031875e-01pF $ CtiIntAck_0__ATdrc_i0000073 31200 53100
C4 5 0 2.007777e-01pF $ CTIINEN3_2__ATdrc_i0000061 29800 53100
C5 6 0 3.299228e-03pF $ giga_ATls_i0000094 28800 53100
C6 7 0 2.028422e-01pF $ CTRData_7__ATdrc_i0000071 27800 53100
C7 8 0 2.029323e-01pF $ CTIINEN3_3__ATdrc_i0000064 26100 53100
C8 9 0 2.029726e-01pF $ CTIINEN3_1__ATdrc_i0000060 25000 53100
C9 10 0 9.668627e-03pF $ CTWDataQ_reg_5_ 21400 53100
C10 11 0 1.398360e-02pF $ CTAddrQ_reg_5_ 15600 53100
C11 12 0 2.008711e-01pF $ test_so4_ATdrc_i0000058 11600 53100
C12 13 0 2.006758e-01pF $ CTIOUTEN3_2__ATdrc_i0000025 10200 53100
C13 14 0 2.008124e-01pF $ CTIOUTEN4_0__ATdrc_i0000017 8800 53100
C14 15 0 7.875155e-02pF $ U19 7600 53100
C15 16 0 2.006887e-01pF $ CTIOUTEN0_0__ATdrc_i0000020 6600 53100
C16 17 0 2.006568e-01pF $ CTIOUTEN3_2__ATdrc_i0000024 5200 53100
C17 18 0 2.008038e-01pF $ CTIOUTEN3_3__ATdrc_i0000026 3800 53100
C18 19 0 2.009523e-01pF $ CTIOUTEN3_1__ATdrc_i0000021 2400 53100
C19 20 0 2.011148e-01pF $ CtiIntAck_6__ATdrc_i0000083 48600 49500
C20 21 0 6.914251e-03pF $ ASICCTL_reg_6_ 46600 49500
C21 22 0 2.090898e-03pF $ RegCtiINTACK_reg_6_ 45000 49500
C22 23 0 3.910489e-04pF $ latch 41700 49500
C23 24 0 3.858485e-03pF $ RegCtiINTACK_reg_7_ 39000 49500
C24 25 0 4.114027e-03pF $ RegCtiINTACK_reg_0_ 36800 49500
C25 26 0 2.026468e-01pF $ CtiIntAck_7__ATdrc_i0000075 35000 49500
C26 27 0 2.472594e-03pF $ giga_ATls_i0000095 32200 49500
C27 28 0 5.099019e-03pF $ CTWDataQ_reg_7_ 31400 49500
C28 29 0 2.105728e-01pF $ ASICCTL_reg_7_ 26100 49500
C29 30 0 2.030103e-01pF $ CTIINEN2_2__ATdrc_i0000065 25600 49500
C30 31 0 7.967244e-03pF $ RegCtiINEN3_reg_2_ 22200 49500
C31 32 0 1.297288e-02pF $ CTAddrQ_reg_6_ 21800 49500
C32 33 0 2.018859e-01pF $ CTRData_4__ATdrc_i0000069 16800 49500
C33 34 0 1.610905e-02pF $ CTAddrQ_reg_0_ 16000 49500
C34 35 0 2.016962e-01pF $ CTIINEN4_2__ATdrc_i0000045 15400 49500
C35 36 0 2.016295e-01pF $ CTRData_0__ATdrc_i0000053 14000 49500
C36 37 0 2.017178e-01pF $ CTIINEN1_1__ATdrc_i0000044 12600 49500
C37 38 0 2.012124e-01pF $ CTIINEN4_0__ATdrc_i0000046 12400 49500
C38 39 0 2.011402e-01pF $ CTRData_5__ATdrc_i0000037 11000 49500
C39 40 0 2.012272e-01pF $ CTIOUTEN7_1__ATdrc_i0000036 9600 49500
C40 41 0 9.108878e-03pF $ RegCtiOUTEN3_reg_3_ 8600 49500
C41 42 0 2.009678e-01pF $ CTIOUTEN2_0__ATdrc_i0000028 7600 49500
C42 43 0 2.010024e-01pF $ CTIINEN4_1__ATdrc_i0000049 5000 49500
C43 44 0 6.147030e-03pF $ RegCtiOUTEN3_reg_0_ 3800 49500
C44 45 0 2.012967e-01pF $ CTIOUTEN3_0__ATdrc_i0000022 1600 49500
C45 46 0 2.093745e-01pF $ ASICCTL_reg_3_ 45100 45900
C46 47 0 7.447575e-03pF $ ASICCTL_reg_0_ 44000 45900
C47 48 0 2.110604e-01pF $ ASICCTL_reg_1_ 33500 45900
C48 49 0 5.266907e-03pF $ RegRData_reg_7_ 32200 45900
C49 50 0 6.517482e-06pF $ latch 26100 45900
C50 51 0 7.296215e-03pF $ RegCtiINEN3_reg_1_ 26000 45900
C51 52 0 5.041319e-03pF $ RegRData_reg_0_ 19000 45900
C52 53 0 2.025705e-01pF $ CTIINEN2_0__ATdrc_i0000062 18800 45900
C53 54 0 2.024824e-01pF $ CTIINEN0_2__ATdrc_i0000048 15400 45900
C54 55 0 2.160850e-03pF $ RegRData_reg_5_ 14200 45900
C55 56 0 2.018730e-01pF $ ITTRIGOUTEn_ATmfs_i0000001 11800 45900
C56 57 0 4.236363e-04pF $ latch 8700 45900
C57 58 0 6.808810e-03pF $ RegCtiOUTEN3_reg_2_ 4600 45900
C58 59 0 5.729956e-03pF $ RegCtiOUTEN3_reg_1_ 3800 45900
C59 60 0 2.008105e-01pF $ CTRData_6__ATdrc_i0000074 49200 42300
C60 61 0 3.268670e-03pF $ CTAddrQ_reg_1_ 46900 42300
C61 62 0 2.062431e-01pF $ ASICCTL_reg_4_ 45100 42300
C62 63 0 4.431887e-04pF $ latch 40500 42300
C63 64 0 2.038997e-01pF $ ASICCTL_reg_5_ 38300 42300
C64 65 0 3.714906e-03pF $ ASICCTL_reg_2_ 34800 42300
C65 66 0 1.818733e-03pF $ giga_ATls_i0000124 34300 42300
C66 67 0 2.353961e-03pF $ giga_ATls_i0000159 33300 42300
C67 68 0 7.330926e-03pF $ RegCtiINEN3_reg_0_ 26100 42300
C68 69 0 6.692431e-03pF $ RegCtiINEN3_reg_3_ 26100 42300
C69 70 0 5.598177e-03pF $ RegCtiINEN2_reg_0_ 22600 42300
C70 71 0 4.053079e-03pF $ RegCtiINEN0_reg_1_ 21400 42300
C71 72 0 9.015847e-03pF $ RegCtiINEN0_reg_2_ 16800 42300
C72 73 0 6.996703e-03pF $ RegCtiINEN4_reg_0_ 15400 42300
C73 74 0 2.256360e-03pF $ U105 13200 42300
C74 75 0 2.712468e-03pF $ U202 12000 42300
C75 76 0 1.844748e-03pF $ U116 10800 42300
C76 77 0 1.958819e-03pF $ U120 9800 42300
C77 78 0 5.482685e-03pF $ RegCtiOUTEN2_reg_0_ 9600 42300
C78 79 0 3.485699e-03pF $ U186 8600 42300
C79 80 0 9.776222e-05pF $ latch 5300 42300
C80 81 0 5.083236e-03pF $ RegCtiOUTEN2_reg_1_ 3800 42300
C81 82 0 2.016826e-01pF $ CTIINEN3_0__ATdrc_i0000067 3000 42300
C82 83 0 2.020455e-01pF $ CTIOUTEN2_1__ATdrc_i0000011 1600 42300
C83 84 0 2.043244e-01pF $ CTAddrQ_reg_9_ 46500 38700
C84 85 0 4.913332e-02pF $ CTWDataQ_reg_0_ 45000 38700
C85 86 0 2.118355e-01pF $ test_so7_ATmdrc_i0000007 41400 38700
C86 87 0 2.083320e-03pF $ CTAddrQ_reg_3_ 40000 38700
C87 88 0 4.094690e-03pF $ RegRData_reg_6_ 37400 38700
C88 89 0 1.428820e-03pF $ giga_ATls_i0000150 35300 38700
C89 90 0 3.828896e-03pF $ U20 34200 38700
C90 91 0 1.964837e-03pF $ giga_ATls_i0000169 33400 38700
C91 92 0 2.042272e-01pF $ ASICCTL_6__ATdrc_i0000080 33200 38700
C92 93 0 2.340785e-03pF $ giga_ATls_i0000149 32300 38700
C93 94 0 2.168391e-03pF $ giga_ATls_i0000174 30700 38700
C94 95 0 2.229394e-03pF $ U119 28000 38700
C95 96 0 1.555839e-03pF $ U115 27000 38700
C96 97 0 5.938022e-03pF $ RegCtiINEN2_reg_2_ 26100 38700
C97 98 0 2.020419e-04pF $ latch 24500 38700
C98 99 0 2.524313e-03pF $ U211 23000 38700
C99 100 0 6.832207e-03pF $ RegCtiINEN4_reg_2_ 19400 38700
C100 101 0 4.236363e-04pF $ latch 18500 38700
C101 102 0 2.084131e-01pF $ RegCtiOUTEN7_reg_0_ 12900 38700
C102 103 0 6.928073e-03pF $ RegCtiOUTEN7_reg_1_ 12800 38700
C103 104 0 3.394256e-03pF $ U143 9200 38700
C104 105 0 3.492048e-03pF $ U166 8400 38700
C105 106 0 5.108255e-03pF $ RegCtiOUTEN2_reg_3_ 5300 38700
C106 107 0 6.477455e-03pF $ RegCtiOUTEN2_reg_2_ 4200 38700
C107 108 0 3.398043e-03pF $ CTWDataQ_reg_4_ 46600 35100
C108 109 0 2.041743e-01pF $ CTAddrQ_reg_7_ 43900 35100
C109 110 0 2.162049e-03pF $ giga_ATls_i0000131 40400 35100
C110 111 0 3.135927e-03pF $ giga_ATls_i0000130 39800 35100
C111 112 0 5.892500e-02pF $ U5 39700 35100
C112 113 0 2.799349e-03pF $ giga_ATls_i0000175 38800 35100
C113 114 0 1.315657e-03pF $ giga_ATls_i0000123 38800 35100
C114 115 0 4.103967e-03pF $ giga_ATls_i0000158 37700 35100
C115 116 0 1.607765e-03pF $ giga_ATls_i0000125 37500 35100
C116 117 0 4.949147e-03pF $ giga_ATls_i0000160 36400 35100
C117 118 0 1.644993e-03pF $ giga_ATls_i0000157 36200 35100
C118 119 0 5.347020e-03pF $ giga_ATls_i0000122 35400 35100
C119 120 0 1.673258e-03pF $ giga_ATls_i0000115 35400 35100
C120 121 0 1.350305e-03pF $ giga_ATls_i0000102 34800 35100
C121 122 0 1.845919e-03pF $ giga_ATls_i0000156 34600 35100
C122 123 0 1.808808e-03pF $ U132 33800 35100
C123 124 0 1.727585e-03pF $ giga_ATls_i0000170 33600 35100
C124 125 0 3.940061e-03pF $ giga_ATls_i0000114 32800 35100
C125 126 0 1.488437e-03pF $ giga_ATls_i0000176 32700 35100
C126 127 0 1.450671e-03pF $ giga_ATls_i0000148 31900 35100
C127 128 0 2.183276e-03pF $ giga_ATls_i0000147 30700 35100
C128 129 0 5.348067e-03pF $ RegRData_reg_4_ 29400 35100
C129 130 0 2.068404e-01pF $ RegCtiINEN2_reg_3_ 26100 35100
C130 131 0 6.580104e-03pF $ RegCtiINEN2_reg_1_ 23400 35100
C131 132 0 2.432872e-03pF $ U192 22600 35100
C132 133 0 1.742848e-03pF $ U108 21400 35100
C133 134 0 1.914879e-03pF $ U121 20400 35100
C134 135 0 2.215944e-04pF $ latch 18500 35100
C135 136 0 8.385848e-03pF $ RegCtiINEN4_reg_1_ 17000 35100
C136 137 0 3.808435e-03pF $ RegCtiINEN4_reg_3_ 13400 35100
C137 138 0 1.756219e-03pF $ U205 11700 35100
C138 139 0 2.578501e-03pF $ U189 10900 35100
C139 140 0 5.534567e-03pF $ RegCtiOUTEN0_reg_0_ 5300 35100
C140 141 0 4.926759e-03pF $ RegCtiOUTEN4_reg_1_ 5300 35100
C141 142 0 2.009910e-01pF $ CTIOUTEN4_1__ATdrc_i0000031 3000 35100
C142 143 0 2.006923e-01pF $ CTIINEN2_1__ATdrc_i0000056 1600 35100
C143 144 0 2.004921e-01pF $ CTIOUTEN2_3__ATdrc_i0000016 1600 35100
C144 145 0 2.009782e-01pF $ ITTRIGINACKEn_ATmfs_i0000003 49000 31500
C145 146 0 2.108597e-01pF $ test_so5_ATmdrc_i0000008 46900 31500
C146 147 0 5.023143e-03pF $ CTAddrQ_reg_8_ 46900 31500
C147 148 0 3.438531e-03pF $ U55 45700 31500
C148 149 0 3.108736e-03pF $ U38 44500 31500
C149 150 0 1.867809e-03pF $ U57 43300 31500
C150 151 0 3.041682e-03pF $ U40 43200 31500
C151 152 0 6.367589e-03pF $ U58 42400 31500
C152 153 0 3.100939e-03pF $ U51 42100 31500
C153 154 0 1.740296e-03pF $ U59_ATruldec_i0000177 41400 31500
C154 155 0 7.000188e-03pF $ U59_ATruldec_i0000179 40900 31500
C155 156 0 3.471818e-03pF $ U41 39900 31500
C156 157 0 1.828437e-03pF $ U65 39800 31500
C157 158 0 4.137673e-03pF $ U109 38800 31500
C158 159 0 2.799350e-03pF $ U102 38800 31500
C159 160 0 3.405369e-03pF $ U42 37700 31500
C160 161 0 1.706738e-03pF $ giga_ATls_i0000120 36800 31500
C161 162 0 1.660769e-02pF $ giga_ATls_i0000154 35900 31500
C162 163 0 4.212469e-03pF $ U62 35900 31500
C163 164 0 1.692760e-03pF $ giga_ATls_i0000117 35000 31500
C164 165 0 2.232606e-03pF $ giga_ATls_i0000121 33300 31500
C165 166 0 2.043064e-01pF $ ASICCTL_0__ATdrc_i0000076 33200 31500
C166 167 0 2.447280e-02pF $ U50 31900 31500
C167 168 0 2.215263e-02pF $ U60 30700 31500
C168 169 0 7.967786e-03pF $ U46 30700 31500
C169 170 0 6.119380e-03pF $ U45 29800 31500
C170 171 0 2.886165e-03pF $ U117 29600 31500
C171 172 0 2.947125e-03pF $ U44 29200 31500
C172 173 0 1.843037e-02pF $ U118 28600 31500
C173 174 0 3.164806e-03pF $ U77 28600 31500
C174 175 0 2.734199e-02pF $ U72 27700 31500
C175 176 0 1.848621e-02pF $ U104 27500 31500
C176 177 0 1.814555e-03pF $ U172 26100 31500
C177 178 0 2.383765e-03pF $ U215 24900 31500
C178 179 0 2.349218e-03pF $ U149 24800 31500
C179 180 0 1.837933e-03pF $ U175 23700 31500
C180 181 0 1.738030e-03pF $ U214 22500 31500
C181 182 0 2.112266e-03pF $ U194 22300 31500
C182 183 0 1.831250e-03pF $ U176 21300 31500
C183 184 0 1.653218e-03pF $ U193 20800 31500
C184 185 0 5.834436e-03pF $ RegCtiINEN0_reg_0_ 17800 31500
C185 186 0 2.055144e-01pF $ RegCtiINEN0_reg_3_ 16500 31500
C186 187 0 1.858418e-03pF $ U203 14200 31500
C187 188 0 3.595839e-03pF $ U206 12400 31500
C188 189 0 2.138341e-03pF $ U122 11000 31500
C189 190 0 5.278249e-03pF $ RegCtiOUTEN4_reg_2_ 10600 31500
C190 191 0 2.410060e-03pF $ U204 6800 31500
C191 192 0 2.070742e-01pF $ RegCtiOUTEN4_reg_0_ 5300 31500
C192 193 0 2.011588e-01pF $ CTIINEN1_0__ATdrc_i0000047 4400 31500
C193 194 0 2.010319e-01pF $ CTIOUTEN4_2__ATdrc_i0000030 3000 31500
C194 195 0 2.006701e-01pF $ CTIOUTEN0_1__ATdrc_i0000015 3000 31500
C195 196 0 2.006718e-01pF $ CTIINEN0_3__ATdrc_i0000038 1600 31500
C196 197 0 2.005801e-01pF $ CTIOUTEN4_3__ATdrc_i0000029 1600 31500
C197 198 0 2.558551e-03pF $ U95 48600 27900
C198 199 0 5.496555e-03pF $ CTAddrQ_reg_4_ 46900 27900
C199 200 0 3.435123e-03pF $ U39 45400 27900
C200 201 0 3.167635e-03pF $ U91 44500 27900
C201 202 0 5.741453e-03pF $ U52 43200 27900
C202 203 0 3.516620e-03pF $ U92 42000 27900
C203 204 0 7.820978e-05pF $ latch 41200 27900
C204 205 0 1.124029e-02pF $ U66 40800 27900
C205 206 0 1.091844e-02pF $ U154 38900 27900
C206 207 0 3.412581e-03pF $ U100 38000 27900
C207 208 0 2.899639e-03pF $ U53 37500 27900
C208 209 0 1.156523e-02pF $ U54 36400 27900
C209 210 0 5.865733e-05pF $ latch 35500 27900
C210 211 0 5.090955e-03pF $ U130 35500 27900
C211 212 0 3.205371e-03pF $ U61 34700 27900
C212 213 0 6.483304e-03pF $ U43 33700 27900
C213 214 0 1.013425e-02pF $ U106 32700 27900
C214 215 0 1.438986e-02pF $ U107 32200 27900
C215 216 0 1.602973e-03pF $ U210 31900 27900
C216 217 0 6.858112e-03pF $ U152 31300 27900
C217 218 0 1.475741e-03pF $ U216 30800 27900
C218 219 0 2.035305e-03pF $ giga_ATls_i0000103 30300 27900
C219 220 0 1.559205e-03pF $ giga_ATls_i0000155 29600 27900
C220 221 0 2.382826e-02pF $ U127 28600 27900
C221 222 0 2.494295e-02pF $ U78 27500 27900
C222 223 0 3.438603e-03pF $ RegCtiINEN7_reg_0_ 26100 27900
C223 224 0 1.693827e-03pF $ giga_ATls_i0000127 26100 27900
C224 225 0 1.463758e-03pF $ giga_ATls_i0000110 25300 27900
C225 226 0 2.055028e-03pF $ U195 24000 27900
C226 227 0 1.817221e-03pF $ U171 23000 27900
C227 228 0 1.787267e-03pF $ U153 23000 27900
C228 229 0 1.535531e-03pF $ giga_ATls_i0000109 21900 27900
C229 230 0 2.638299e-03pF $ U177 21800 27900
C230 231 0 2.125649e-03pF $ U174 20200 27900
C231 232 0 2.269585e-03pF $ U151 18700 27900
C232 233 0 3.340206e-03pF $ giga_ATls_i0000166 17300 27900
C233 234 0 2.283248e-03pF $ U213 16800 27900
C234 235 0 1.523251e-03pF $ U129 15800 27900
C235 236 0 1.820436e-03pF $ U150 15400 27900
C236 237 0 1.759720e-04pF $ latch 13300 27900
C237 238 0 1.694545e-04pF $ latch 12700 27900
C238 239 0 1.638398e-03pF $ U146 10700 27900
C239 240 0 2.627559e-03pF $ U170 10100 27900
C240 241 0 3.040461e-03pF $ U190 9600 27900
C241 242 0 1.703020e-03pF $ U187 8000 27900
C242 243 0 1.832526e-03pF $ U188 6600 27900
C243 244 0 5.462595e-03pF $ RegCtiOUTEN4_reg_3_ 5300 27900
C244 245 0 2.007831e-01pF $ CTIINEN0_0__ATdrc_i0000043 3000 27900
C245 246 0 2.008627e-01pF $ CTIOUTEN7_2__ATdrc_i0000039 2800 27900
C246 247 0 2.005430e-01pF $ CTIOUTEN2_2__ATdrc_i0000023 1600 27900
C247 248 0 2.007436e-01pF $ ITEN_ATdrc_i0000079 49000 24300
C248 249 0 2.038164e-01pF $ RegCTACK_cdc_check_reg 46300 24300
C249 250 0 5.502573e-03pF $ ITCONTROL_reg 45200 24300
C250 251 0 2.051487e-03pF $ U94 41900 24300
C251 252 0 3.232185e-03pF $ U209 40800 24300
C252 253 0 2.382252e-03pF $ U93 40300 24300
C253 254 0 8.991135e-03pF $ U70 39200 24300
C254 255 0 1.133833e-02pF $ U101 37500 24300
C255 256 0 2.124778e-03pF $ U68_ATdup_i0000086 37300 24300
C256 257 0 7.581052e-03pF $ n20_ATmfs_i0000002 36800 24300
C257 258 0 1.761728e-03pF $ U68 36100 24300
C258 259 0 1.632751e-03pF $ U68_ATdup_i0000085 35900 24300
C259 260 0 8.915217e-03pF $ U67 35200 24300
C260 261 0 1.511498e-03pF $ giga_ATls_i0000119 35000 24300
C261 262 0 2.025850e-03pF $ giga_ATls_i0000151 34500 24300
C262 263 0 1.675902e-03pF $ giga_ATls_i0000116 33800 24300
C263 264 0 8.159064e-03pF $ U110 33600 24300
C264 265 0 1.508101e-02pF $ U49 33100 24300
C265 266 0 8.111201e-03pF $ U142 32900 24300
C266 267 0 9.493806e-03pF $ U48 32300 24300
C267 268 0 1.664099e-02pF $ U111 32000 24300
C268 269 0 1.101264e-02pF $ U47 31300 24300
C269 270 0 1.853407e-03pF $ U128 29800 24300
C270 271 0 3.359456e-03pF $ RegCtiINEN7_reg_1_ 26100 24300
C271 272 0 1.433846e-04pF $ latch 26100 24300
C272 273 0 2.865610e-03pF $ giga_ATls_i0000100 23900 24300
C273 274 0 2.246156e-03pF $ U212 23600 24300
C274 275 0 2.381047e-03pF $ giga_ATls_i0000101 22700 24300
C275 276 0 2.094197e-03pF $ U148 22200 24300
C276 277 0 1.669143e-03pF $ giga_ATls_i0000108 21500 24300
C277 278 0 8.262075e-03pF $ RegCtiINEN1_reg_1_ 18600 24300
C278 279 0 8.734541e-03pF $ RegCtiINEN1_reg_0_ 16600 24300
C279 280 0 2.430936e-03pF $ giga_ATls_i0000172 13100 24300
C280 281 0 2.016634e-01pF $ U103 12200 24300
C281 282 0 2.017664e-01pF $ CTIINEN1_3__ATdrc_i0000042 11800 24300
C282 283 0 2.825174e-03pF $ U147 10400 24300
C283 284 0 1.387403e-03pF $ U145 10400 24300
C284 285 0 1.999749e-03pF $ U169 9100 24300
C285 286 0 1.585256e-03pF $ U167 8800 24300
C286 287 0 1.788019e-03pF $ U168 7400 24300
C287 288 0 2.009953e-01pF $ CTIOUTEN1_3__ATdrc_i0000033 5300 24300
C288 289 0 6.107740e-03pF $ RegCtiOUTEN0_reg_1_ 5300 24300
C289 290 0 2.010549e-01pF $ CTIOUTEN0_2__ATdrc_i0000019 4400 24300
C290 291 0 2.018866e-01pF $ CTIOUTEN0_3__ATdrc_i0000012 3000 24300
C291 292 0 2.538128e-03pF $ giga_ATls_i0000090 2200 24300
C292 293 0 2.014839e-01pF $ CTIOUTEN6_2__ATdrc_i0000009 1600 24300
C293 294 0 2.005657e-01pF $ ChOutEnable_3__ATdrc_i0000078 49200 20700
C294 295 0 2.006678e-01pF $ ChOutEnable_3__ATdrc_i0000077 49200 20700
C295 296 0 6.220550e-03pF $ ChannelGate_reg_3_ 45200 20700
C296 297 0 2.281119e-04pF $ latch 44700 20700
C297 298 0 1.840367e-03pF $ giga_ATls_i0000153 41700 20700
C298 299 0 6.172257e-03pF $ giga_ATls_i0000133 41000 20700
C299 300 0 1.558528e-03pF $ U99_ATruldec_i0000178 40800 20700
C300 301 0 1.562587e-03pF $ giga_ATls_i0000132 40400 20700
C301 302 0 3.086905e-03pF $ U25 40000 20700
C302 303 0 2.629014e-03pF $ giga_ATls_i0000161 39200 20700
C303 304 0 2.423807e-03pF $ giga_ATls_i0000129 39200 20700
C304 305 0 6.317148e-03pF $ U156 37500 20700
C305 306 0 2.127483e-03pF $ U157 37400 20700
C306 307 0 2.081698e-03pF $ giga_ATls_i0000106 36400 20700
C307 308 0 4.172664e-03pF $ U197 35800 20700
C308 309 0 4.010300e-03pF $ U181 35200 20700
C309 310 0 1.608596e-03pF $ U218 34400 20700
C310 311 0 1.568404e-03pF $ U158 34200 20700
C311 312 0 1.037015e-02pF $ U159 33300 20700
C312 313 0 1.452087e-03pF $ U219 32500 20700
C313 314 0 9.806287e-03pF $ giga_ATls_i0000143 32300 20700
C314 315 0 1.610527e-03pF $ giga_ATls_i0000104 31400 20700
C315 316 0 1.319058e-03pF $ giga_ATls_i0000141 31100 20700
C316 317 0 3.592114e-03pF $ giga_ATls_i0000126 30400 20700
C317 318 0 1.587696e-03pF $ giga_ATls_i0000140 30100 20700
C318 319 0 3.113564e-03pF $ giga_ATls_i0000105 29400 20700
C319 320 0 2.968116e-03pF $ RegCtiINEN7_reg_2_ 26100 20700
C320 321 0 3.290411e-03pF $ RegCtiINEN7_reg_3_ 25800 20700
C321 322 0 2.745669e-03pF $ U173 22800 20700
C322 323 0 1.343478e-03pF $ giga_ATls_i0000112 22600 20700
C323 324 0 2.730425e-03pF $ giga_ATls_i0000145 21700 20700
C324 325 0 1.658074e-03pF $ U113 20600 20700
C325 326 0 2.215944e-04pF $ latch 19100 20700
C326 327 0 5.658045e-03pF $ RegCtiINEN1_reg_2_ 17200 20700
C327 328 0 2.652343e-03pF $ giga_ATls_i0000142 16300 20700
C328 329 0 5.883417e-03pF $ RegCtiINEN1_reg_3_ 12600 20700
C329 330 0 1.907783e-03pF $ U112 8600 20700
C330 331 0 4.794173e-03pF $ RegCtiOUTEN0_reg_2_ 5300 20700
C331 332 0 2.020419e-04pF $ latch 5300 20700
C332 333 0 2.007997e-01pF $ CTIINEN6_3__ATdrc_i0000052 2200 20700
C333 334 0 3.469681e-03pF $ U198 1600 20700
C334 335 0 3.015526e-03pF $ giga_ATls_i0000088 1200 20700
C335 336 0 2.006291e-01pF $ ChOutEnable_0__ATdrc_i0000082 49200 17100
C336 337 0 2.007910e-01pF $ ChOutEnable_2__ATdrc_i0000081 47800 17100
C337 338 0 6.690090e-03pF $ ChannelGate_reg_2_ 46900 17100
C338 339 0 6.450408e-03pF $ ChannelGate_reg_0_ 43200 17100
C339 340 0 3.680912e-03pF $ ChannelGate_reg_1_ 41000 17100
C340 341 0 7.081288e-03pF $ giga_ATls_i0000128 38300 17100
C341 342 0 6.317448e-03pF $ U226 37400 17100
C342 343 0 1.991286e-03pF $ U180 34800 17100
C343 344 0 4.579917e-03pF $ RegCtiOUTEN5_reg_1_ 34600 17100
C344 345 0 1.995185e-03pF $ U124 32800 17100
C345 346 0 2.162225e-03pF $ giga_ATls_i0000107 31600 17100
C346 347 0 2.546875e-03pF $ giga_ATls_i0000113 30600 17100
C347 348 0 2.511927e-03pF $ U123 28400 17100
C348 349 0 2.034438e-03pF $ giga_ATls_i0000144 26800 17100
C349 350 0 4.690114e-03pF $ CTWriteQ_reg 26100 17100
C350 351 0 1.898896e-03pF $ U125 25400 17100
C351 352 0 2.897784e-03pF $ U191 24200 17100
C352 353 0 2.178707e-03pF $ giga_ATls_i0000146 23100 17100
C353 354 0 8.234723e-03pF $ RegCtiINEN6_reg_2_ 22600 17100
C354 355 0 2.350474e-03pF $ giga_ATls_i0000099 22000 17100
C355 356 0 8.159217e-03pF $ RegCtiINEN6_reg_3_ 18600 17100
C356 357 0 2.346432e-03pF $ giga_ATls_i0000098 18500 17100
C357 358 0 2.715980e-03pF $ giga_ATls_i0000118 17400 17100
C358 359 0 1.682284e-03pF $ giga_ATls_i0000111 16200 17100
C359 360 0 2.063870e-03pF $ U199 15000 17100
C360 361 0 6.052916e-03pF $ RegCtiOUTEN7_reg_3_ 12800 17100
C361 362 0 8.566610e-03pF $ RegCtiOUTEN7_reg_2_ 11400 17100
C362 363 0 2.659655e-03pF $ U144 9000 17100
C363 364 0 1.670085e-03pF $ U114 7800 17100
C364 365 0 2.618467e-03pF $ U126 7600 17100
C365 366 0 7.169230e-05pF $ latch 5100 17100
C366 367 0 6.845743e-03pF $ RegCtiOUTEN0_reg_3_ 4200 17100
C367 368 0 3.390078e-03pF $ U160 1600 17100
C368 369 0 1.534836e-03pF $ U81 46900 13500
C369 370 0 9.060800e-03pF $ RegCtiAppTrig_reg_0_ 46900 13500
C370 371 0 5.156064e-03pF $ U24 46200 13500
C371 372 0 1.390614e-03pF $ U80 45300 13500
C372 373 0 1.934382e-03pF $ U84 44100 13500
C373 374 0 1.262500e-03pF $ U89 43500 13500
C374 375 0 1.276963e-03pF $ U83 42700 13500
C375 376 0 1.937464e-03pF $ U90 42300 13500
C376 377 0 1.828613e-03pF $ U87 41100 13500
C377 378 0 1.390614e-03pF $ U86 39900 13500
C378 379 0 5.487772e-03pF $ U23 39000 13500
C379 380 0 2.054997e-01pF $ RegCtiControl_reg 38700 13500
C380 381 0 4.474871e-03pF $ U22 38400 13500
C381 382 0 6.555679e-03pF $ U79 37700 13500
C382 383 0 2.932867e-04pF $ latch 35300 13500
C383 384 0 2.062874e-03pF $ U164 33200 13500
C384 385 0 2.049438e-03pF $ U184 32200 13500
C385 386 0 2.640932e-03pF $ U217 31000 13500
C386 387 0 2.836077e-03pF $ RegCtiOUTEN5_reg_0_ 26100 13500
C387 388 0 5.324028e-03pF $ RegCtiINEN6_reg_1_ 25400 13500
C388 389 0 3.910489e-04pF $ latch 23100 13500
C389 390 0 7.425816e-03pF $ RegCtiINEN6_reg_0_ 19400 13500
C390 391 0 2.022692e-01pF $ CTIINEN1_2__ATdrc_i0000050 18800 13500
C391 392 0 1.339629e-03pF $ giga_ATls_i0000138 15900 13500
C392 393 0 2.130944e-03pF $ giga_ATls_i0000096 14700 13500
C393 394 0 1.887253e-03pF $ giga_ATls_i0000097 14600 13500
C394 395 0 5.439213e-03pF $ RegCtiOUTEN1_reg_3_ 11200 13500
C395 396 0 7.798882e-03pF $ RegCtiOUTEN1_reg_0_ 11000 13500
C396 397 0 6.216983e-03pF $ RegCtiOUTEN1_reg_1_ 5200 13500
C397 398 0 6.359824e-03pF $ RegCtiOUTEN1_reg_2_ 5200 13500
C398 399 0 2.006990e-01pF $ CTIOUTEN6_3__ATdrc_i0000013 1600 13500
C399 400 0 2.004926e-01pF $ CTIOUTEN6_1__ATdrc_i0000010 1600 13500
C400 401 0 9.899205e-03pF $ RegCtiAppTrig_reg_3_ 46900 9900
C401 402 0 9.568402e-03pF $ RegCtiAppTrig_reg_2_ 43400 9900
C402 403 0 8.722537e-03pF $ RegCtiAppTrig_reg_1_ 41000 9900
C403 404 0 2.008171e-03pF $ U230 39400 9900
C404 405 0 2.239903e-03pF $ U228 38400 9900
C405 406 0 3.131604e-03pF $ RegCtiOUTEN5_reg_2_ 35000 9900
C406 407 0 5.129842e-03pF $ RegCtiOUTEN5_reg_3_ 33600 9900
C407 408 0 2.876969e-03pF $ U139 31000 9900
C408 409 0 0.000000e+00pF $ latch 26100 9900
C409 410 0 5.423015e-03pF $ RegCtiINEN5_reg_0_ 26100 9900
C410 411 0 5.728987e-03pF $ RegCtiINEN5_reg_3_ 23000 9900
C411 412 0 6.259894e-03pF $ RegRData_reg_1_ 22000 9900
C412 413 0 2.022145e-01pF $ CTIINEN6_1__ATdrc_i0000057 19400 9900
C413 414 0 1.396718e-03pF $ giga_ATls_i0000168 18500 9900
C414 415 0 1.716454e-03pF $ giga_ATls_i0000139 17300 9900
C415 416 0 2.022496e-01pF $ CTIINEN6_0__ATdrc_i0000054 16000 9900
C416 417 0 3.097935e-03pF $ RegRData_reg_3_ 15800 9900
C417 418 0 1.602163e-03pF $ giga_ATls_i0000173 14500 9900
C418 419 0 1.894266e-03pF $ giga_ATls_i0000137 12700 9900
C419 420 0 1.820827e-03pF $ giga_ATls_i0000165 12500 9900
C420 421 0 1.798118e-03pF $ giga_ATls_i0000152 11300 9900
C421 422 0 1.645854e-03pF $ giga_ATls_i0000171 11200 9900
C422 423 0 1.956262e-03pF $ giga_ATls_i0000167 9900 9900
C423 424 0 8.322661e-03pF $ RegCtiOUTEN6_reg_0_ 5300 9900
C424 425 0 5.837820e-03pF $ RegCtiOUTEN6_reg_3_ 5200 9900
C425 426 0 2.381702e-03pF $ giga_ATls_i0000089 1800 9900
C426 427 0 2.005984e-01pF $ CTIOUTEN1_1__ATdrc_i0000014 1600 9900
C427 428 0 2.428340e-03pF $ giga_ATls_i0000087 1200 9900
C428 429 0 3.143847e-03pF $ giga_ATls_i0000135 49600 6300
C429 430 0 9.622660e-03pF $ APBaction_reg 46600 6300
C430 431 0 3.021166e-03pF $ LastAPBREQ_reg 46000 6300
C431 432 0 2.217890e-03pF $ U229 39600 6300
C432 433 0 4.294913e-03pF $ RegCtiAppPulse_reg_3_ 38800 6300
C433 434 0 2.145437e-03pF $ U227 38600 6300
C434 435 0 4.146804e-03pF $ RegCtiAppPulse_reg_1_ 35000 6300
C435 436 0 2.026834e-01pF $ U222 34700 6300
C436 437 0 2.038286e-01pF $ U224 32500 6300
C437 438 0 2.453576e-01pF $ test_so1_ATmdrc_i0000006 30800 6300
C438 439 0 2.024437e-01pF $ CTIOUTEN5_3__ATdrc_i0000072 30600 6300
C439 440 0 8.037944e-03pF $ RegCtiINEN5_reg_1_ 26100 6300
C440 441 0 6.458419e-03pF $ RegCtiINEN5_reg_2_ 24800 6300
C441 442 0 2.020686e-01pF $ CTIINEN5_0__ATdrc_i0000066 23400 6300
C442 443 0 2.441328e-01pF $ test_so3_ATmdrc_i0000005 21200 6300
C443 444 0 2.013753e-01pF $ CTIINEN6_0__ATdrc_i0000055 19400 6300
C444 445 0 1.674796e-03pF $ giga_ATls_i0000093 18400 6300
C445 446 0 2.052778e-03pF $ CTWDataQ_reg_3_ 17600 6300
C446 447 0 2.451522e-01pF $ test_so2_ATmdrc_i0000004 17400 6300
C447 448 0 2.013659e-01pF $ CTRData_3__ATdrc_i0000041 15800 6300
C448 449 0 1.694515e-03pF $ giga_ATls_i0000092 14200 6300
C449 450 0 2.015546e-01pF $ CTIOUTEN5_1__ATdrc_i0000040 12400 6300
C450 451 0 2.286658e-03pF $ RegRData_reg_2_ 12200 6300
C451 452 0 1.703018e-03pF $ giga_ATls_i0000091 11200 6300
C452 453 0 2.551755e-03pF $ U155 10600 6300
C453 454 0 3.636857e-03pF $ U196 9600 6300
C454 455 0 2.011957e-01pF $ CTIOUTEN7_3__ATdrc_i0000035 8400 6300
C455 456 0 9.776222e-05pF $ latch 5300 6300
C456 457 0 7.557192e-03pF $ RegCtiOUTEN6_reg_1_ 3800 6300
C457 458 0 1.729045e-03pF $ giga_ATls_i0000164 49000 2700
C458 459 0 6.028265e-03pF $ giga_ATls_i0000163 46900 2700
C459 460 0 3.040699e-03pF $ giga_ATls_i0000136 46300 2700
C460 461 0 2.247025e-03pF $ giga_ATls_i0000162 45800 2700
C461 462 0 1.356823e-03pF $ giga_ATls_i0000134 45600 2700
C462 463 0 1.878530e-03pF $ U3 44900 2700
C463 464 0 1.708668e-03pF $ U96 44300 2700
C464 465 0 9.334570e-03pF $ RegCTIAPBSBYPASS_reg 41600 2700
C465 466 0 2.056117e-01pF $ RegCtiAppPulse_reg_2_ 38100 2700
C466 467 0 4.429280e-03pF $ RegCtiAppPulse_reg_0_ 35600 2700
C467 468 0 2.351191e-03pF $ CTWDataQ_reg_2_ 31200 2700
C468 469 0 2.023459e-01pF $ U225 31100 2700
C469 470 0 2.022588e-01pF $ U223 29100 2700
C470 471 0 1.254598e-02pF $ CTAddrQ_reg_2_ 25400 2700
C471 472 0 2.012928e-01pF $ CTIINEN5_3__ATdrc_i0000063 25000 2700
C472 473 0 2.013926e-01pF $ CTIINEN5_2__ATdrc_i0000068 23600 2700
C473 474 0 2.011453e-01pF $ CTRData_1__ATdrc_i0000059 22000 2700
C474 475 0 2.074192e-03pF $ CTWDataQ_reg_1_ 19600 2700
C475 476 0 2.024296e-01pF $ sync_reg_reg 16500 2700
C476 477 0 7.478971e-03pF $ sync2_reg_reg 13800 2700
C477 478 0 2.010267e-01pF $ CTIINEN5_1__ATdrc_i0000070 10200 2700
C478 479 0 2.012797e-01pF $ CTRData_2__ATdrc_i0000034 10000 2700
C479 480 0 2.007591e-01pF $ CTIOUTEN1_0__ATdrc_i0000032 8600 2700
C480 481 0 2.007556e-01pF $ CTIOUTEN1_2__ATdrc_i0000027 7600 2700
C481 482 0 2.008134e-01pF $ CTIOUTEN6_0__ATdrc_i0000018 7200 2700
C482 483 0 2.008693e-01pF $ CTIINEN6_2__ATdrc_i0000051 5300 2700
C483 484 0 7.334058e-03pF $ RegCtiOUTEN6_reg_2_ 3800 2700

*** Power supplies
V1 722 0  1.080000e+00
V2 723 0  1.080000e+00
V3 724 0  1.080000e+00
V4 725 0  1.080000e+00
V5 726 0  1.080000e+00
V6 727 0  1.080000e+00
V7 728 0  1.080000e+00
V8 729 0  1.080000e+00
V9 730 0  1.080000e+00
V10 731 0  1.080000e+00
V11 732 0  1.080000e+00
V12 733 0  1.080000e+00
V13 734 0  1.080000e+00
V14 735 0  1.080000e+00
V15 736 0  1.080000e+00
I0 1 0 PWL 0 0
+ 0.496ns 0mA
+ 0.498ns 0.00225772mA
+ 0.5ns 0.00982192mA
+ 0.502ns 0.0173864mA
+ 0.504ns 0.0249506mA
+ 0.506ns 0.032515mA
+ 0.508ns 0.0400792mA
+ 0.51ns 0.0476436mA
+ 0.512ns 0.0552078mA
+ 0.514ns 0.062772mA
+ 0.516ns 0.0703365mA
+ 0.518ns 0.0779007mA
+ 0.52ns 0.0854651mA
+ 0.522ns 0.0930293mA
+ 0.524ns 0.100594mA
+ 0.526ns 0.108158mA
+ 0.528ns 0.115722mA
+ 0.53ns 0.123287mA
+ 0.532ns 0.130851mA
+ 0.534ns 0.138415mA
+ 0.536ns 0.145979mA
+ 0.538ns 0.153544mA
+ 0.54ns 0.161108mA
+ 0.542ns 0.168672mA
+ 0.544ns 0.176237mA
+ 0.546ns 0.183801mA
+ 0.548ns 0.191365mA
+ 0.55ns 0.19893mA
+ 0.552ns 0.206494mA
+ 0.554ns 0.214058mA
+ 0.556ns 0.221623mA
+ 0.558ns 0.229187mA
+ 0.56ns 0.236751mA
+ 0.562ns 0.244315mA
+ 0.564ns 0.25188mA
+ 0.566ns 0.259444mA
+ 0.568ns 0.267008mA
+ 0.57ns 0.274573mA
+ 0.572ns 0.282137mA
+ 0.574ns 0.289701mA
+ 0.576ns 0.297266mA
+ 0.578ns 0.30483mA
+ 0.58ns 0.312394mA
+ 0.582ns 0.319958mA
+ 0.584ns 0.327523mA
+ 0.586ns 0.335087mA
+ 0.588ns 0.342651mA
+ 0.59ns 0.350216mA
+ 0.592ns 0.35778mA
+ 0.594ns 0.365344mA
+ 0.596ns 0.372909mA
+ 0.598ns 0.380473mA
+ 0.6ns 0.388037mA
+ 0.602ns 0.395602mA
+ 0.604ns 0.403166mA
+ 0.606ns 0.41073mA
+ 0.608ns 0.418294mA
+ 0.61ns 0.425859mA
+ 0.612ns 0.433423mA
+ 0.614ns 0.440987mA
+ 0.616ns 0.448552mA
+ 0.618ns 0.456116mA
+ 0.62ns 0.46368mA
+ 0.622ns 0.471245mA
+ 0.624ns 0.478809mA
+ 0.626ns 0.486373mA
+ 0.628ns 0.493937mA
+ 0.63ns 0.501502mA
+ 0.632ns 0.509066mA
+ 0.634ns 0.51663mA
+ 0.636ns 0.524195mA
+ 0.638ns 0.531759mA
+ 0.64ns 0.539323mA
+ 0.642ns 0.544405mA
+ 0.644ns 0.542046mA
+ 0.646ns 0.539697mA
+ 0.648ns 0.537359mA
+ 0.65ns 0.535031mA
+ 0.652ns 0.532712mA
+ 0.654ns 0.530404mA
+ 0.656ns 0.528106mA
+ 0.658ns 0.525818mA
+ 0.66ns 0.523539mA
+ 0.662ns 0.521271mA
+ 0.664ns 0.519012mA
+ 0.666ns 0.516763mA
+ 0.668ns 0.514524mA
+ 0.67ns 0.512295mA
+ 0.672ns 0.510075mA
+ 0.674ns 0.507865mA
+ 0.676ns 0.505664mA
+ 0.678ns 0.503473mA
+ 0.68ns 0.501292mA
+ 0.682ns 0.49912mA
+ 0.684ns 0.496957mA
+ 0.686ns 0.494804mA
+ 0.688ns 0.49266mA
+ 0.69ns 0.490525mA
+ 0.692ns 0.4884mA
+ 0.694ns 0.486283mA
+ 0.696ns 0.484176mA
+ 0.698ns 0.482078mA
+ 0.7ns 0.479989mA
+ 0.702ns 0.47791mA
+ 0.704ns 0.475839mA
+ 0.706ns 0.473777mA
+ 0.708ns 0.471724mA
+ 0.71ns 0.46968mA
+ 0.712ns 0.467645mA
+ 0.714ns 0.465618mA
+ 0.716ns 0.463601mA
+ 0.718ns 0.461592mA
+ 0.72ns 0.459592mA
+ 0.722ns 0.4576mA
+ 0.724ns 0.455618mA
+ 0.726ns 0.453643mA
+ 0.728ns 0.451678mA
+ 0.73ns 0.449721mA
+ 0.732ns 0.447772mA
+ 0.734ns 0.445832mA
+ 0.736ns 0.4439mA
+ 0.738ns 0.441976mA
+ 0.74ns 0.440061mA
+ 0.742ns 0.438154mA
+ 0.744ns 0.436256mA
+ 0.746ns 0.434365mA
+ 0.748ns 0.432483mA
+ 0.75ns 0.430609mA
+ 0.752ns 0.428743mA
+ 0.754ns 0.426885mA
+ 0.756ns 0.425036mA
+ 0.758ns 0.423194mA
+ 0.76ns 0.42136mA
+ 0.762ns 0.419534mA
+ 0.764ns 0.417716mA
+ 0.766ns 0.415906mA
+ 0.768ns 0.414104mA
+ 0.77ns 0.41231mA
+ 0.772ns 0.410523mA
+ 0.774ns 0.408744mA
+ 0.776ns 0.406973mA
+ 0.778ns 0.40521mA
+ 0.78ns 0.403454mA
+ 0.782ns 0.401705mA
+ 0.784ns 0.399965mA
+ 0.786ns 0.398232mA
+ 0.788ns 0.396506mA
+ 0.79ns 0.394788mA
+ 0.792ns 0.393077mA
+ 0.794ns 0.391374mA
+ 0.796ns 0.389678mA
+ 0.798ns 0.387989mA
+ 0.8ns 0.386308mA
+ 0.802ns 0.384634mA
+ 0.804ns 0.382967mA
+ 0.806ns 0.381308mA
+ 0.808ns 0.379655mA
+ 0.81ns 0.37801mA
+ 0.812ns 0.376372mA
+ 0.814ns 0.374741mA
+ 0.816ns 0.373117mA
+ 0.818ns 0.371501mA
+ 0.82ns 0.369891mA
+ 0.822ns 0.368288mA
+ 0.824ns 0.366692mA
+ 0.826ns 0.365103mA
+ 0.828ns 0.363521mA
+ 0.83ns 0.361946mA
+ 0.832ns 0.360377mA
+ 0.834ns 0.358816mA
+ 0.836ns 0.357261mA
+ 0.838ns 0.355713mA
+ 0.84ns 0.354171mA
+ 0.842ns 0.352636mA
+ 0.844ns 0.351108mA
+ 0.846ns 0.349587mA
+ 0.848ns 0.348072mA
+ 0.85ns 0.346564mA
+ 0.852ns 0.345062mA
+ 0.854ns 0.343566mA
+ 0.856ns 0.342078mA
+ 0.858ns 0.340595mA
+ 0.86ns 0.339119mA
+ 0.862ns 0.33765mA
+ 0.864ns 0.336187mA
+ 0.866ns 0.33473mA
+ 0.868ns 0.333279mA
+ 0.87ns 0.331835mA
+ 0.872ns 0.330397mA
+ 0.874ns 0.328965mA
+ 0.876ns 0.32754mA
+ 0.878ns 0.32612mA
+ 0.88ns 0.324707mA
+ 0.882ns 0.3233mA
+ 0.884ns 0.321899mA
+ 0.886ns 0.320504mA
+ 0.888ns 0.319115mA
+ 0.89ns 0.317732mA
+ 0.892ns 0.316355mA
+ 0.894ns 0.314984mA
+ 0.896ns 0.313619mA
+ 0.898ns 0.31226mA
+ 0.9ns 0.310907mA
+ 0.902ns 0.30956mA
+ 0.904ns 0.308218mA
+ 0.906ns 0.306883mA
+ 0.908ns 0.305553mA
+ 0.91ns 0.304229mA
+ 0.912ns 0.30291mA
+ 0.914ns 0.301598mA
+ 0.916ns 0.300291mA
+ 0.918ns 0.298989mA
+ 0.92ns 0.297694mA
+ 0.922ns 0.296404mA
+ 0.924ns 0.295119mA
+ 0.926ns 0.29384mA
+ 0.928ns 0.292567mA
+ 0.93ns 0.291299mA
+ 0.932ns 0.290037mA
+ 0.934ns 0.28878mA
+ 0.936ns 0.287528mA
+ 0.938ns 0.286282mA
+ 0.94ns 0.285042mA
+ 0.942ns 0.283806mA
+ 0.944ns 0.282576mA
+ 0.946ns 0.281352mA
+ 0.948ns 0.280133mA
+ 0.95ns 0.278919mA
+ 0.952ns 0.27771mA
+ 0.954ns 0.276506mA
+ 0.956ns 0.275308mA
+ 0.958ns 0.274115mA
+ 0.96ns 0.272927mA
+ 0.962ns 0.271744mA
+ 0.964ns 0.270567mA
+ 0.966ns 0.269394mA
+ 0.968ns 0.268227mA
+ 0.97ns 0.267064mA
+ 0.972ns 0.265907mA
+ 0.974ns 0.264755mA
+ 0.976ns 0.263607mA
+ 0.978ns 0.262465mA
+ 0.98ns 0.261327mA
+ 0.982ns 0.260195mA
+ 0.984ns 0.259067mA
+ 0.986ns 0.257945mA
+ 0.988ns 0.256827mA
+ 0.99ns 0.255714mA
+ 0.992ns 0.254606mA
+ 0.994ns 0.253502mA
+ 0.996ns 0.252403mA
+ 0.998ns 0.25131mA
+ 1ns 0.250221mA
+ 1.002ns 0.249136mA
+ 1.004ns 0.248056mA
+ 1.006ns 0.246981mA
+ 1.008ns 0.245911mA
+ 1.01ns 0.244845mA
+ 1.012ns 0.243784mA
+ 1.014ns 0.242728mA
+ 1.016ns 0.241676mA
+ 1.018ns 0.240628mA
+ 1.02ns 0.239586mA
+ 1.022ns 0.238547mA
+ 1.024ns 0.237514mA
+ 1.026ns 0.236484mA
+ 1.028ns 0.235459mA
+ 1.03ns 0.234439mA
+ 1.032ns 0.233423mA
+ 1.034ns 0mA
I1 2 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.00962426mA
+ 2.654ns 0.0206992mA
+ 2.656ns 0.0317741mA
+ 2.658ns 0.0428477mA
+ 2.66ns 0.0539226mA
+ 2.662ns 0.0649962mA
+ 2.664ns 0.0760711mA
+ 2.666ns 0.0730324mA
+ 2.668ns 0.0604307mA
+ 2.67ns 0.0500018mA
+ 2.672ns 0.0413733mA
+ 2.674ns 0.0342327mA
+ 2.676ns 0.0283242mA
+ 2.678ns 0.0234359mA
+ 2.68ns 0mA
I2 3 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00674546mA
+ 5.156ns 0.0173036mA
+ 5.158ns 0.0278617mA
+ 5.16ns 0.0384198mA
+ 5.162ns 0.0489805mA
+ 5.164ns 0.0595386mA
+ 5.166ns 0.0700967mA
+ 5.168ns 0.0806573mA
+ 5.17ns 0.0912155mA
+ 5.172ns 0.101774mA
+ 5.174ns 0.112334mA
+ 5.176ns 0.122892mA
+ 5.178ns 0.11984mA
+ 5.18ns 0.106856mA
+ 5.182ns 0.0952765mA
+ 5.184ns 0.0849536mA
+ 5.186ns 0.0757488mA
+ 5.188ns 0.0675393mA
+ 5.19ns 0.060221mA
+ 5.192ns 0.0536955mA
+ 5.194ns 0.0478757mA
+ 5.196ns 0.0426877mA
+ 5.198ns 0.0380617mA
+ 5.2ns 0.033936mA
+ 5.202ns 0mA
I3 4 0 PWL 0 0
+ 3.01ns 0mA
+ 3.012ns 0.00322798mA
+ 3.014ns 0.0108278mA
+ 3.016ns 0.0184285mA
+ 3.018ns 0.0260292mA
+ 3.02ns 0.0336291mA
+ 3.022ns 0.0412298mA
+ 3.024ns 0.0488305mA
+ 3.026ns 0.0564303mA
+ 3.028ns 0.0640311mA
+ 3.03ns 0.0716309mA
+ 3.032ns 0.0792316mA
+ 3.034ns 0.0868323mA
+ 3.036ns 0.0944322mA
+ 3.038ns 0.102033mA
+ 3.04ns 0.109633mA
+ 3.042ns 0.117233mA
+ 3.044ns 0.124834mA
+ 3.046ns 0.132434mA
+ 3.048ns 0.140035mA
+ 3.05ns 0.147635mA
+ 3.052ns 0.155235mA
+ 3.054ns 0.162836mA
+ 3.056ns 0.170436mA
+ 3.058ns 0.178037mA
+ 3.06ns 0.185636mA
+ 3.062ns 0.193237mA
+ 3.064ns 0.200838mA
+ 3.066ns 0.208438mA
+ 3.068ns 0.216038mA
+ 3.07ns 0.223638mA
+ 3.072ns 0.231239mA
+ 3.074ns 0.23884mA
+ 3.076ns 0.246439mA
+ 3.078ns 0.25404mA
+ 3.08ns 0.261641mA
+ 3.082ns 0.269241mA
+ 3.084ns 0.276841mA
+ 3.086ns 0.284441mA
+ 3.088ns 0.292042mA
+ 3.09ns 0.299643mA
+ 3.092ns 0.307243mA
+ 3.094ns 0.314843mA
+ 3.096ns 0.322443mA
+ 3.098ns 0.330044mA
+ 3.1ns 0.337645mA
+ 3.102ns 0.345244mA
+ 3.104ns 0.352845mA
+ 3.106ns 0.360445mA
+ 3.108ns 0.368046mA
+ 3.11ns 0.375646mA
+ 3.112ns 0.383246mA
+ 3.114ns 0.390847mA
+ 3.116ns 0.398447mA
+ 3.118ns 0.406047mA
+ 3.12ns 0.413648mA
+ 3.122ns 0.421248mA
+ 3.124ns 0.428849mA
+ 3.126ns 0.436449mA
+ 3.128ns 0.444049mA
+ 3.13ns 0.45165mA
+ 3.132ns 0.45925mA
+ 3.134ns 0.466851mA
+ 3.136ns 0.474451mA
+ 3.138ns 0.482051mA
+ 3.14ns 0.489652mA
+ 3.142ns 0.497252mA
+ 3.144ns 0.504852mA
+ 3.146ns 0.512453mA
+ 3.148ns 0.520053mA
+ 3.15ns 0.527654mA
+ 3.152ns 0.535253mA
+ 3.154ns 0.538396mA
+ 3.156ns 0.536097mA
+ 3.158ns 0.533808mA
+ 3.16ns 0.531528mA
+ 3.162ns 0.529259mA
+ 3.164ns 0.526999mA
+ 3.166ns 0.524748mA
+ 3.168ns 0.522508mA
+ 3.17ns 0.520276mA
+ 3.172ns 0.518055mA
+ 3.174ns 0.515843mA
+ 3.176ns 0.51364mA
+ 3.178ns 0.511447mA
+ 3.18ns 0.509263mA
+ 3.182ns 0.507088mA
+ 3.184ns 0.504923mA
+ 3.186ns 0.502766mA
+ 3.188ns 0.50062mA
+ 3.19ns 0.498482mA
+ 3.192ns 0.496353mA
+ 3.194ns 0.494234mA
+ 3.196ns 0.492123mA
+ 3.198ns 0.490022mA
+ 3.2ns 0.487929mA
+ 3.202ns 0.485845mA
+ 3.204ns 0.483771mA
+ 3.206ns 0.481705mA
+ 3.208ns 0.479648mA
+ 3.21ns 0.4776mA
+ 3.212ns 0.47556mA
+ 3.214ns 0.47353mA
+ 3.216ns 0.471507mA
+ 3.218ns 0.469494mA
+ 3.22ns 0.467489mA
+ 3.222ns 0.465493mA
+ 3.224ns 0.463505mA
+ 3.226ns 0.461526mA
+ 3.228ns 0.459555mA
+ 3.23ns 0.457593mA
+ 3.232ns 0.455638mA
+ 3.234ns 0.453693mA
+ 3.236ns 0.451755mA
+ 3.238ns 0.449826mA
+ 3.24ns 0.447905mA
+ 3.242ns 0.445993mA
+ 3.244ns 0.444088mA
+ 3.246ns 0.442192mA
+ 3.248ns 0.440303mA
+ 3.25ns 0.438423mA
+ 3.252ns 0.436551mA
+ 3.254ns 0.434687mA
+ 3.256ns 0.43283mA
+ 3.258ns 0.430982mA
+ 3.26ns 0.429142mA
+ 3.262ns 0.427309mA
+ 3.264ns 0.425484mA
+ 3.266ns 0.423667mA
+ 3.268ns 0.421858mA
+ 3.27ns 0.420057mA
+ 3.272ns 0.418263mA
+ 3.274ns 0.416477mA
+ 3.276ns 0.414698mA
+ 3.278ns 0.412927mA
+ 3.28ns 0.411164mA
+ 3.282ns 0.409408mA
+ 3.284ns 0.40766mA
+ 3.286ns 0.405919mA
+ 3.288ns 0.404185mA
+ 3.29ns 0.402459mA
+ 3.292ns 0.400741mA
+ 3.294ns 0.399029mA
+ 3.296ns 0.397325mA
+ 3.298ns 0.395628mA
+ 3.3ns 0.393939mA
+ 3.302ns 0.392257mA
+ 3.304ns 0.390582mA
+ 3.306ns 0.388914mA
+ 3.308ns 0.387253mA
+ 3.31ns 0.385599mA
+ 3.312ns 0.383952mA
+ 3.314ns 0.382313mA
+ 3.316ns 0.38068mA
+ 3.318ns 0.379054mA
+ 3.32ns 0.377435mA
+ 3.322ns 0.375824mA
+ 3.324ns 0.374219mA
+ 3.326ns 0.372621mA
+ 3.328ns 0.371029mA
+ 3.33ns 0.369445mA
+ 3.332ns 0.367867mA
+ 3.334ns 0.366296mA
+ 3.336ns 0.364732mA
+ 3.338ns 0.363174mA
+ 3.34ns 0.361623mA
+ 3.342ns 0.360079mA
+ 3.344ns 0.358541mA
+ 3.346ns 0.35701mA
+ 3.348ns 0.355486mA
+ 3.35ns 0.353967mA
+ 3.352ns 0.352456mA
+ 3.354ns 0.350951mA
+ 3.356ns 0.349452mA
+ 3.358ns 0.347959mA
+ 3.36ns 0.346473mA
+ 3.362ns 0.344994mA
+ 3.364ns 0.34352mA
+ 3.366ns 0.342053mA
+ 3.368ns 0.340593mA
+ 3.37ns 0.339138mA
+ 3.372ns 0.33769mA
+ 3.374ns 0.336248mA
+ 3.376ns 0.334812mA
+ 3.378ns 0.333382mA
+ 3.38ns 0.331958mA
+ 3.382ns 0.33054mA
+ 3.384ns 0.329129mA
+ 3.386ns 0.327723mA
+ 3.388ns 0.326324mA
+ 3.39ns 0.32493mA
+ 3.392ns 0.323542mA
+ 3.394ns 0.322161mA
+ 3.396ns 0.320785mA
+ 3.398ns 0.319415mA
+ 3.4ns 0.318051mA
+ 3.402ns 0.316692mA
+ 3.404ns 0.31534mA
+ 3.406ns 0.313993mA
+ 3.408ns 0.312652mA
+ 3.41ns 0.311317mA
+ 3.412ns 0.309987mA
+ 3.414ns 0.308664mA
+ 3.416ns 0.307345mA
+ 3.418ns 0.306033mA
+ 3.42ns 0.304726mA
+ 3.422ns 0.303424mA
+ 3.424ns 0.302129mA
+ 3.426ns 0.300838mA
+ 3.428ns 0.299554mA
+ 3.43ns 0.298274mA
+ 3.432ns 0.297mA
+ 3.434ns 0.295732mA
+ 3.436ns 0.294469mA
+ 3.438ns 0.293211mA
+ 3.44ns 0.291959mA
+ 3.442ns 0.290712mA
+ 3.444ns 0.289471mA
+ 3.446ns 0.288234mA
+ 3.448ns 0.287003mA
+ 3.45ns 0.285778mA
+ 3.452ns 0.284557mA
+ 3.454ns 0.283342mA
+ 3.456ns 0.282132mA
+ 3.458ns 0.280927mA
+ 3.46ns 0.279727mA
+ 3.462ns 0.278532mA
+ 3.464ns 0.277343mA
+ 3.466ns 0.276158mA
+ 3.468ns 0.274979mA
+ 3.47ns 0.273805mA
+ 3.472ns 0.272635mA
+ 3.474ns 0.271471mA
+ 3.476ns 0.270311mA
+ 3.478ns 0.269157mA
+ 3.48ns 0.268007mA
+ 3.482ns 0.266863mA
+ 3.484ns 0.265723mA
+ 3.486ns 0.264588mA
+ 3.488ns 0.263458mA
+ 3.49ns 0.262333mA
+ 3.492ns 0.261213mA
+ 3.494ns 0.260097mA
+ 3.496ns 0.258986mA
+ 3.498ns 0.25788mA
+ 3.5ns 0.256779mA
+ 3.502ns 0.255682mA
+ 3.504ns 0.25459mA
+ 3.506ns 0.253503mA
+ 3.508ns 0.25242mA
+ 3.51ns 0.251342mA
+ 3.512ns 0.250268mA
+ 3.514ns 0.249199mA
+ 3.516ns 0.248135mA
+ 3.518ns 0.247075mA
+ 3.52ns 0.24602mA
+ 3.522ns 0.244969mA
+ 3.524ns 0.243923mA
+ 3.526ns 0.242881mA
+ 3.528ns 0.241844mA
+ 3.53ns 0.240811mA
+ 3.532ns 0.239783mA
+ 3.534ns 0.238759mA
+ 3.536ns 0.237739mA
+ 3.538ns 0.236723mA
+ 3.54ns 0.235712mA
+ 3.542ns 0.234706mA
+ 3.544ns 0.233703mA
+ 3.546ns 0.232705mA
+ 3.548ns 0.231711mA
+ 3.55ns 0mA
I4 8 0 PWL 0 0
+ 8.018ns 0mA
+ 8.02ns 0.00048641mA
+ 8.022ns 0.00810903mA
+ 8.024ns 0.0157317mA
+ 8.026ns 0.0233543mA
+ 8.028ns 0.0309769mA
+ 8.03ns 0.0385995mA
+ 8.032ns 0.0462221mA
+ 8.034ns 0.0538484mA
+ 8.036ns 0.061471mA
+ 8.038ns 0.0690936mA
+ 8.04ns 0.0767163mA
+ 8.042ns 0.0843389mA
+ 8.044ns 0.0919615mA
+ 8.046ns 0.0995841mA
+ 8.048ns 0.10721mA
+ 8.05ns 0.114833mA
+ 8.052ns 0.122456mA
+ 8.054ns 0.130078mA
+ 8.056ns 0.137701mA
+ 8.058ns 0.145323mA
+ 8.06ns 0.15295mA
+ 8.062ns 0.160572mA
+ 8.064ns 0.168195mA
+ 8.066ns 0.175818mA
+ 8.068ns 0.18344mA
+ 8.07ns 0.191063mA
+ 8.072ns 0.198685mA
+ 8.074ns 0.206312mA
+ 8.076ns 0.213934mA
+ 8.078ns 0.221557mA
+ 8.08ns 0.22918mA
+ 8.082ns 0.236802mA
+ 8.084ns 0.244425mA
+ 8.086ns 0.252051mA
+ 8.088ns 0.259674mA
+ 8.09ns 0.267296mA
+ 8.092ns 0.274919mA
+ 8.094ns 0.282542mA
+ 8.096ns 0.290164mA
+ 8.098ns 0.297787mA
+ 8.1ns 0.305413mA
+ 8.102ns 0.313036mA
+ 8.104ns 0.320658mA
+ 8.106ns 0.328281mA
+ 8.108ns 0.335904mA
+ 8.11ns 0.343526mA
+ 8.112ns 0.351152mA
+ 8.114ns 0.358775mA
+ 8.116ns 0.366398mA
+ 8.118ns 0.37402mA
+ 8.12ns 0.381643mA
+ 8.122ns 0.389266mA
+ 8.124ns 0.396888mA
+ 8.126ns 0.404514mA
+ 8.128ns 0.412137mA
+ 8.13ns 0.41976mA
+ 8.132ns 0.427382mA
+ 8.134ns 0.435005mA
+ 8.136ns 0.442628mA
+ 8.138ns 0.45025mA
+ 8.14ns 0.457876mA
+ 8.142ns 0.465499mA
+ 8.144ns 0.473122mA
+ 8.146ns 0.480744mA
+ 8.148ns 0.488367mA
+ 8.15ns 0.49599mA
+ 8.152ns 0.503616mA
+ 8.154ns 0.511238mA
+ 8.156ns 0.518861mA
+ 8.158ns 0.526484mA
+ 8.16ns 0.534106mA
+ 8.162ns 0.540734mA
+ 8.164ns 0.538424mA
+ 8.166ns 0.536123mA
+ 8.168ns 0.533834mA
+ 8.17ns 0.531554mA
+ 8.172ns 0.529283mA
+ 8.174ns 0.527023mA
+ 8.176ns 0.524772mA
+ 8.178ns 0.522529mA
+ 8.18ns 0.520298mA
+ 8.182ns 0.518075mA
+ 8.184ns 0.515863mA
+ 8.186ns 0.513659mA
+ 8.188ns 0.511466mA
+ 8.19ns 0.509281mA
+ 8.192ns 0.507105mA
+ 8.194ns 0.504939mA
+ 8.196ns 0.502782mA
+ 8.198ns 0.500635mA
+ 8.2ns 0.498497mA
+ 8.202ns 0.496368mA
+ 8.204ns 0.494246mA
+ 8.206ns 0.492135mA
+ 8.208ns 0.490034mA
+ 8.21ns 0.487941mA
+ 8.212ns 0.485857mA
+ 8.214ns 0.483781mA
+ 8.216ns 0.481715mA
+ 8.218ns 0.479657mA
+ 8.22ns 0.477608mA
+ 8.222ns 0.475568mA
+ 8.224ns 0.473537mA
+ 8.226ns 0.471514mA
+ 8.228ns 0.4695mA
+ 8.23ns 0.467495mA
+ 8.232ns 0.465497mA
+ 8.234ns 0.463509mA
+ 8.236ns 0.461529mA
+ 8.238ns 0.459558mA
+ 8.24ns 0.457595mA
+ 8.242ns 0.455641mA
+ 8.244ns 0.453694mA
+ 8.246ns 0.451756mA
+ 8.248ns 0.449826mA
+ 8.25ns 0.447905mA
+ 8.252ns 0.445992mA
+ 8.254ns 0.444087mA
+ 8.256ns 0.44219mA
+ 8.258ns 0.440301mA
+ 8.26ns 0.43842mA
+ 8.262ns 0.436547mA
+ 8.264ns 0.434683mA
+ 8.266ns 0.432826mA
+ 8.268ns 0.430977mA
+ 8.27ns 0.429136mA
+ 8.272ns 0.427303mA
+ 8.274ns 0.425478mA
+ 8.276ns 0.42366mA
+ 8.278ns 0.421851mA
+ 8.28ns 0.420049mA
+ 8.282ns 0.418255mA
+ 8.284ns 0.416467mA
+ 8.286ns 0.414689mA
+ 8.288ns 0.412917mA
+ 8.29ns 0.411154mA
+ 8.292ns 0.409398mA
+ 8.294ns 0.407649mA
+ 8.296ns 0.405907mA
+ 8.298ns 0.404173mA
+ 8.3ns 0.402447mA
+ 8.302ns 0.400728mA
+ 8.304ns 0.399016mA
+ 8.306ns 0.397312mA
+ 8.308ns 0.395615mA
+ 8.31ns 0.393924mA
+ 8.312ns 0.392242mA
+ 8.314ns 0.390566mA
+ 8.316ns 0.388898mA
+ 8.318ns 0.387237mA
+ 8.32ns 0.385583mA
+ 8.322ns 0.383936mA
+ 8.324ns 0.382295mA
+ 8.326ns 0.380662mA
+ 8.328ns 0.379036mA
+ 8.33ns 0.377417mA
+ 8.332ns 0.375805mA
+ 8.334ns 0.3742mA
+ 8.336ns 0.372601mA
+ 8.338ns 0.371009mA
+ 8.34ns 0.369424mA
+ 8.342ns 0.367847mA
+ 8.344ns 0.366275mA
+ 8.346ns 0.364711mA
+ 8.348ns 0.363153mA
+ 8.35ns 0.361601mA
+ 8.352ns 0.360056mA
+ 8.354ns 0.358519mA
+ 8.356ns 0.356987mA
+ 8.358ns 0.355462mA
+ 8.36ns 0.353944mA
+ 8.362ns 0.352431mA
+ 8.364ns 0.350926mA
+ 8.366ns 0.349427mA
+ 8.368ns 0.347934mA
+ 8.37ns 0.346448mA
+ 8.372ns 0.344968mA
+ 8.374ns 0.343495mA
+ 8.376ns 0.342027mA
+ 8.378ns 0.340566mA
+ 8.38ns 0.339111mA
+ 8.382ns 0.337663mA
+ 8.384ns 0.33622mA
+ 8.386ns 0.334784mA
+ 8.388ns 0.333353mA
+ 8.39ns 0.33193mA
+ 8.392ns 0.330512mA
+ 8.394ns 0.3291mA
+ 8.396ns 0.327694mA
+ 8.398ns 0.326294mA
+ 8.4ns 0.324901mA
+ 8.402ns 0.323512mA
+ 8.404ns 0.32213mA
+ 8.406ns 0.320754mA
+ 8.408ns 0.319384mA
+ 8.41ns 0.31802mA
+ 8.412ns 0.316661mA
+ 8.414ns 0.315309mA
+ 8.416ns 0.313961mA
+ 8.418ns 0.31262mA
+ 8.42ns 0.311285mA
+ 8.422ns 0.309955mA
+ 8.424ns 0.308631mA
+ 8.426ns 0.307313mA
+ 8.428ns 0.305999mA
+ 8.43ns 0.304692mA
+ 8.432ns 0.303391mA
+ 8.434ns 0.302095mA
+ 8.436ns 0.300804mA
+ 8.438ns 0.299519mA
+ 8.44ns 0.29824mA
+ 8.442ns 0.296965mA
+ 8.444ns 0.295697mA
+ 8.446ns 0.294434mA
+ 8.448ns 0.293176mA
+ 8.45ns 0.291924mA
+ 8.452ns 0.290677mA
+ 8.454ns 0.289434mA
+ 8.456ns 0.288198mA
+ 8.458ns 0.286967mA
+ 8.46ns 0.285741mA
+ 8.462ns 0.284521mA
+ 8.464ns 0.283305mA
+ 8.466ns 0.282095mA
+ 8.468ns 0.280889mA
+ 8.47ns 0.27969mA
+ 8.472ns 0.278495mA
+ 8.474ns 0.277305mA
+ 8.476ns 0.276121mA
+ 8.478ns 0.274941mA
+ 8.48ns 0.273766mA
+ 8.482ns 0.272597mA
+ 8.484ns 0.271432mA
+ 8.486ns 0.270273mA
+ 8.488ns 0.269118mA
+ 8.49ns 0.267969mA
+ 8.492ns 0.266824mA
+ 8.494ns 0.265683mA
+ 8.496ns 0.264549mA
+ 8.498ns 0.263418mA
+ 8.5ns 0.262293mA
+ 8.502ns 0.261173mA
+ 8.504ns 0.260057mA
+ 8.506ns 0.258946mA
+ 8.508ns 0.257839mA
+ 8.51ns 0.256738mA
+ 8.512ns 0.255641mA
+ 8.514ns 0.254549mA
+ 8.516ns 0.253462mA
+ 8.518ns 0.252379mA
+ 8.52ns 0.2513mA
+ 8.522ns 0.250227mA
+ 8.524ns 0.249158mA
+ 8.526ns 0.248094mA
+ 8.528ns 0.247034mA
+ 8.53ns 0.245979mA
+ 8.532ns 0.244928mA
+ 8.534ns 0.243881mA
+ 8.536ns 0.242839mA
+ 8.538ns 0.241802mA
+ 8.54ns 0.240769mA
+ 8.542ns 0.23974mA
+ 8.544ns 0.238716mA
+ 8.546ns 0.237696mA
+ 8.548ns 0.236681mA
+ 8.55ns 0.235669mA
+ 8.552ns 0.234663mA
+ 8.554ns 0.23366mA
+ 8.556ns 0.232662mA
+ 8.558ns 0mA
I5 9 0 PWL 0 0
+ 0.52ns 0mA
+ 0.522ns 0.00317192mA
+ 0.524ns 0.01084mA
+ 0.526ns 0.018508mA
+ 0.528ns 0.0261759mA
+ 0.53ns 0.033844mA
+ 0.532ns 0.0415119mA
+ 0.534ns 0.04918mA
+ 0.536ns 0.0568479mA
+ 0.538ns 0.0645161mA
+ 0.54ns 0.072184mA
+ 0.542ns 0.0798521mA
+ 0.544ns 0.08752mA
+ 0.546ns 0.0951879mA
+ 0.548ns 0.102856mA
+ 0.55ns 0.110524mA
+ 0.552ns 0.118192mA
+ 0.554ns 0.12586mA
+ 0.556ns 0.133528mA
+ 0.558ns 0.141196mA
+ 0.56ns 0.148864mA
+ 0.562ns 0.156532mA
+ 0.564ns 0.1642mA
+ 0.566ns 0.171868mA
+ 0.568ns 0.179536mA
+ 0.57ns 0.187204mA
+ 0.572ns 0.194872mA
+ 0.574ns 0.20254mA
+ 0.576ns 0.210208mA
+ 0.578ns 0.217876mA
+ 0.58ns 0.225544mA
+ 0.582ns 0.233212mA
+ 0.584ns 0.24088mA
+ 0.586ns 0.248548mA
+ 0.588ns 0.256216mA
+ 0.59ns 0.263884mA
+ 0.592ns 0.271552mA
+ 0.594ns 0.27922mA
+ 0.596ns 0.286888mA
+ 0.598ns 0.294556mA
+ 0.6ns 0.302224mA
+ 0.602ns 0.309892mA
+ 0.604ns 0.31756mA
+ 0.606ns 0.325228mA
+ 0.608ns 0.332896mA
+ 0.61ns 0.340564mA
+ 0.612ns 0.348232mA
+ 0.614ns 0.3559mA
+ 0.616ns 0.363568mA
+ 0.618ns 0.371236mA
+ 0.62ns 0.378904mA
+ 0.622ns 0.386572mA
+ 0.624ns 0.39424mA
+ 0.626ns 0.401908mA
+ 0.628ns 0.409576mA
+ 0.63ns 0.417244mA
+ 0.632ns 0.424912mA
+ 0.634ns 0.43258mA
+ 0.636ns 0.440248mA
+ 0.638ns 0.447916mA
+ 0.64ns 0.455584mA
+ 0.642ns 0.463252mA
+ 0.644ns 0.47092mA
+ 0.646ns 0.478588mA
+ 0.648ns 0.486256mA
+ 0.65ns 0.493924mA
+ 0.652ns 0.501592mA
+ 0.654ns 0.50926mA
+ 0.656ns 0.516928mA
+ 0.658ns 0.524596mA
+ 0.66ns 0.532264mA
+ 0.662ns 0.539932mA
+ 0.664ns 0.540608mA
+ 0.666ns 0.538296mA
+ 0.668ns 0.535993mA
+ 0.67ns 0.533701mA
+ 0.672ns 0.531418mA
+ 0.674ns 0.529145mA
+ 0.676ns 0.526882mA
+ 0.678ns 0.524629mA
+ 0.68ns 0.522385mA
+ 0.682ns 0.52015mA
+ 0.684ns 0.517926mA
+ 0.686ns 0.51571mA
+ 0.688ns 0.513505mA
+ 0.69ns 0.511308mA
+ 0.692ns 0.509121mA
+ 0.694ns 0.506944mA
+ 0.696ns 0.504776mA
+ 0.698ns 0.502617mA
+ 0.7ns 0.500467mA
+ 0.702ns 0.498326mA
+ 0.704ns 0.496195mA
+ 0.706ns 0.494073mA
+ 0.708ns 0.491959mA
+ 0.71ns 0.489855mA
+ 0.712ns 0.48776mA
+ 0.714ns 0.485674mA
+ 0.716ns 0.483597mA
+ 0.718ns 0.481528mA
+ 0.72ns 0.479469mA
+ 0.722ns 0.477418mA
+ 0.724ns 0.475376mA
+ 0.726ns 0.473342mA
+ 0.728ns 0.471318mA
+ 0.73ns 0.469302mA
+ 0.732ns 0.467295mA
+ 0.734ns 0.465296mA
+ 0.736ns 0.463306mA
+ 0.738ns 0.461324mA
+ 0.74ns 0.459351mA
+ 0.742ns 0.457386mA
+ 0.744ns 0.45543mA
+ 0.746ns 0.453482mA
+ 0.748ns 0.451542mA
+ 0.75ns 0.449611mA
+ 0.752ns 0.447688mA
+ 0.754ns 0.445773mA
+ 0.756ns 0.443866mA
+ 0.758ns 0.441968mA
+ 0.76ns 0.440077mA
+ 0.762ns 0.438195mA
+ 0.764ns 0.436321mA
+ 0.766ns 0.434454mA
+ 0.768ns 0.432596mA
+ 0.77ns 0.430746mA
+ 0.772ns 0.428903mA
+ 0.774ns 0.427069mA
+ 0.776ns 0.425242mA
+ 0.778ns 0.423423mA
+ 0.78ns 0.421612mA
+ 0.782ns 0.419809mA
+ 0.784ns 0.418013mA
+ 0.786ns 0.416225mA
+ 0.788ns 0.414445mA
+ 0.79ns 0.412672mA
+ 0.792ns 0.410907mA
+ 0.794ns 0.409149mA
+ 0.796ns 0.407399mA
+ 0.798ns 0.405657mA
+ 0.8ns 0.403922mA
+ 0.802ns 0.402194mA
+ 0.804ns 0.400474mA
+ 0.806ns 0.398761mA
+ 0.808ns 0.397055mA
+ 0.81ns 0.395357mA
+ 0.812ns 0.393665mA
+ 0.814ns 0.391982mA
+ 0.816ns 0.390305mA
+ 0.818ns 0.388635mA
+ 0.82ns 0.386973mA
+ 0.822ns 0.385318mA
+ 0.824ns 0.38367mA
+ 0.826ns 0.382029mA
+ 0.828ns 0.380394mA
+ 0.83ns 0.378767mA
+ 0.832ns 0.377147mA
+ 0.834ns 0.375534mA
+ 0.836ns 0.373928mA
+ 0.838ns 0.372328mA
+ 0.84ns 0.370736mA
+ 0.842ns 0.36915mA
+ 0.844ns 0.367571mA
+ 0.846ns 0.365999mA
+ 0.848ns 0.364433mA
+ 0.85ns 0.362874mA
+ 0.852ns 0.361322mA
+ 0.854ns 0.359776mA
+ 0.856ns 0.358237mA
+ 0.858ns 0.356705mA
+ 0.86ns 0.355179mA
+ 0.862ns 0.35366mA
+ 0.864ns 0.352147mA
+ 0.866ns 0.350641mA
+ 0.868ns 0.349141mA
+ 0.87ns 0.347648mA
+ 0.872ns 0.346161mA
+ 0.874ns 0.34468mA
+ 0.876ns 0.343205mA
+ 0.878ns 0.341737mA
+ 0.88ns 0.340276mA
+ 0.882ns 0.33882mA
+ 0.884ns 0.337371mA
+ 0.886ns 0.335928mA
+ 0.888ns 0.334491mA
+ 0.89ns 0.33306mA
+ 0.892ns 0.331635mA
+ 0.894ns 0.330217mA
+ 0.896ns 0.328804mA
+ 0.898ns 0.327398mA
+ 0.9ns 0.325997mA
+ 0.902ns 0.324603mA
+ 0.904ns 0.323214mA
+ 0.906ns 0.321832mA
+ 0.908ns 0.320455mA
+ 0.91ns 0.319084mA
+ 0.912ns 0.317719mA
+ 0.914ns 0.31636mA
+ 0.916ns 0.315007mA
+ 0.918ns 0.313659mA
+ 0.92ns 0.312318mA
+ 0.922ns 0.310982mA
+ 0.924ns 0.309651mA
+ 0.926ns 0.308327mA
+ 0.928ns 0.307008mA
+ 0.93ns 0.305695mA
+ 0.932ns 0.304387mA
+ 0.934ns 0.303085mA
+ 0.936ns 0.301788mA
+ 0.938ns 0.300498mA
+ 0.94ns 0.299212mA
+ 0.942ns 0.297932mA
+ 0.944ns 0.296658mA
+ 0.946ns 0.295389mA
+ 0.948ns 0.294125mA
+ 0.95ns 0.292867mA
+ 0.952ns 0.291614mA
+ 0.954ns 0.290367mA
+ 0.956ns 0.289125mA
+ 0.958ns 0.287888mA
+ 0.96ns 0.286656mA
+ 0.962ns 0.28543mA
+ 0.964ns 0.284209mA
+ 0.966ns 0.282993mA
+ 0.968ns 0.281783mA
+ 0.97ns 0.280577mA
+ 0.972ns 0.279377mA
+ 0.974ns 0.278182mA
+ 0.976ns 0.276992mA
+ 0.978ns 0.275807mA
+ 0.98ns 0.274627mA
+ 0.982ns 0.273453mA
+ 0.984ns 0.272283mA
+ 0.986ns 0.271118mA
+ 0.988ns 0.269958mA
+ 0.99ns 0.268803mA
+ 0.992ns 0.267654mA
+ 0.994ns 0.266509mA
+ 0.996ns 0.265368mA
+ 0.998ns 0.264233mA
+ 1ns 0.263103mA
+ 1.002ns 0.261977mA
+ 1.004ns 0.260857mA
+ 1.006ns 0.259741mA
+ 1.008ns 0.25863mA
+ 1.01ns 0.257523mA
+ 1.012ns 0.256422mA
+ 1.014ns 0.255325mA
+ 1.016ns 0.254233mA
+ 1.018ns 0.253145mA
+ 1.02ns 0.252062mA
+ 1.022ns 0.250984mA
+ 1.024ns 0.24991mA
+ 1.026ns 0.248841mA
+ 1.028ns 0.247777mA
+ 1.03ns 0.246717mA
+ 1.032ns 0.245661mA
+ 1.034ns 0.24461mA
+ 1.036ns 0.243564mA
+ 1.038ns 0.242522mA
+ 1.04ns 0.241484mA
+ 1.042ns 0.240451mA
+ 1.044ns 0.239423mA
+ 1.046ns 0.238399mA
+ 1.048ns 0.237379mA
+ 1.05ns 0.236363mA
+ 1.052ns 0.235352mA
+ 1.054ns 0.234345mA
+ 1.056ns 0.233343mA
+ 1.058ns 0mA
I6 10 0 PWL 0 0
+ 0.138ns 0mA
+ 0.14ns 0.000403226mA
+ 0.142ns 0.00490237mA
+ 0.144ns 0.00940151mA
+ 0.146ns 0.0139006mA
+ 0.148ns 0.0183998mA
+ 0.15ns 0.0228989mA
+ 0.152ns 0.027398mA
+ 0.154ns 0.0318972mA
+ 0.156ns 0.0363963mA
+ 0.158ns 0.0408954mA
+ 0.16ns 0.0453946mA
+ 0.162ns 0.0498937mA
+ 0.164ns 0.0543928mA
+ 0.166ns 0.058892mA
+ 0.168ns 0.0633911mA
+ 0.17ns 0.0678902mA
+ 0.172ns 0.0723894mA
+ 0.174ns 0.0768885mA
+ 0.176ns 0.0813876mA
+ 0.178ns 0.0858867mA
+ 0.18ns 0.0903859mA
+ 0.182ns 0.094885mA
+ 0.184ns 0.0993842mA
+ 0.186ns 0.103883mA
+ 0.188ns 0.108382mA
+ 0.19ns 0.112882mA
+ 0.192ns 0.117381mA
+ 0.194ns 0.115238mA
+ 0.196ns 0.11201mA
+ 0.198ns 0.108872mA
+ 0.2ns 0.105822mA
+ 0.202ns 0.102857mA
+ 0.204ns 0.0999753mA
+ 0.206ns 0.0971743mA
+ 0.208ns 0.0944518mA
+ 0.21ns 0.0918056mA
+ 0.212ns 0.0892335mA
+ 0.214ns 0.0867334mA
+ 0.216ns 0.0843034mA
+ 0.218ns 0.0819414mA
+ 0.22ns 0.0796456mA
+ 0.222ns 0.0774141mA
+ 0.224ns 0.0752451mA
+ 0.226ns 0.0731368mA
+ 0.228ns 0.0710876mA
+ 0.23ns 0.0690959mA
+ 0.232ns 0.0671599mA
+ 0.234ns 0.0652781mA
+ 0.236ns 0.0634491mA
+ 0.238ns 0.0616713mA
+ 0.24ns 0.0599432mA
+ 0.242ns 0.0582636mA
+ 0.244ns 0.0566311mA
+ 0.246ns 0.0550443mA
+ 0.248ns 0.0535019mA
+ 0.25ns 0.0520028mA
+ 0.252ns 0.0505456mA
+ 0.254ns 0.0491293mA
+ 0.256ns 0.0477526mA
+ 0.258ns 0.0464145mA
+ 0.26ns 0.0451139mA
+ 0.262ns 0.0438497mA
+ 0.264ns 0.042621mA
+ 0.266ns 0.0414266mA
+ 0.268ns 0mA
+ 5.138ns 0mA
+ 5.14ns 0.000403259mA
+ 5.142ns 0.00490314mA
+ 5.144ns 0.00940194mA
+ 5.146ns 0.0139008mA
+ 5.148ns 0.0184006mA
+ 5.15ns 0.0228994mA
+ 5.152ns 0.0273982mA
+ 5.154ns 0.0318981mA
+ 5.156ns 0.0363969mA
+ 5.158ns 0.0408957mA
+ 5.16ns 0.0453945mA
+ 5.162ns 0.0498944mA
+ 5.164ns 0.0543932mA
+ 5.166ns 0.058892mA
+ 5.168ns 0.0633919mA
+ 5.17ns 0.0678907mA
+ 5.172ns 0.0723895mA
+ 5.174ns 0.0768894mA
+ 5.176ns 0.0813882mA
+ 5.178ns 0.085887mA
+ 5.18ns 0.0903858mA
+ 5.182ns 0.0948857mA
+ 5.184ns 0.0993845mA
+ 5.186ns 0.103883mA
+ 5.188ns 0.108383mA
+ 5.19ns 0.112882mA
+ 5.192ns 0.117381mA
+ 5.194ns 0.115238mA
+ 5.196ns 0.112009mA
+ 5.198ns 0.108872mA
+ 5.2ns 0.105821mA
+ 5.202ns 0.102857mA
+ 5.204ns 0.0999751mA
+ 5.206ns 0.0971743mA
+ 5.208ns 0.0944514mA
+ 5.21ns 0.0918054mA
+ 5.212ns 0.0892334mA
+ 5.214ns 0.086733mA
+ 5.216ns 0.0843031mA
+ 5.218ns 0.0819413mA
+ 5.22ns 0.0796451mA
+ 5.222ns 0.0774138mA
+ 5.224ns 0.0752449mA
+ 5.226ns 0.0731369mA
+ 5.228ns 0.0710873mA
+ 5.23ns 0.0690957mA
+ 5.232ns 0.0671599mA
+ 5.234ns 0.0652778mA
+ 5.236ns 0.0634489mA
+ 5.238ns 0.0616712mA
+ 5.24ns 0.0599429mA
+ 5.242ns 0.0582634mA
+ 5.244ns 0.056631mA
+ 5.246ns 0.0550439mA
+ 5.248ns 0.0535017mA
+ 5.25ns 0.0520027mA
+ 5.252ns 0.0505456mA
+ 5.254ns 0.049129mA
+ 5.256ns 0.0477525mA
+ 5.258ns 0.0464145mA
+ 5.26ns 0.0451137mA
+ 5.262ns 0.0438496mA
+ 5.264ns 0.0426209mA
+ 5.266ns 0.0414264mA
+ 5.268ns 0mA
I7 11 0 PWL 0 0
+ 0.144ns 0mA
+ 0.146ns 4.08793e-05mA
+ 0.148ns 0.00428426mA
+ 0.15ns 0.00852768mA
+ 0.152ns 0.0127711mA
+ 0.154ns 0.0170145mA
+ 0.156ns 0.0212579mA
+ 0.158ns 0.0255013mA
+ 0.16ns 0.0297447mA
+ 0.162ns 0.0339881mA
+ 0.164ns 0.0382315mA
+ 0.166ns 0.0424749mA
+ 0.168ns 0.0467183mA
+ 0.17ns 0.0509617mA
+ 0.172ns 0.0552051mA
+ 0.174ns 0.0594485mA
+ 0.176ns 0.063692mA
+ 0.178ns 0.0679353mA
+ 0.18ns 0.0721788mA
+ 0.182ns 0.0764222mA
+ 0.184ns 0.0806656mA
+ 0.186ns 0.084909mA
+ 0.188ns 0.0891524mA
+ 0.19ns 0.0933958mA
+ 0.192ns 0.0976392mA
+ 0.194ns 0.101883mA
+ 0.196ns 0.106126mA
+ 0.198ns 0.110369mA
+ 0.2ns 0.114613mA
+ 0.202ns 0.118856mA
+ 0.204ns 0.1231mA
+ 0.206ns 0.127343mA
+ 0.208ns 0.131586mA
+ 0.21ns 0.13583mA
+ 0.212ns 0.137603mA
+ 0.214ns 0.134826mA
+ 0.216ns 0.132106mA
+ 0.218ns 0.12944mA
+ 0.22ns 0.126828mA
+ 0.222ns 0.124269mA
+ 0.224ns 0.121762mA
+ 0.226ns 0.119305mA
+ 0.228ns 0.116897mA
+ 0.23ns 0.114538mA
+ 0.232ns 0.112227mA
+ 0.234ns 0.109963mA
+ 0.236ns 0.107744mA
+ 0.238ns 0.10557mA
+ 0.24ns 0.103439mA
+ 0.242ns 0.101352mA
+ 0.244ns 0.0993067mA
+ 0.246ns 0.0973028mA
+ 0.248ns 0.0953393mA
+ 0.25ns 0.0934154mA
+ 0.252ns 0.0915303mA
+ 0.254ns 0.0896832mA
+ 0.256ns 0.0878735mA
+ 0.258ns 0.0861002mA
+ 0.26ns 0.0843627mA
+ 0.262ns 0.0826602mA
+ 0.264ns 0.0809921mA
+ 0.266ns 0.0793577mA
+ 0.268ns 0.0777562mA
+ 0.27ns 0.076187mA
+ 0.272ns 0.0746495mA
+ 0.274ns 0.0731431mA
+ 0.276ns 0.071667mA
+ 0.278ns 0.0702206mA
+ 0.28ns 0.0688035mA
+ 0.282ns 0.067415mA
+ 0.284ns 0.0660545mA
+ 0.286ns 0.0647214mA
+ 0.288ns 0.0634153mA
+ 0.29ns 0.0621354mA
+ 0.292ns 0.0608814mA
+ 0.294ns 0.0596528mA
+ 0.296ns 0.0584489mA
+ 0.298ns 0.0572692mA
+ 0.3ns 0.0561134mA
+ 0.302ns 0.0549809mA
+ 0.304ns 0.0538713mA
+ 0.306ns 0.0527841mA
+ 0.308ns 0.0517187mA
+ 0.31ns 0.0506749mA
+ 0.312ns 0mA
+ 7.644ns 0mA
+ 7.646ns 4.08793e-05mA
+ 7.648ns 0.00428499mA
+ 7.65ns 0.00852809mA
+ 7.652ns 0.0127712mA
+ 7.654ns 0.0170153mA
+ 7.656ns 0.0212584mA
+ 7.658ns 0.0255015mA
+ 7.66ns 0.0297446mA
+ 7.662ns 0.0339887mA
+ 7.664ns 0.0382318mA
+ 7.666ns 0.0424749mA
+ 7.668ns 0.046719mA
+ 7.67ns 0.0509621mA
+ 7.672ns 0.0552052mA
+ 7.674ns 0.0594493mA
+ 7.676ns 0.0636924mA
+ 7.678ns 0.0679355mA
+ 7.68ns 0.0721796mA
+ 7.682ns 0.0764227mA
+ 7.684ns 0.0806658mA
+ 7.686ns 0.0849089mA
+ 7.688ns 0.089153mA
+ 7.69ns 0.0933961mA
+ 7.692ns 0.0976392mA
+ 7.694ns 0.101883mA
+ 7.696ns 0.106126mA
+ 7.698ns 0.11037mA
+ 7.7ns 0.114614mA
+ 7.702ns 0.118857mA
+ 7.704ns 0.1231mA
+ 7.706ns 0.127343mA
+ 7.708ns 0.131587mA
+ 7.71ns 0.13583mA
+ 7.712ns 0.137603mA
+ 7.714ns 0.134826mA
+ 7.716ns 0.132106mA
+ 7.718ns 0.12944mA
+ 7.72ns 0.126828mA
+ 7.722ns 0.124269mA
+ 7.724ns 0.121762mA
+ 7.726ns 0.119304mA
+ 7.728ns 0.116897mA
+ 7.73ns 0.114538mA
+ 7.732ns 0.112227mA
+ 7.734ns 0.109962mA
+ 7.736ns 0.107744mA
+ 7.738ns 0.10557mA
+ 7.74ns 0.103439mA
+ 7.742ns 0.101352mA
+ 7.744ns 0.0993067mA
+ 7.746ns 0.0973024mA
+ 7.748ns 0.0953391mA
+ 7.75ns 0.0934153mA
+ 7.752ns 0.0915304mA
+ 7.754ns 0.089683mA
+ 7.756ns 0.0878733mA
+ 7.758ns 0.0861002mA
+ 7.76ns 0.0843624mA
+ 7.762ns 0.0826601mA
+ 7.764ns 0.0809921mA
+ 7.766ns 0.0793574mA
+ 7.768ns 0.077756mA
+ 7.77ns 0.076187mA
+ 7.772ns 0.0746492mA
+ 7.774ns 0.0731429mA
+ 7.776ns 0.0716669mA
+ 7.778ns 0.0702207mA
+ 7.78ns 0.0688033mA
+ 7.782ns 0.0674149mA
+ 7.784ns 0.0660545mA
+ 7.786ns 0.0647212mA
+ 7.788ns 0.0634151mA
+ 7.79ns 0.0621354mA
+ 7.792ns 0.0608812mA
+ 7.794ns 0.0596526mA
+ 7.796ns 0.0584488mA
+ 7.798ns 0.0572693mA
+ 7.8ns 0.0561133mA
+ 7.802ns 0.0549809mA
+ 7.804ns 0.0538713mA
+ 7.806ns 0.0527839mA
+ 7.808ns 0.0517187mA
+ 7.81ns 0.0506749mA
+ 7.812ns 0mA
I8 12 0 PWL 0 0
+ 5.522ns 0mA
+ 5.524ns 0.00521549mA
+ 5.526ns 0.012859mA
+ 5.528ns 0.0205025mA
+ 5.53ns 0.0281478mA
+ 5.532ns 0.0357913mA
+ 5.534ns 0.0434347mA
+ 5.536ns 0.0510801mA
+ 5.538ns 0.0587235mA
+ 5.54ns 0.066367mA
+ 5.542ns 0.0740123mA
+ 5.544ns 0.0816558mA
+ 5.546ns 0.0892993mA
+ 5.548ns 0.0969428mA
+ 5.55ns 0.104588mA
+ 5.552ns 0.112232mA
+ 5.554ns 0.119875mA
+ 5.556ns 0.12752mA
+ 5.558ns 0.135164mA
+ 5.56ns 0.142807mA
+ 5.562ns 0.150453mA
+ 5.564ns 0.158096mA
+ 5.566ns 0.16574mA
+ 5.568ns 0.173383mA
+ 5.57ns 0.181028mA
+ 5.572ns 0.188672mA
+ 5.574ns 0.196315mA
+ 5.576ns 0.203961mA
+ 5.578ns 0.211604mA
+ 5.58ns 0.219248mA
+ 5.582ns 0.226893mA
+ 5.584ns 0.234536mA
+ 5.586ns 0.24218mA
+ 5.588ns 0.249825mA
+ 5.59ns 0.257469mA
+ 5.592ns 0.265112mA
+ 5.594ns 0.272756mA
+ 5.596ns 0.280401mA
+ 5.598ns 0.288045mA
+ 5.6ns 0.295688mA
+ 5.602ns 0.303333mA
+ 5.604ns 0.310977mA
+ 5.606ns 0.31862mA
+ 5.608ns 0.326266mA
+ 5.61ns 0.333909mA
+ 5.612ns 0.341553mA
+ 5.614ns 0.349196mA
+ 5.616ns 0.356841mA
+ 5.618ns 0.364485mA
+ 5.62ns 0.372128mA
+ 5.622ns 0.379774mA
+ 5.624ns 0.387417mA
+ 5.626ns 0.395061mA
+ 5.628ns 0.402706mA
+ 5.63ns 0.410349mA
+ 5.632ns 0.417993mA
+ 5.634ns 0.425638mA
+ 5.636ns 0.433282mA
+ 5.638ns 0.440925mA
+ 5.64ns 0.448569mA
+ 5.642ns 0.456214mA
+ 5.644ns 0.463858mA
+ 5.646ns 0.471501mA
+ 5.648ns 0.479146mA
+ 5.65ns 0.48679mA
+ 5.652ns 0.494433mA
+ 5.654ns 0.502079mA
+ 5.656ns 0.509722mA
+ 5.658ns 0.517366mA
+ 5.66ns 0.525009mA
+ 5.662ns 0.532654mA
+ 5.664ns 0.540298mA
+ 5.666ns 0.547941mA
+ 5.668ns 0.550053mA
+ 5.67ns 0.547648mA
+ 5.672ns 0.545255mA
+ 5.674ns 0.542871mA
+ 5.676ns 0.540498mA
+ 5.678ns 0.538135mA
+ 5.68ns 0.535782mA
+ 5.682ns 0.533441mA
+ 5.684ns 0.531109mA
+ 5.686ns 0.528787mA
+ 5.688ns 0.526475mA
+ 5.69ns 0.524174mA
+ 5.692ns 0.521883mA
+ 5.694ns 0.519601mA
+ 5.696ns 0.51733mA
+ 5.698ns 0.515069mA
+ 5.7ns 0.512817mA
+ 5.702ns 0.510575mA
+ 5.704ns 0.508343mA
+ 5.706ns 0.506121mA
+ 5.708ns 0.503908mA
+ 5.71ns 0.501706mA
+ 5.712ns 0.499513mA
+ 5.714ns 0.497329mA
+ 5.716ns 0.495155mA
+ 5.718ns 0.49299mA
+ 5.72ns 0.490835mA
+ 5.722ns 0.48869mA
+ 5.724ns 0.486553mA
+ 5.726ns 0.484426mA
+ 5.728ns 0.482309mA
+ 5.73ns 0.4802mA
+ 5.732ns 0.478101mA
+ 5.734ns 0.476011mA
+ 5.736ns 0.47393mA
+ 5.738ns 0.471858mA
+ 5.74ns 0.469795mA
+ 5.742ns 0.467742mA
+ 5.744ns 0.465697mA
+ 5.746ns 0.463661mA
+ 5.748ns 0.461634mA
+ 5.75ns 0.459616mA
+ 5.752ns 0.457607mA
+ 5.754ns 0.455607mA
+ 5.756ns 0.453615mA
+ 5.758ns 0.451632mA
+ 5.76ns 0.449657mA
+ 5.762ns 0.447692mA
+ 5.764ns 0.445735mA
+ 5.766ns 0.443786mA
+ 5.768ns 0.441846mA
+ 5.77ns 0.439915mA
+ 5.772ns 0.437991mA
+ 5.774ns 0.436077mA
+ 5.776ns 0.43417mA
+ 5.778ns 0.432272mA
+ 5.78ns 0.430382mA
+ 5.782ns 0.428501mA
+ 5.784ns 0.426628mA
+ 5.786ns 0.424763mA
+ 5.788ns 0.422906mA
+ 5.79ns 0.421057mA
+ 5.792ns 0.419216mA
+ 5.794ns 0.417384mA
+ 5.796ns 0.415559mA
+ 5.798ns 0.413743mA
+ 5.8ns 0.411934mA
+ 5.802ns 0.410133mA
+ 5.804ns 0.40834mA
+ 5.806ns 0.406555mA
+ 5.808ns 0.404777mA
+ 5.81ns 0.403008mA
+ 5.812ns 0.401246mA
+ 5.814ns 0.399492mA
+ 5.816ns 0.397746mA
+ 5.818ns 0.396006mA
+ 5.82ns 0.394275mA
+ 5.822ns 0.392552mA
+ 5.824ns 0.390836mA
+ 5.826ns 0.389127mA
+ 5.828ns 0.387426mA
+ 5.83ns 0.385732mA
+ 5.832ns 0.384046mA
+ 5.834ns 0.382367mA
+ 5.836ns 0.380695mA
+ 5.838ns 0.379031mA
+ 5.84ns 0.377374mA
+ 5.842ns 0.375724mA
+ 5.844ns 0.374082mA
+ 5.846ns 0.372446mA
+ 5.848ns 0.370818mA
+ 5.85ns 0.369197mA
+ 5.852ns 0.367583mA
+ 5.854ns 0.365976mA
+ 5.856ns 0.364376mA
+ 5.858ns 0.362783mA
+ 5.86ns 0.361197mA
+ 5.862ns 0.359618mA
+ 5.864ns 0.358045mA
+ 5.866ns 0.35648mA
+ 5.868ns 0.354922mA
+ 5.87ns 0.35337mA
+ 5.872ns 0.351825mA
+ 5.874ns 0.350287mA
+ 5.876ns 0.348756mA
+ 5.878ns 0.347231mA
+ 5.88ns 0.345713mA
+ 5.882ns 0.344202mA
+ 5.884ns 0.342697mA
+ 5.886ns 0.341198mA
+ 5.888ns 0.339707mA
+ 5.89ns 0.338222mA
+ 5.892ns 0.336743mA
+ 5.894ns 0.335271mA
+ 5.896ns 0.333805mA
+ 5.898ns 0.332346mA
+ 5.9ns 0.330893mA
+ 5.902ns 0.329446mA
+ 5.904ns 0.328006mA
+ 5.906ns 0.326572mA
+ 5.908ns 0.325144mA
+ 5.91ns 0.323722mA
+ 5.912ns 0.322307mA
+ 5.914ns 0.320898mA
+ 5.916ns 0.319495mA
+ 5.918ns 0.318098mA
+ 5.92ns 0.316708mA
+ 5.922ns 0.315323mA
+ 5.924ns 0.313944mA
+ 5.926ns 0.312572mA
+ 5.928ns 0.311205mA
+ 5.93ns 0.309845mA
+ 5.932ns 0.30849mA
+ 5.934ns 0.307141mA
+ 5.936ns 0.305799mA
+ 5.938ns 0.304462mA
+ 5.94ns 0.303131mA
+ 5.942ns 0.301805mA
+ 5.944ns 0.300486mA
+ 5.946ns 0.299172mA
+ 5.948ns 0.297864mA
+ 5.95ns 0.296562mA
+ 5.952ns 0.295265mA
+ 5.954ns 0.293974mA
+ 5.956ns 0.292689mA
+ 5.958ns 0.291409mA
+ 5.96ns 0.290135mA
+ 5.962ns 0.288867mA
+ 5.964ns 0.287604mA
+ 5.966ns 0.286346mA
+ 5.968ns 0.285095mA
+ 5.97ns 0.283848mA
+ 5.972ns 0.282607mA
+ 5.974ns 0.281372mA
+ 5.976ns 0.280141mA
+ 5.978ns 0.278917mA
+ 5.98ns 0.277697mA
+ 5.982ns 0.276483mA
+ 5.984ns 0.275274mA
+ 5.986ns 0.274071mA
+ 5.988ns 0.272873mA
+ 5.99ns 0.271679mA
+ 5.992ns 0.270492mA
+ 5.994ns 0.269309mA
+ 5.996ns 0.268131mA
+ 5.998ns 0.266959mA
+ 6ns 0.265792mA
+ 6.002ns 0.26463mA
+ 6.004ns 0.263473mA
+ 6.006ns 0.262321mA
+ 6.008ns 0.261174mA
+ 6.01ns 0.260032mA
+ 6.012ns 0.258895mA
+ 6.014ns 0.257763mA
+ 6.016ns 0.256637mA
+ 6.018ns 0.255514mA
+ 6.02ns 0.254397mA
+ 6.022ns 0.253285mA
+ 6.024ns 0.252177mA
+ 6.026ns 0.251075mA
+ 6.028ns 0.249977mA
+ 6.03ns 0.248884mA
+ 6.032ns 0.247796mA
+ 6.034ns 0.246713mA
+ 6.036ns 0.245634mA
+ 6.038ns 0.24456mA
+ 6.04ns 0.243491mA
+ 6.042ns 0.242426mA
+ 6.044ns 0.241366mA
+ 6.046ns 0.240311mA
+ 6.048ns 0.23926mA
+ 6.05ns 0.238214mA
+ 6.052ns 0.237173mA
+ 6.054ns 0.236136mA
+ 6.056ns 0mA
I9 13 0 PWL 0 0
+ 3.012ns 0mA
+ 3.014ns 0.000840449mA
+ 3.016ns 0.00850198mA
+ 3.018ns 0.0161635mA
+ 3.02ns 0.0238241mA
+ 3.022ns 0.0314857mA
+ 3.024ns 0.0391472mA
+ 3.026ns 0.0468078mA
+ 3.028ns 0.0544693mA
+ 3.03ns 0.06213mA
+ 3.032ns 0.0697915mA
+ 3.034ns 0.077453mA
+ 3.036ns 0.0851136mA
+ 3.038ns 0.0927752mA
+ 3.04ns 0.100436mA
+ 3.042ns 0.108097mA
+ 3.044ns 0.115759mA
+ 3.046ns 0.123419mA
+ 3.048ns 0.131081mA
+ 3.05ns 0.138742mA
+ 3.052ns 0.146403mA
+ 3.054ns 0.154065mA
+ 3.056ns 0.161725mA
+ 3.058ns 0.169387mA
+ 3.06ns 0.177047mA
+ 3.062ns 0.184709mA
+ 3.064ns 0.19237mA
+ 3.066ns 0.200031mA
+ 3.068ns 0.207693mA
+ 3.07ns 0.215353mA
+ 3.072ns 0.223015mA
+ 3.074ns 0.230676mA
+ 3.076ns 0.238337mA
+ 3.078ns 0.245998mA
+ 3.08ns 0.25366mA
+ 3.082ns 0.261321mA
+ 3.084ns 0.268982mA
+ 3.086ns 0.276643mA
+ 3.088ns 0.284304mA
+ 3.09ns 0.291966mA
+ 3.092ns 0.299626mA
+ 3.094ns 0.307288mA
+ 3.096ns 0.314949mA
+ 3.098ns 0.32261mA
+ 3.1ns 0.330272mA
+ 3.102ns 0.337932mA
+ 3.104ns 0.345594mA
+ 3.106ns 0.353254mA
+ 3.108ns 0.360916mA
+ 3.11ns 0.368577mA
+ 3.112ns 0.376238mA
+ 3.114ns 0.3839mA
+ 3.116ns 0.39156mA
+ 3.118ns 0.399222mA
+ 3.12ns 0.406883mA
+ 3.122ns 0.414544mA
+ 3.124ns 0.422205mA
+ 3.126ns 0.429867mA
+ 3.128ns 0.437528mA
+ 3.13ns 0.445189mA
+ 3.132ns 0.45285mA
+ 3.134ns 0.460511mA
+ 3.136ns 0.468173mA
+ 3.138ns 0.475833mA
+ 3.14ns 0.483495mA
+ 3.142ns 0.491156mA
+ 3.144ns 0.498817mA
+ 3.146ns 0.506479mA
+ 3.148ns 0.514139mA
+ 3.15ns 0.521801mA
+ 3.152ns 0.529461mA
+ 3.154ns 0.537123mA
+ 3.156ns 0.544784mA
+ 3.158ns 0.55194mA
+ 3.16ns 0.549525mA
+ 3.162ns 0.547121mA
+ 3.164ns 0.544727mA
+ 3.166ns 0.542343mA
+ 3.168ns 0.53997mA
+ 3.17ns 0.537607mA
+ 3.172ns 0.535255mA
+ 3.174ns 0.532913mA
+ 3.176ns 0.530581mA
+ 3.178ns 0.528259mA
+ 3.18ns 0.525948mA
+ 3.182ns 0.523646mA
+ 3.184ns 0.521355mA
+ 3.186ns 0.519073mA
+ 3.188ns 0.516802mA
+ 3.19ns 0.514541mA
+ 3.192ns 0.512289mA
+ 3.194ns 0.510048mA
+ 3.196ns 0.507816mA
+ 3.198ns 0.505594mA
+ 3.2ns 0.503381mA
+ 3.202ns 0.501179mA
+ 3.204ns 0.498986mA
+ 3.206ns 0.496802mA
+ 3.208ns 0.494628mA
+ 3.21ns 0.492464mA
+ 3.212ns 0.490309mA
+ 3.214ns 0.488164mA
+ 3.216ns 0.486027mA
+ 3.218ns 0.483901mA
+ 3.22ns 0.481783mA
+ 3.222ns 0.479675mA
+ 3.224ns 0.477576mA
+ 3.226ns 0.475486mA
+ 3.228ns 0.473406mA
+ 3.23ns 0.471334mA
+ 3.232ns 0.469272mA
+ 3.234ns 0.467218mA
+ 3.236ns 0.465174mA
+ 3.238ns 0.463138mA
+ 3.24ns 0.461112mA
+ 3.242ns 0.459094mA
+ 3.244ns 0.457085mA
+ 3.246ns 0.455085mA
+ 3.248ns 0.453093mA
+ 3.25ns 0.451111mA
+ 3.252ns 0.449137mA
+ 3.254ns 0.447171mA
+ 3.256ns 0.445214mA
+ 3.258ns 0.443266mA
+ 3.26ns 0.441327mA
+ 3.262ns 0.439395mA
+ 3.264ns 0.437472mA
+ 3.266ns 0.435558mA
+ 3.268ns 0.433652mA
+ 3.27ns 0.431755mA
+ 3.272ns 0.429865mA
+ 3.274ns 0.427984mA
+ 3.276ns 0.426111mA
+ 3.278ns 0.424247mA
+ 3.28ns 0.42239mA
+ 3.282ns 0.420542mA
+ 3.284ns 0.418702mA
+ 3.286ns 0.41687mA
+ 3.288ns 0.415045mA
+ 3.29ns 0.413229mA
+ 3.292ns 0.411421mA
+ 3.294ns 0.40962mA
+ 3.296ns 0.407828mA
+ 3.298ns 0.406043mA
+ 3.3ns 0.404267mA
+ 3.302ns 0.402497mA
+ 3.304ns 0.400736mA
+ 3.306ns 0.398982mA
+ 3.308ns 0.397236mA
+ 3.31ns 0.395498mA
+ 3.312ns 0.393767mA
+ 3.314ns 0.392044mA
+ 3.316ns 0.390329mA
+ 3.318ns 0.388621mA
+ 3.32ns 0.38692mA
+ 3.322ns 0.385227mA
+ 3.324ns 0.383541mA
+ 3.326ns 0.381863mA
+ 3.328ns 0.380192mA
+ 3.33ns 0.378528mA
+ 3.332ns 0.376871mA
+ 3.334ns 0.375222mA
+ 3.336ns 0.37358mA
+ 3.338ns 0.371945mA
+ 3.34ns 0.370318mA
+ 3.342ns 0.368697mA
+ 3.344ns 0.367084mA
+ 3.346ns 0.365477mA
+ 3.348ns 0.363878mA
+ 3.35ns 0.362285mA
+ 3.352ns 0.3607mA
+ 3.354ns 0.359122mA
+ 3.356ns 0.35755mA
+ 3.358ns 0.355985mA
+ 3.36ns 0.354428mA
+ 3.362ns 0.352877mA
+ 3.364ns 0.351332mA
+ 3.366ns 0.349795mA
+ 3.368ns 0.348264mA
+ 3.37ns 0.34674mA
+ 3.372ns 0.345223mA
+ 3.374ns 0.343712mA
+ 3.376ns 0.342208mA
+ 3.378ns 0.34071mA
+ 3.38ns 0.339219mA
+ 3.382ns 0.337735mA
+ 3.384ns 0.336257mA
+ 3.386ns 0.334785mA
+ 3.388ns 0.33332mA
+ 3.39ns 0.331861mA
+ 3.392ns 0.330409mA
+ 3.394ns 0.328963mA
+ 3.396ns 0.327523mA
+ 3.398ns 0.32609mA
+ 3.4ns 0.324663mA
+ 3.402ns 0.323242mA
+ 3.404ns 0.321828mA
+ 3.406ns 0.320419mA
+ 3.408ns 0.319017mA
+ 3.41ns 0.317621mA
+ 3.412ns 0.316231mA
+ 3.414ns 0.314847mA
+ 3.416ns 0.313469mA
+ 3.418ns 0.312098mA
+ 3.42ns 0.310732mA
+ 3.422ns 0.309372mA
+ 3.424ns 0.308018mA
+ 3.426ns 0.30667mA
+ 3.428ns 0.305328mA
+ 3.43ns 0.303992mA
+ 3.432ns 0.302661mA
+ 3.434ns 0.301337mA
+ 3.436ns 0.300018mA
+ 3.438ns 0.298705mA
+ 3.44ns 0.297398mA
+ 3.442ns 0.296096mA
+ 3.444ns 0.294801mA
+ 3.446ns 0.29351mA
+ 3.448ns 0.292226mA
+ 3.45ns 0.290947mA
+ 3.452ns 0.289674mA
+ 3.454ns 0.288406mA
+ 3.456ns 0.287144mA
+ 3.458ns 0.285887mA
+ 3.46ns 0.284636mA
+ 3.462ns 0.28339mA
+ 3.464ns 0.28215mA
+ 3.466ns 0.280915mA
+ 3.468ns 0.279686mA
+ 3.47ns 0.278462mA
+ 3.472ns 0.277243mA
+ 3.474ns 0.27603mA
+ 3.476ns 0.274822mA
+ 3.478ns 0.273619mA
+ 3.48ns 0.272422mA
+ 3.482ns 0.271229mA
+ 3.484ns 0.270043mA
+ 3.486ns 0.268861mA
+ 3.488ns 0.267684mA
+ 3.49ns 0.266513mA
+ 3.492ns 0.265346mA
+ 3.494ns 0.264185mA
+ 3.496ns 0.263029mA
+ 3.498ns 0.261877mA
+ 3.5ns 0.260731mA
+ 3.502ns 0.25959mA
+ 3.504ns 0.258454mA
+ 3.506ns 0.257323mA
+ 3.508ns 0.256197mA
+ 3.51ns 0.255076mA
+ 3.512ns 0.253959mA
+ 3.514ns 0.252848mA
+ 3.516ns 0.251741mA
+ 3.518ns 0.25064mA
+ 3.52ns 0.249543mA
+ 3.522ns 0.248451mA
+ 3.524ns 0.247363mA
+ 3.526ns 0.246281mA
+ 3.528ns 0.245203mA
+ 3.53ns 0.24413mA
+ 3.532ns 0.243061mA
+ 3.534ns 0.241997mA
+ 3.536ns 0.240938mA
+ 3.538ns 0.239884mA
+ 3.54ns 0.238834mA
+ 3.542ns 0.237789mA
+ 3.544ns 0.236748mA
+ 3.546ns 0.235712mA
+ 3.548ns 0mA
I10 14 0 PWL 0 0
+ 3.406ns 0mA
+ 3.408ns 0.00137788mA
+ 3.41ns 0.0074234mA
+ 3.412ns 0.0134689mA
+ 3.414ns 0.0195137mA
+ 3.416ns 0.0255592mA
+ 3.418ns 0.0316041mA
+ 3.42ns 0.0376496mA
+ 3.422ns 0.0436951mA
+ 3.424ns 0.0497399mA
+ 3.426ns 0.0557854mA
+ 3.428ns 0.0618302mA
+ 3.43ns 0.0678757mA
+ 3.432ns 0.0739213mA
+ 3.434ns 0.0799661mA
+ 3.436ns 0.0860116mA
+ 3.438ns 0.0920564mA
+ 3.44ns 0.0981019mA
+ 3.442ns 0.104147mA
+ 3.444ns 0.110192mA
+ 3.446ns 0.116238mA
+ 3.448ns 0.122283mA
+ 3.45ns 0.128328mA
+ 3.452ns 0.134374mA
+ 3.454ns 0.140418mA
+ 3.456ns 0.146464mA
+ 3.458ns 0.152509mA
+ 3.46ns 0.158554mA
+ 3.462ns 0.1646mA
+ 3.464ns 0.170645mA
+ 3.466ns 0.17669mA
+ 3.468ns 0.182736mA
+ 3.47ns 0.18878mA
+ 3.472ns 0.194826mA
+ 3.474ns 0.200871mA
+ 3.476ns 0.206916mA
+ 3.478ns 0.212962mA
+ 3.48ns 0.219007mA
+ 3.482ns 0.225052mA
+ 3.484ns 0.231097mA
+ 3.486ns 0.237142mA
+ 3.488ns 0.243188mA
+ 3.49ns 0.249233mA
+ 3.492ns 0.255278mA
+ 3.494ns 0.261323mA
+ 3.496ns 0.267369mA
+ 3.498ns 0.273414mA
+ 3.5ns 0.279459mA
+ 3.502ns 0.285504mA
+ 3.504ns 0.29155mA
+ 3.506ns 0.297595mA
+ 3.508ns 0.30364mA
+ 3.51ns 0.309685mA
+ 3.512ns 0.315731mA
+ 3.514ns 0.321776mA
+ 3.516ns 0.327821mA
+ 3.518ns 0.333866mA
+ 3.52ns 0.339911mA
+ 3.522ns 0.345957mA
+ 3.524ns 0.352002mA
+ 3.526ns 0.358047mA
+ 3.528ns 0.364093mA
+ 3.53ns 0.370137mA
+ 3.532ns 0.376183mA
+ 3.534ns 0.382228mA
+ 3.536ns 0.388273mA
+ 3.538ns 0.394319mA
+ 3.54ns 0.400364mA
+ 3.542ns 0.406409mA
+ 3.544ns 0.412455mA
+ 3.546ns 0.418499mA
+ 3.548ns 0.424545mA
+ 3.55ns 0.430591mA
+ 3.552ns 0.436635mA
+ 3.554ns 0.442681mA
+ 3.556ns 0.448726mA
+ 3.558ns 0.454771mA
+ 3.56ns 0.460817mA
+ 3.562ns 0.466861mA
+ 3.564ns 0.472907mA
+ 3.566ns 0.478952mA
+ 3.568ns 0.484997mA
+ 3.57ns 0.491043mA
+ 3.572ns 0.497088mA
+ 3.574ns 0.503133mA
+ 3.576ns 0.509178mA
+ 3.578ns 0.515224mA
+ 3.58ns 0.521269mA
+ 3.582ns 0.523982mA
+ 3.584ns 0.521706mA
+ 3.586ns 0.519439mA
+ 3.588ns 0.517183mA
+ 3.59ns 0.514936mA
+ 3.592ns 0.512699mA
+ 3.594ns 0.510472mA
+ 3.596ns 0.508254mA
+ 3.598ns 0.506046mA
+ 3.6ns 0.503848mA
+ 3.602ns 0.501659mA
+ 3.604ns 0.49948mA
+ 3.606ns 0.49731mA
+ 3.608ns 0.495149mA
+ 3.61ns 0.492998mA
+ 3.612ns 0.490857mA
+ 3.614ns 0.488724mA
+ 3.616ns 0.486601mA
+ 3.618ns 0.484487mA
+ 3.62ns 0.482383mA
+ 3.622ns 0.480287mA
+ 3.624ns 0.4782mA
+ 3.626ns 0.476123mA
+ 3.628ns 0.474055mA
+ 3.63ns 0.471995mA
+ 3.632ns 0.469945mA
+ 3.634ns 0.467903mA
+ 3.636ns 0.46587mA
+ 3.638ns 0.463847mA
+ 3.64ns 0.461832mA
+ 3.642ns 0.459825mA
+ 3.644ns 0.457828mA
+ 3.646ns 0.455839mA
+ 3.648ns 0.453858mA
+ 3.65ns 0.451887mA
+ 3.652ns 0.449923mA
+ 3.654ns 0.447969mA
+ 3.656ns 0.446023mA
+ 3.658ns 0.444085mA
+ 3.66ns 0.442156mA
+ 3.662ns 0.440235mA
+ 3.664ns 0.438323mA
+ 3.666ns 0.436418mA
+ 3.668ns 0.434522mA
+ 3.67ns 0.432635mA
+ 3.672ns 0.430755mA
+ 3.674ns 0.428884mA
+ 3.676ns 0.42702mA
+ 3.678ns 0.425166mA
+ 3.68ns 0.423318mA
+ 3.682ns 0.421479mA
+ 3.684ns 0.419648mA
+ 3.686ns 0.417825mA
+ 3.688ns 0.41601mA
+ 3.69ns 0.414203mA
+ 3.692ns 0.412403mA
+ 3.694ns 0.410612mA
+ 3.696ns 0.408828mA
+ 3.698ns 0.407051mA
+ 3.7ns 0.405283mA
+ 3.702ns 0.403522mA
+ 3.704ns 0.401769mA
+ 3.706ns 0.400024mA
+ 3.708ns 0.398286mA
+ 3.71ns 0.396556mA
+ 3.712ns 0.394833mA
+ 3.714ns 0.393118mA
+ 3.716ns 0.39141mA
+ 3.718ns 0.389709mA
+ 3.72ns 0.388016mA
+ 3.722ns 0.38633mA
+ 3.724ns 0.384652mA
+ 3.726ns 0.382981mA
+ 3.728ns 0.381317mA
+ 3.73ns 0.37966mA
+ 3.732ns 0.378011mA
+ 3.734ns 0.376369mA
+ 3.736ns 0.374734mA
+ 3.738ns 0.373105mA
+ 3.74ns 0.371485mA
+ 3.742ns 0.369871mA
+ 3.744ns 0.368264mA
+ 3.746ns 0.366664mA
+ 3.748ns 0.365071mA
+ 3.75ns 0.363485mA
+ 3.752ns 0.361906mA
+ 3.754ns 0.360333mA
+ 3.756ns 0.358768mA
+ 3.758ns 0.357209mA
+ 3.76ns 0.355657mA
+ 3.762ns 0.354112mA
+ 3.764ns 0.352573mA
+ 3.766ns 0.351042mA
+ 3.768ns 0.349517mA
+ 3.77ns 0.347998mA
+ 3.772ns 0.346486mA
+ 3.774ns 0.344981mA
+ 3.776ns 0.343482mA
+ 3.778ns 0.34199mA
+ 3.78ns 0.340504mA
+ 3.782ns 0.339025mA
+ 3.784ns 0.337552mA
+ 3.786ns 0.336085mA
+ 3.788ns 0.334625mA
+ 3.79ns 0.333171mA
+ 3.792ns 0.331724mA
+ 3.794ns 0.330282mA
+ 3.796ns 0.328848mA
+ 3.798ns 0.327419mA
+ 3.8ns 0.325996mA
+ 3.802ns 0.32458mA
+ 3.804ns 0.32317mA
+ 3.806ns 0.321766mA
+ 3.808ns 0.320368mA
+ 3.81ns 0.318976mA
+ 3.812ns 0.31759mA
+ 3.814ns 0.31621mA
+ 3.816ns 0.314836mA
+ 3.818ns 0.313468mA
+ 3.82ns 0.312106mA
+ 3.822ns 0.310751mA
+ 3.824ns 0.3094mA
+ 3.826ns 0.308056mA
+ 3.828ns 0.306718mA
+ 3.83ns 0.305385mA
+ 3.832ns 0.304058mA
+ 3.834ns 0.302737mA
+ 3.836ns 0.301422mA
+ 3.838ns 0.300112mA
+ 3.84ns 0.298808mA
+ 3.842ns 0.29751mA
+ 3.844ns 0.296218mA
+ 3.846ns 0.29493mA
+ 3.848ns 0.293649mA
+ 3.85ns 0.292373mA
+ 3.852ns 0.291103mA
+ 3.854ns 0.289838mA
+ 3.856ns 0.288579mA
+ 3.858ns 0.287325mA
+ 3.86ns 0.286077mA
+ 3.862ns 0.284834mA
+ 3.864ns 0.283596mA
+ 3.866ns 0.282364mA
+ 3.868ns 0.281137mA
+ 3.87ns 0.279916mA
+ 3.872ns 0.2787mA
+ 3.874ns 0.277489mA
+ 3.876ns 0.276283mA
+ 3.878ns 0.275083mA
+ 3.88ns 0.273887mA
+ 3.882ns 0.272697mA
+ 3.884ns 0.271513mA
+ 3.886ns 0.270333mA
+ 3.888ns 0.269158mA
+ 3.89ns 0.267989mA
+ 3.892ns 0.266825mA
+ 3.894ns 0.265665mA
+ 3.896ns 0.264511mA
+ 3.898ns 0.263362mA
+ 3.9ns 0.262217mA
+ 3.902ns 0.261078mA
+ 3.904ns 0.259944mA
+ 3.906ns 0.258814mA
+ 3.908ns 0.25769mA
+ 3.91ns 0.25657mA
+ 3.912ns 0.255455mA
+ 3.914ns 0.254346mA
+ 3.916ns 0.25324mA
+ 3.918ns 0.25214mA
+ 3.92ns 0.251045mA
+ 3.922ns 0.249954mA
+ 3.924ns 0.248868mA
+ 3.926ns 0.247786mA
+ 3.928ns 0.24671mA
+ 3.93ns 0.245638mA
+ 3.932ns 0.244571mA
+ 3.934ns 0.243508mA
+ 3.936ns 0.24245mA
+ 3.938ns 0.241396mA
+ 3.94ns 0.240348mA
+ 3.942ns 0.239303mA
+ 3.944ns 0.238264mA
+ 3.946ns 0.237228mA
+ 3.948ns 0.236197mA
+ 3.95ns 0.235171mA
+ 3.952ns 0.234149mA
+ 3.954ns 0.233132mA
+ 3.956ns 0.232119mA
+ 3.958ns 0.23111mA
+ 3.96ns 0.230106mA
+ 3.962ns 0.229107mA
+ 3.964ns 0.228111mA
+ 3.966ns 0.22712mA
+ 3.968ns 0.226133mA
+ 3.97ns 0.225151mA
+ 3.972ns 0.224172mA
+ 3.974ns 0.223198mA
+ 3.976ns 0.222228mA
+ 3.978ns 0.221263mA
+ 3.98ns 0.220301mA
+ 3.982ns 0.219344mA
+ 3.984ns 0.218391mA
+ 3.986ns 0.217442mA
+ 3.988ns 0mA
I11 17 0 PWL 0 0
+ 3.014ns 0mA
+ 3.016ns 0.0074344mA
+ 3.018ns 0.0151038mA
+ 3.02ns 0.0227722mA
+ 3.022ns 0.0304416mA
+ 3.024ns 0.0381109mA
+ 3.026ns 0.0457794mA
+ 3.028ns 0.0534487mA
+ 3.03ns 0.0611171mA
+ 3.032ns 0.0687865mA
+ 3.034ns 0.0764559mA
+ 3.036ns 0.0841243mA
+ 3.038ns 0.0917937mA
+ 3.04ns 0.0994621mA
+ 3.042ns 0.107131mA
+ 3.044ns 0.114801mA
+ 3.046ns 0.122469mA
+ 3.048ns 0.130139mA
+ 3.05ns 0.137807mA
+ 3.052ns 0.145476mA
+ 3.054ns 0.153146mA
+ 3.056ns 0.160814mA
+ 3.058ns 0.168484mA
+ 3.06ns 0.176152mA
+ 3.062ns 0.183821mA
+ 3.064ns 0.191491mA
+ 3.066ns 0.199159mA
+ 3.068ns 0.206829mA
+ 3.07ns 0.214497mA
+ 3.072ns 0.222166mA
+ 3.074ns 0.229836mA
+ 3.076ns 0.237504mA
+ 3.078ns 0.245173mA
+ 3.08ns 0.252843mA
+ 3.082ns 0.260511mA
+ 3.084ns 0.268181mA
+ 3.086ns 0.275849mA
+ 3.088ns 0.283518mA
+ 3.09ns 0.291188mA
+ 3.092ns 0.298856mA
+ 3.094ns 0.306526mA
+ 3.096ns 0.314194mA
+ 3.098ns 0.321863mA
+ 3.1ns 0.329533mA
+ 3.102ns 0.337201mA
+ 3.104ns 0.344871mA
+ 3.106ns 0.352539mA
+ 3.108ns 0.360208mA
+ 3.11ns 0.367878mA
+ 3.112ns 0.375546mA
+ 3.114ns 0.383215mA
+ 3.116ns 0.390884mA
+ 3.118ns 0.398553mA
+ 3.12ns 0.406223mA
+ 3.122ns 0.413891mA
+ 3.124ns 0.42156mA
+ 3.126ns 0.42923mA
+ 3.128ns 0.436898mA
+ 3.13ns 0.444568mA
+ 3.132ns 0.452236mA
+ 3.134ns 0.459905mA
+ 3.136ns 0.467575mA
+ 3.138ns 0.475243mA
+ 3.14ns 0.482913mA
+ 3.142ns 0.490581mA
+ 3.144ns 0.49825mA
+ 3.146ns 0.50592mA
+ 3.148ns 0.513588mA
+ 3.15ns 0.521257mA
+ 3.152ns 0.528926mA
+ 3.154ns 0.536595mA
+ 3.156ns 0.544265mA
+ 3.158ns 0.551933mA
+ 3.16ns 0.54952mA
+ 3.162ns 0.547117mA
+ 3.164ns 0.544725mA
+ 3.166ns 0.542343mA
+ 3.168ns 0.539972mA
+ 3.17ns 0.53761mA
+ 3.172ns 0.53526mA
+ 3.174ns 0.532919mA
+ 3.176ns 0.530589mA
+ 3.178ns 0.528269mA
+ 3.18ns 0.525959mA
+ 3.182ns 0.52366mA
+ 3.184ns 0.52137mA
+ 3.186ns 0.51909mA
+ 3.188ns 0.516821mA
+ 3.19ns 0.514561mA
+ 3.192ns 0.512311mA
+ 3.194ns 0.510071mA
+ 3.196ns 0.50784mA
+ 3.198ns 0.50562mA
+ 3.2ns 0.503409mA
+ 3.202ns 0.501208mA
+ 3.204ns 0.499016mA
+ 3.206ns 0.496834mA
+ 3.208ns 0.494662mA
+ 3.21ns 0.492499mA
+ 3.212ns 0.490345mA
+ 3.214ns 0.488201mA
+ 3.216ns 0.486067mA
+ 3.218ns 0.483941mA
+ 3.22ns 0.481825mA
+ 3.222ns 0.479718mA
+ 3.224ns 0.477621mA
+ 3.226ns 0.475532mA
+ 3.228ns 0.473453mA
+ 3.23ns 0.471383mA
+ 3.232ns 0.469322mA
+ 3.234ns 0.46727mA
+ 3.236ns 0.465226mA
+ 3.238ns 0.463192mA
+ 3.24ns 0.461167mA
+ 3.242ns 0.45915mA
+ 3.244ns 0.457143mA
+ 3.246ns 0.455143mA
+ 3.248ns 0.453153mA
+ 3.25ns 0.451172mA
+ 3.252ns 0.449199mA
+ 3.254ns 0.447235mA
+ 3.256ns 0.445279mA
+ 3.258ns 0.443332mA
+ 3.26ns 0.441394mA
+ 3.262ns 0.439463mA
+ 3.264ns 0.437542mA
+ 3.266ns 0.435629mA
+ 3.268ns 0.433724mA
+ 3.27ns 0.431827mA
+ 3.272ns 0.429939mA
+ 3.274ns 0.428059mA
+ 3.276ns 0.426187mA
+ 3.278ns 0.424323mA
+ 3.28ns 0.422468mA
+ 3.282ns 0.420621mA
+ 3.284ns 0.418781mA
+ 3.286ns 0.41695mA
+ 3.288ns 0.415127mA
+ 3.29ns 0.413312mA
+ 3.292ns 0.411505mA
+ 3.294ns 0.409705mA
+ 3.296ns 0.407914mA
+ 3.298ns 0.40613mA
+ 3.3ns 0.404354mA
+ 3.302ns 0.402586mA
+ 3.304ns 0.400825mA
+ 3.306ns 0.399073mA
+ 3.308ns 0.397328mA
+ 3.31ns 0.39559mA
+ 3.312ns 0.39386mA
+ 3.314ns 0.392138mA
+ 3.316ns 0.390423mA
+ 3.318ns 0.388716mA
+ 3.32ns 0.387016mA
+ 3.322ns 0.385324mA
+ 3.324ns 0.383639mA
+ 3.326ns 0.381961mA
+ 3.328ns 0.380291mA
+ 3.33ns 0.378628mA
+ 3.332ns 0.376972mA
+ 3.334ns 0.375324mA
+ 3.336ns 0.373683mA
+ 3.338ns 0.372049mA
+ 3.34ns 0.370422mA
+ 3.342ns 0.368802mA
+ 3.344ns 0.367189mA
+ 3.346ns 0.365584mA
+ 3.348ns 0.363985mA
+ 3.35ns 0.362393mA
+ 3.352ns 0.360809mA
+ 3.354ns 0.359231mA
+ 3.356ns 0.35766mA
+ 3.358ns 0.356096mA
+ 3.36ns 0.354539mA
+ 3.362ns 0.352988mA
+ 3.364ns 0.351445mA
+ 3.366ns 0.349908mA
+ 3.368ns 0.348378mA
+ 3.37ns 0.346854mA
+ 3.372ns 0.345338mA
+ 3.374ns 0.343827mA
+ 3.376ns 0.342324mA
+ 3.378ns 0.340827mA
+ 3.38ns 0.339336mA
+ 3.382ns 0.337853mA
+ 3.384ns 0.336375mA
+ 3.386ns 0.334904mA
+ 3.388ns 0.33344mA
+ 3.39ns 0.331982mA
+ 3.392ns 0.33053mA
+ 3.394ns 0.329084mA
+ 3.396ns 0.327645mA
+ 3.398ns 0.326213mA
+ 3.4ns 0.324786mA
+ 3.402ns 0.323366mA
+ 3.404ns 0.321952mA
+ 3.406ns 0.320544mA
+ 3.408ns 0.319142mA
+ 3.41ns 0.317746mA
+ 3.412ns 0.316357mA
+ 3.414ns 0.314973mA
+ 3.416ns 0.313596mA
+ 3.418ns 0.312225mA
+ 3.42ns 0.310859mA
+ 3.422ns 0.3095mA
+ 3.424ns 0.308146mA
+ 3.426ns 0.306799mA
+ 3.428ns 0.305457mA
+ 3.43ns 0.304121mA
+ 3.432ns 0.302791mA
+ 3.434ns 0.301467mA
+ 3.436ns 0.300149mA
+ 3.438ns 0.298836mA
+ 3.44ns 0.29753mA
+ 3.442ns 0.296228mA
+ 3.444ns 0.294933mA
+ 3.446ns 0.293643mA
+ 3.448ns 0.292359mA
+ 3.45ns 0.291081mA
+ 3.452ns 0.289808mA
+ 3.454ns 0.28854mA
+ 3.456ns 0.287278mA
+ 3.458ns 0.286022mA
+ 3.46ns 0.284771mA
+ 3.462ns 0.283526mA
+ 3.464ns 0.282286mA
+ 3.466ns 0.281052mA
+ 3.468ns 0.279822mA
+ 3.47ns 0.278599mA
+ 3.472ns 0.27738mA
+ 3.474ns 0.276167mA
+ 3.476ns 0.27496mA
+ 3.478ns 0.273757mA
+ 3.48ns 0.27256mA
+ 3.482ns 0.271368mA
+ 3.484ns 0.270181mA
+ 3.486ns 0.269mA
+ 3.488ns 0.267823mA
+ 3.49ns 0.266652mA
+ 3.492ns 0.265486mA
+ 3.494ns 0.264325mA
+ 3.496ns 0.263169mA
+ 3.498ns 0.262018mA
+ 3.5ns 0.260872mA
+ 3.502ns 0.259731mA
+ 3.504ns 0.258595mA
+ 3.506ns 0.257465mA
+ 3.508ns 0.256339mA
+ 3.51ns 0.255218mA
+ 3.512ns 0.254101mA
+ 3.514ns 0.25299mA
+ 3.516ns 0.251884mA
+ 3.518ns 0.250782mA
+ 3.52ns 0.249686mA
+ 3.522ns 0.248594mA
+ 3.524ns 0.247506mA
+ 3.526ns 0.246424mA
+ 3.528ns 0.245346mA
+ 3.53ns 0.244273mA
+ 3.532ns 0.243205mA
+ 3.534ns 0.242141mA
+ 3.536ns 0.241082mA
+ 3.538ns 0.240028mA
+ 3.54ns 0.238978mA
+ 3.542ns 0.237933mA
+ 3.544ns 0.236893mA
+ 3.546ns 0.235857mA
+ 3.548ns 0mA
I12 18 0 PWL 0 0
+ 3.02ns 0mA
+ 3.022ns 0.000483052mA
+ 3.024ns 0.00812895mA
+ 3.026ns 0.0157739mA
+ 3.028ns 0.0234198mA
+ 3.03ns 0.0310648mA
+ 3.032ns 0.0387107mA
+ 3.034ns 0.0463566mA
+ 3.036ns 0.0540016mA
+ 3.038ns 0.0616475mA
+ 3.04ns 0.0692925mA
+ 3.042ns 0.0769384mA
+ 3.044ns 0.0845843mA
+ 3.046ns 0.0922292mA
+ 3.048ns 0.0998751mA
+ 3.05ns 0.10752mA
+ 3.052ns 0.115166mA
+ 3.054ns 0.122812mA
+ 3.056ns 0.130457mA
+ 3.058ns 0.138103mA
+ 3.06ns 0.145748mA
+ 3.062ns 0.153394mA
+ 3.064ns 0.16104mA
+ 3.066ns 0.168685mA
+ 3.068ns 0.17633mA
+ 3.07ns 0.183975mA
+ 3.072ns 0.191621mA
+ 3.074ns 0.199267mA
+ 3.076ns 0.206912mA
+ 3.078ns 0.214558mA
+ 3.08ns 0.222204mA
+ 3.082ns 0.229849mA
+ 3.084ns 0.237495mA
+ 3.086ns 0.24514mA
+ 3.088ns 0.252786mA
+ 3.09ns 0.260432mA
+ 3.092ns 0.268077mA
+ 3.094ns 0.275723mA
+ 3.096ns 0.283368mA
+ 3.098ns 0.291013mA
+ 3.1ns 0.298659mA
+ 3.102ns 0.306304mA
+ 3.104ns 0.31395mA
+ 3.106ns 0.321595mA
+ 3.108ns 0.329241mA
+ 3.11ns 0.336887mA
+ 3.112ns 0.344532mA
+ 3.114ns 0.352178mA
+ 3.116ns 0.359823mA
+ 3.118ns 0.367469mA
+ 3.12ns 0.375115mA
+ 3.122ns 0.38276mA
+ 3.124ns 0.390406mA
+ 3.126ns 0.398051mA
+ 3.128ns 0.405696mA
+ 3.13ns 0.413342mA
+ 3.132ns 0.420987mA
+ 3.134ns 0.428633mA
+ 3.136ns 0.436279mA
+ 3.138ns 0.443924mA
+ 3.14ns 0.45157mA
+ 3.142ns 0.459215mA
+ 3.144ns 0.466861mA
+ 3.146ns 0.474507mA
+ 3.148ns 0.482152mA
+ 3.15ns 0.489798mA
+ 3.152ns 0.497443mA
+ 3.154ns 0.505089mA
+ 3.156ns 0.512734mA
+ 3.158ns 0.520379mA
+ 3.16ns 0.528025mA
+ 3.162ns 0.53567mA
+ 3.164ns 0.543316mA
+ 3.166ns 0.550962mA
+ 3.168ns 0.549056mA
+ 3.17ns 0.546657mA
+ 3.172ns 0.544269mA
+ 3.174ns 0.541892mA
+ 3.176ns 0.539524mA
+ 3.178ns 0.537168mA
+ 3.18ns 0.534821mA
+ 3.182ns 0.532485mA
+ 3.184ns 0.530159mA
+ 3.186ns 0.527843mA
+ 3.188ns 0.525537mA
+ 3.19ns 0.523241mA
+ 3.192ns 0.520955mA
+ 3.194ns 0.51868mA
+ 3.196ns 0.516414mA
+ 3.198ns 0.514158mA
+ 3.2ns 0.511912mA
+ 3.202ns 0.509675mA
+ 3.204ns 0.507449mA
+ 3.206ns 0.505232mA
+ 3.208ns 0.503025mA
+ 3.21ns 0.500828mA
+ 3.212ns 0.49864mA
+ 3.214ns 0.496462mA
+ 3.216ns 0.494293mA
+ 3.218ns 0.492133mA
+ 3.22ns 0.489984mA
+ 3.222ns 0.487843mA
+ 3.224ns 0.485712mA
+ 3.226ns 0.48359mA
+ 3.228ns 0.481477mA
+ 3.23ns 0.479374mA
+ 3.232ns 0.47728mA
+ 3.234ns 0.475195mA
+ 3.236ns 0.473119mA
+ 3.238ns 0.471052mA
+ 3.24ns 0.468995mA
+ 3.242ns 0.466946mA
+ 3.244ns 0.464906mA
+ 3.246ns 0.462875mA
+ 3.248ns 0.460853mA
+ 3.25ns 0.45884mA
+ 3.252ns 0.456835mA
+ 3.254ns 0.454839mA
+ 3.256ns 0.452852mA
+ 3.258ns 0.450874mA
+ 3.26ns 0.448904mA
+ 3.262ns 0.446943mA
+ 3.264ns 0.444991mA
+ 3.266ns 0.443047mA
+ 3.268ns 0.441111mA
+ 3.27ns 0.439184mA
+ 3.272ns 0.437266mA
+ 3.274ns 0.435355mA
+ 3.276ns 0.433454mA
+ 3.278ns 0.43156mA
+ 3.28ns 0.429675mA
+ 3.282ns 0.427798mA
+ 3.284ns 0.425929mA
+ 3.286ns 0.424068mA
+ 3.288ns 0.422215mA
+ 3.29ns 0.420371mA
+ 3.292ns 0.418534mA
+ 3.294ns 0.416706mA
+ 3.296ns 0.414886mA
+ 3.298ns 0.413073mA
+ 3.3ns 0.411269mA
+ 3.302ns 0.409472mA
+ 3.304ns 0.407683mA
+ 3.306ns 0.405902mA
+ 3.308ns 0.404129mA
+ 3.31ns 0.402363mA
+ 3.312ns 0.400605mA
+ 3.314ns 0.398855mA
+ 3.316ns 0.397113mA
+ 3.318ns 0.395378mA
+ 3.32ns 0.39365mA
+ 3.322ns 0.391931mA
+ 3.324ns 0.390218mA
+ 3.326ns 0.388514mA
+ 3.328ns 0.386816mA
+ 3.33ns 0.385127mA
+ 3.332ns 0.383444mA
+ 3.334ns 0.381769mA
+ 3.336ns 0.380101mA
+ 3.338ns 0.37844mA
+ 3.34ns 0.376787mA
+ 3.342ns 0.375141mA
+ 3.344ns 0.373502mA
+ 3.346ns 0.37187mA
+ 3.348ns 0.370246mA
+ 3.35ns 0.368628mA
+ 3.352ns 0.367018mA
+ 3.354ns 0.365414mA
+ 3.356ns 0.363818mA
+ 3.358ns 0.362229mA
+ 3.36ns 0.360646mA
+ 3.362ns 0.35907mA
+ 3.364ns 0.357502mA
+ 3.366ns 0.35594mA
+ 3.368ns 0.354385mA
+ 3.37ns 0.352837mA
+ 3.372ns 0.351295mA
+ 3.374ns 0.34976mA
+ 3.376ns 0.348232mA
+ 3.378ns 0.346711mA
+ 3.38ns 0.345196mA
+ 3.382ns 0.343688mA
+ 3.384ns 0.342187mA
+ 3.386ns 0.340692mA
+ 3.388ns 0.339203mA
+ 3.39ns 0.337721mA
+ 3.392ns 0.336246mA
+ 3.394ns 0.334777mA
+ 3.396ns 0.333314mA
+ 3.398ns 0.331858mA
+ 3.4ns 0.330408mA
+ 3.402ns 0.328965mA
+ 3.404ns 0.327527mA
+ 3.406ns 0.326096mA
+ 3.408ns 0.324672mA
+ 3.41ns 0.323253mA
+ 3.412ns 0.321841mA
+ 3.414ns 0.320435mA
+ 3.416ns 0.319035mA
+ 3.418ns 0.317641mA
+ 3.42ns 0.316253mA
+ 3.422ns 0.314872mA
+ 3.424ns 0.313496mA
+ 3.426ns 0.312126mA
+ 3.428ns 0.310763mA
+ 3.43ns 0.309405mA
+ 3.432ns 0.308053mA
+ 3.434ns 0.306707mA
+ 3.436ns 0.305367mA
+ 3.438ns 0.304033mA
+ 3.44ns 0.302705mA
+ 3.442ns 0.301382mA
+ 3.444ns 0.300066mA
+ 3.446ns 0.298755mA
+ 3.448ns 0.297449mA
+ 3.45ns 0.29615mA
+ 3.452ns 0.294856mA
+ 3.454ns 0.293568mA
+ 3.456ns 0.292285mA
+ 3.458ns 0.291008mA
+ 3.46ns 0.289737mA
+ 3.462ns 0.288471mA
+ 3.464ns 0.28721mA
+ 3.466ns 0.285955mA
+ 3.468ns 0.284706mA
+ 3.47ns 0.283462mA
+ 3.472ns 0.282224mA
+ 3.474ns 0.280991mA
+ 3.476ns 0.279763mA
+ 3.478ns 0.278541mA
+ 3.48ns 0.277324mA
+ 3.482ns 0.276112mA
+ 3.484ns 0.274906mA
+ 3.486ns 0.273705mA
+ 3.488ns 0.272509mA
+ 3.49ns 0.271318mA
+ 3.492ns 0.270133mA
+ 3.494ns 0.268953mA
+ 3.496ns 0.267777mA
+ 3.498ns 0.266607mA
+ 3.5ns 0.265443mA
+ 3.502ns 0.264283mA
+ 3.504ns 0.263128mA
+ 3.506ns 0.261979mA
+ 3.508ns 0.260834mA
+ 3.51ns 0.259694mA
+ 3.512ns 0.25856mA
+ 3.514ns 0.25743mA
+ 3.516ns 0.256305mA
+ 3.518ns 0.255185mA
+ 3.52ns 0.25407mA
+ 3.522ns 0.25296mA
+ 3.524ns 0.251855mA
+ 3.526ns 0.250755mA
+ 3.528ns 0.249659mA
+ 3.53ns 0.248568mA
+ 3.532ns 0.247482mA
+ 3.534ns 0.246401mA
+ 3.536ns 0.245324mA
+ 3.538ns 0.244253mA
+ 3.54ns 0.243185mA
+ 3.542ns 0.242123mA
+ 3.544ns 0.241065mA
+ 3.546ns 0.240012mA
+ 3.548ns 0.238963mA
+ 3.55ns 0.237919mA
+ 3.552ns 0.236879mA
+ 3.554ns 0.235844mA
+ 3.556ns 0mA
+ 5.52ns 0mA
+ 5.522ns 0.000482141mA
+ 5.524ns 0.00812895mA
+ 5.526ns 0.0157739mA
+ 5.528ns 0.0234189mA
+ 5.53ns 0.0310657mA
+ 5.532ns 0.0387107mA
+ 5.534ns 0.0463557mA
+ 5.536ns 0.0540025mA
+ 5.538ns 0.0616475mA
+ 5.54ns 0.0692925mA
+ 5.542ns 0.0769393mA
+ 5.544ns 0.0845843mA
+ 5.546ns 0.0922292mA
+ 5.548ns 0.0998742mA
+ 5.55ns 0.107521mA
+ 5.552ns 0.115166mA
+ 5.554ns 0.122811mA
+ 5.556ns 0.130458mA
+ 5.558ns 0.138103mA
+ 5.56ns 0.145748mA
+ 5.562ns 0.153395mA
+ 5.564ns 0.16104mA
+ 5.566ns 0.168685mA
+ 5.568ns 0.17633mA
+ 5.57ns 0.183976mA
+ 5.572ns 0.191621mA
+ 5.574ns 0.199266mA
+ 5.576ns 0.206913mA
+ 5.578ns 0.214558mA
+ 5.58ns 0.222203mA
+ 5.582ns 0.22985mA
+ 5.584ns 0.237495mA
+ 5.586ns 0.24514mA
+ 5.588ns 0.252787mA
+ 5.59ns 0.260432mA
+ 5.592ns 0.268077mA
+ 5.594ns 0.275722mA
+ 5.596ns 0.283368mA
+ 5.598ns 0.291013mA
+ 5.6ns 0.298658mA
+ 5.602ns 0.306305mA
+ 5.604ns 0.31395mA
+ 5.606ns 0.321595mA
+ 5.608ns 0.329242mA
+ 5.61ns 0.336887mA
+ 5.612ns 0.344532mA
+ 5.614ns 0.352177mA
+ 5.616ns 0.359824mA
+ 5.618ns 0.367469mA
+ 5.62ns 0.375114mA
+ 5.622ns 0.382761mA
+ 5.624ns 0.390406mA
+ 5.626ns 0.39805mA
+ 5.628ns 0.405697mA
+ 5.63ns 0.413342mA
+ 5.632ns 0.420987mA
+ 5.634ns 0.428634mA
+ 5.636ns 0.436279mA
+ 5.638ns 0.443924mA
+ 5.64ns 0.451569mA
+ 5.642ns 0.459216mA
+ 5.644ns 0.466861mA
+ 5.646ns 0.474506mA
+ 5.648ns 0.482153mA
+ 5.65ns 0.489798mA
+ 5.652ns 0.497443mA
+ 5.654ns 0.505089mA
+ 5.656ns 0.512734mA
+ 5.658ns 0.520379mA
+ 5.66ns 0.528024mA
+ 5.662ns 0.535671mA
+ 5.664ns 0.543316mA
+ 5.666ns 0.550961mA
+ 5.668ns 0.549055mA
+ 5.67ns 0.546657mA
+ 5.672ns 0.544269mA
+ 5.674ns 0.541891mA
+ 5.676ns 0.539524mA
+ 5.678ns 0.537168mA
+ 5.68ns 0.534821mA
+ 5.682ns 0.532485mA
+ 5.684ns 0.530159mA
+ 5.686ns 0.527843mA
+ 5.688ns 0.525537mA
+ 5.69ns 0.523241mA
+ 5.692ns 0.520955mA
+ 5.694ns 0.518679mA
+ 5.696ns 0.516414mA
+ 5.698ns 0.514158mA
+ 5.7ns 0.511911mA
+ 5.702ns 0.509675mA
+ 5.704ns 0.507449mA
+ 5.706ns 0.505232mA
+ 5.708ns 0.503025mA
+ 5.71ns 0.500828mA
+ 5.712ns 0.49864mA
+ 5.714ns 0.496461mA
+ 5.716ns 0.494293mA
+ 5.718ns 0.492134mA
+ 5.72ns 0.489983mA
+ 5.722ns 0.487843mA
+ 5.724ns 0.485712mA
+ 5.726ns 0.48359mA
+ 5.728ns 0.481477mA
+ 5.73ns 0.479374mA
+ 5.732ns 0.47728mA
+ 5.734ns 0.475195mA
+ 5.736ns 0.473119mA
+ 5.738ns 0.471053mA
+ 5.74ns 0.468994mA
+ 5.742ns 0.466946mA
+ 5.744ns 0.464906mA
+ 5.746ns 0.462875mA
+ 5.748ns 0.460853mA
+ 5.75ns 0.45884mA
+ 5.752ns 0.456835mA
+ 5.754ns 0.454839mA
+ 5.756ns 0.452852mA
+ 5.758ns 0.450874mA
+ 5.76ns 0.448904mA
+ 5.762ns 0.446943mA
+ 5.764ns 0.444991mA
+ 5.766ns 0.443047mA
+ 5.768ns 0.441111mA
+ 5.77ns 0.439184mA
+ 5.772ns 0.437265mA
+ 5.774ns 0.435355mA
+ 5.776ns 0.433454mA
+ 5.778ns 0.43156mA
+ 5.78ns 0.429675mA
+ 5.782ns 0.427798mA
+ 5.784ns 0.425929mA
+ 5.786ns 0.424068mA
+ 5.788ns 0.422215mA
+ 5.79ns 0.420371mA
+ 5.792ns 0.418534mA
+ 5.794ns 0.416706mA
+ 5.796ns 0.414886mA
+ 5.798ns 0.413073mA
+ 5.8ns 0.411268mA
+ 5.802ns 0.409472mA
+ 5.804ns 0.407683mA
+ 5.806ns 0.405902mA
+ 5.808ns 0.404129mA
+ 5.81ns 0.402363mA
+ 5.812ns 0.400605mA
+ 5.814ns 0.398855mA
+ 5.816ns 0.397113mA
+ 5.818ns 0.395378mA
+ 5.82ns 0.39365mA
+ 5.822ns 0.391931mA
+ 5.824ns 0.390219mA
+ 5.826ns 0.388514mA
+ 5.828ns 0.386816mA
+ 5.83ns 0.385127mA
+ 5.832ns 0.383444mA
+ 5.834ns 0.381769mA
+ 5.836ns 0.380101mA
+ 5.838ns 0.37844mA
+ 5.84ns 0.376787mA
+ 5.842ns 0.375141mA
+ 5.844ns 0.373502mA
+ 5.846ns 0.37187mA
+ 5.848ns 0.370246mA
+ 5.85ns 0.368628mA
+ 5.852ns 0.367018mA
+ 5.854ns 0.365414mA
+ 5.856ns 0.363818mA
+ 5.858ns 0.362228mA
+ 5.86ns 0.360646mA
+ 5.862ns 0.35907mA
+ 5.864ns 0.357502mA
+ 5.866ns 0.35594mA
+ 5.868ns 0.354385mA
+ 5.87ns 0.352837mA
+ 5.872ns 0.351295mA
+ 5.874ns 0.34976mA
+ 5.876ns 0.348232mA
+ 5.878ns 0.346711mA
+ 5.88ns 0.345196mA
+ 5.882ns 0.343688mA
+ 5.884ns 0.342186mA
+ 5.886ns 0.340692mA
+ 5.888ns 0.339203mA
+ 5.89ns 0.337721mA
+ 5.892ns 0.336246mA
+ 5.894ns 0.334777mA
+ 5.896ns 0.333314mA
+ 5.898ns 0.331858mA
+ 5.9ns 0.330408mA
+ 5.902ns 0.328965mA
+ 5.904ns 0.327527mA
+ 5.906ns 0.326096mA
+ 5.908ns 0.324672mA
+ 5.91ns 0.323253mA
+ 5.912ns 0.321841mA
+ 5.914ns 0.320435mA
+ 5.916ns 0.319035mA
+ 5.918ns 0.317641mA
+ 5.92ns 0.316253mA
+ 5.922ns 0.314872mA
+ 5.924ns 0.313496mA
+ 5.926ns 0.312126mA
+ 5.928ns 0.310763mA
+ 5.93ns 0.309405mA
+ 5.932ns 0.308053mA
+ 5.934ns 0.306707mA
+ 5.936ns 0.305367mA
+ 5.938ns 0.304033mA
+ 5.94ns 0.302705mA
+ 5.942ns 0.301382mA
+ 5.944ns 0.300065mA
+ 5.946ns 0.298755mA
+ 5.948ns 0.297449mA
+ 5.95ns 0.29615mA
+ 5.952ns 0.294856mA
+ 5.954ns 0.293568mA
+ 5.956ns 0.292285mA
+ 5.958ns 0.291008mA
+ 5.96ns 0.289737mA
+ 5.962ns 0.288471mA
+ 5.964ns 0.28721mA
+ 5.966ns 0.285955mA
+ 5.968ns 0.284706mA
+ 5.97ns 0.283462mA
+ 5.972ns 0.282224mA
+ 5.974ns 0.280991mA
+ 5.976ns 0.279763mA
+ 5.978ns 0.278541mA
+ 5.98ns 0.277324mA
+ 5.982ns 0.276112mA
+ 5.984ns 0.274906mA
+ 5.986ns 0.273705mA
+ 5.988ns 0.272509mA
+ 5.99ns 0.271318mA
+ 5.992ns 0.270133mA
+ 5.994ns 0.268953mA
+ 5.996ns 0.267777mA
+ 5.998ns 0.266607mA
+ 6ns 0.265443mA
+ 6.002ns 0.264283mA
+ 6.004ns 0.263128mA
+ 6.006ns 0.261979mA
+ 6.008ns 0.260834mA
+ 6.01ns 0.259694mA
+ 6.012ns 0.25856mA
+ 6.014ns 0.25743mA
+ 6.016ns 0.256305mA
+ 6.018ns 0.255185mA
+ 6.02ns 0.25407mA
+ 6.022ns 0.252961mA
+ 6.024ns 0.251855mA
+ 6.026ns 0.250755mA
+ 6.028ns 0.249659mA
+ 6.03ns 0.248568mA
+ 6.032ns 0.247482mA
+ 6.034ns 0.246401mA
+ 6.036ns 0.245325mA
+ 6.038ns 0.244253mA
+ 6.04ns 0.243185mA
+ 6.042ns 0.242123mA
+ 6.044ns 0.241065mA
+ 6.046ns 0.240012mA
+ 6.048ns 0.238963mA
+ 6.05ns 0.237919mA
+ 6.052ns 0.236879mA
+ 6.054ns 0.235844mA
+ 6.056ns 0mA
I13 19 0 PWL 0 0
+ 5.512ns 0mA
+ 5.514ns 0.0047092mA
+ 5.516ns 0.0124483mA
+ 5.518ns 0.0201856mA
+ 5.52ns 0.0279229mA
+ 5.522ns 0.0356602mA
+ 5.524ns 0.0433993mA
+ 5.526ns 0.0511366mA
+ 5.528ns 0.0588739mA
+ 5.53ns 0.066613mA
+ 5.532ns 0.0743503mA
+ 5.534ns 0.0820876mA
+ 5.536ns 0.0898267mA
+ 5.538ns 0.097564mA
+ 5.54ns 0.105301mA
+ 5.542ns 0.11304mA
+ 5.544ns 0.120778mA
+ 5.546ns 0.128515mA
+ 5.548ns 0.136252mA
+ 5.55ns 0.143991mA
+ 5.552ns 0.151729mA
+ 5.554ns 0.159466mA
+ 5.556ns 0.167205mA
+ 5.558ns 0.174942mA
+ 5.56ns 0.18268mA
+ 5.562ns 0.190419mA
+ 5.564ns 0.198156mA
+ 5.566ns 0.205893mA
+ 5.568ns 0.213631mA
+ 5.57ns 0.22137mA
+ 5.572ns 0.229107mA
+ 5.574ns 0.236844mA
+ 5.576ns 0.244583mA
+ 5.578ns 0.252321mA
+ 5.58ns 0.260058mA
+ 5.582ns 0.267797mA
+ 5.584ns 0.275534mA
+ 5.586ns 0.283272mA
+ 5.588ns 0.291011mA
+ 5.59ns 0.298748mA
+ 5.592ns 0.306485mA
+ 5.594ns 0.314223mA
+ 5.596ns 0.321962mA
+ 5.598ns 0.329699mA
+ 5.6ns 0.337436mA
+ 5.602ns 0.345176mA
+ 5.604ns 0.352913mA
+ 5.606ns 0.36065mA
+ 5.608ns 0.368389mA
+ 5.61ns 0.376126mA
+ 5.612ns 0.383864mA
+ 5.614ns 0.391601mA
+ 5.616ns 0.39934mA
+ 5.618ns 0.407077mA
+ 5.62ns 0.414815mA
+ 5.622ns 0.422554mA
+ 5.624ns 0.430291mA
+ 5.626ns 0.438028mA
+ 5.628ns 0.445768mA
+ 5.63ns 0.453505mA
+ 5.632ns 0.461242mA
+ 5.634ns 0.468981mA
+ 5.636ns 0.476719mA
+ 5.638ns 0.484456mA
+ 5.64ns 0.492193mA
+ 5.642ns 0.499932mA
+ 5.644ns 0.50767mA
+ 5.646ns 0.515407mA
+ 5.648ns 0.523146mA
+ 5.65ns 0.530883mA
+ 5.652ns 0.538621mA
+ 5.654ns 0.54636mA
+ 5.656ns 0.55004mA
+ 5.658ns 0.547644mA
+ 5.66ns 0.545259mA
+ 5.662ns 0.542883mA
+ 5.664ns 0.540519mA
+ 5.666ns 0.538164mA
+ 5.668ns 0.53582mA
+ 5.67ns 0.533486mA
+ 5.672ns 0.531162mA
+ 5.674ns 0.528848mA
+ 5.676ns 0.526545mA
+ 5.678ns 0.524251mA
+ 5.68ns 0.521967mA
+ 5.682ns 0.519694mA
+ 5.684ns 0.51743mA
+ 5.686ns 0.515176mA
+ 5.688ns 0.512932mA
+ 5.69ns 0.510698mA
+ 5.692ns 0.508473mA
+ 5.694ns 0.506258mA
+ 5.696ns 0.504053mA
+ 5.698ns 0.501857mA
+ 5.7ns 0.499671mA
+ 5.702ns 0.497494mA
+ 5.704ns 0.495328mA
+ 5.706ns 0.49317mA
+ 5.708ns 0.491021mA
+ 5.71ns 0.488883mA
+ 5.712ns 0.486753mA
+ 5.714ns 0.484632mA
+ 5.716ns 0.482522mA
+ 5.718ns 0.48042mA
+ 5.72ns 0.478327mA
+ 5.722ns 0.476243mA
+ 5.724ns 0.474169mA
+ 5.726ns 0.472103mA
+ 5.728ns 0.470047mA
+ 5.73ns 0.467999mA
+ 5.732ns 0.465961mA
+ 5.734ns 0.463931mA
+ 5.736ns 0.46191mA
+ 5.738ns 0.459898mA
+ 5.74ns 0.457894mA
+ 5.742ns 0.4559mA
+ 5.744ns 0.453914mA
+ 5.746ns 0.451936mA
+ 5.748ns 0.449968mA
+ 5.75ns 0.448008mA
+ 5.752ns 0.446056mA
+ 5.754ns 0.444113mA
+ 5.756ns 0.442178mA
+ 5.758ns 0.440252mA
+ 5.76ns 0.438334mA
+ 5.762ns 0.436425mA
+ 5.764ns 0.434524mA
+ 5.766ns 0.432631mA
+ 5.768ns 0.430746mA
+ 5.77ns 0.42887mA
+ 5.772ns 0.427001mA
+ 5.774ns 0.425141mA
+ 5.776ns 0.423289mA
+ 5.778ns 0.421446mA
+ 5.78ns 0.419609mA
+ 5.782ns 0.417782mA
+ 5.784ns 0.415962mA
+ 5.786ns 0.41415mA
+ 5.788ns 0.412346mA
+ 5.79ns 0.410549mA
+ 5.792ns 0.408761mA
+ 5.794ns 0.40698mA
+ 5.796ns 0.405207mA
+ 5.798ns 0.403442mA
+ 5.8ns 0.401684mA
+ 5.802ns 0.399935mA
+ 5.804ns 0.398193mA
+ 5.806ns 0.396458mA
+ 5.808ns 0.394731mA
+ 5.81ns 0.393011mA
+ 5.812ns 0.391299mA
+ 5.814ns 0.389595mA
+ 5.816ns 0.387897mA
+ 5.818ns 0.386207mA
+ 5.82ns 0.384525mA
+ 5.822ns 0.38285mA
+ 5.824ns 0.381182mA
+ 5.826ns 0.379522mA
+ 5.828ns 0.377868mA
+ 5.83ns 0.376222mA
+ 5.832ns 0.374583mA
+ 5.834ns 0.372951mA
+ 5.836ns 0.371327mA
+ 5.838ns 0.369709mA
+ 5.84ns 0.368098mA
+ 5.842ns 0.366495mA
+ 5.844ns 0.364899mA
+ 5.846ns 0.363309mA
+ 5.848ns 0.361726mA
+ 5.85ns 0.36015mA
+ 5.852ns 0.358581mA
+ 5.854ns 0.357019mA
+ 5.856ns 0.355464mA
+ 5.858ns 0.353915mA
+ 5.86ns 0.352374mA
+ 5.862ns 0.350839mA
+ 5.864ns 0.34931mA
+ 5.866ns 0.347788mA
+ 5.868ns 0.346273mA
+ 5.87ns 0.344765mA
+ 5.872ns 0.343263mA
+ 5.874ns 0.341767mA
+ 5.876ns 0.340279mA
+ 5.878ns 0.338796mA
+ 5.88ns 0.33732mA
+ 5.882ns 0.335851mA
+ 5.884ns 0.334387mA
+ 5.886ns 0.332931mA
+ 5.888ns 0.33148mA
+ 5.89ns 0.330036mA
+ 5.892ns 0.328598mA
+ 5.894ns 0.327167mA
+ 5.896ns 0.325742mA
+ 5.898ns 0.324322mA
+ 5.9ns 0.32291mA
+ 5.902ns 0.321503mA
+ 5.904ns 0.320102mA
+ 5.906ns 0.318708mA
+ 5.908ns 0.317319mA
+ 5.91ns 0.315937mA
+ 5.912ns 0.31456mA
+ 5.914ns 0.31319mA
+ 5.916ns 0.311826mA
+ 5.918ns 0.310467mA
+ 5.92ns 0.309115mA
+ 5.922ns 0.307768mA
+ 5.924ns 0.306427mA
+ 5.926ns 0.305092mA
+ 5.928ns 0.303763mA
+ 5.93ns 0.30244mA
+ 5.932ns 0.301122mA
+ 5.934ns 0.29981mA
+ 5.936ns 0.298504mA
+ 5.938ns 0.297204mA
+ 5.94ns 0.295909mA
+ 5.942ns 0.29462mA
+ 5.944ns 0.293336mA
+ 5.946ns 0.292058mA
+ 5.948ns 0.290786mA
+ 5.95ns 0.289519mA
+ 5.952ns 0.288258mA
+ 5.954ns 0.287002mA
+ 5.956ns 0.285751mA
+ 5.958ns 0.284507mA
+ 5.96ns 0.283267mA
+ 5.962ns 0.282033mA
+ 5.964ns 0.280804mA
+ 5.966ns 0.279581mA
+ 5.968ns 0.278363mA
+ 5.97ns 0.27715mA
+ 5.972ns 0.275943mA
+ 5.974ns 0.274741mA
+ 5.976ns 0.273543mA
+ 5.978ns 0.272352mA
+ 5.98ns 0.271165mA
+ 5.982ns 0.269984mA
+ 5.984ns 0.268808mA
+ 5.986ns 0.267637mA
+ 5.988ns 0.266471mA
+ 5.99ns 0.26531mA
+ 5.992ns 0.264154mA
+ 5.994ns 0.263003mA
+ 5.996ns 0.261857mA
+ 5.998ns 0.260716mA
+ 6ns 0.25958mA
+ 6.002ns 0.25845mA
+ 6.004ns 0.257323mA
+ 6.006ns 0.256202mA
+ 6.008ns 0.255086mA
+ 6.01ns 0.253975mA
+ 6.012ns 0.252868mA
+ 6.014ns 0.251767mA
+ 6.016ns 0.25067mA
+ 6.018ns 0.249578mA
+ 6.02ns 0.24849mA
+ 6.022ns 0.247408mA
+ 6.024ns 0.24633mA
+ 6.026ns 0.245257mA
+ 6.028ns 0.244188mA
+ 6.03ns 0.243124mA
+ 6.032ns 0.242065mA
+ 6.034ns 0.24101mA
+ 6.036ns 0.23996mA
+ 6.038ns 0.238915mA
+ 6.04ns 0.237874mA
+ 6.042ns 0.236838mA
+ 6.044ns 0mA
I14 20 0 PWL 0 0
+ 2.996ns 0mA
+ 2.998ns 0.00149374mA
+ 3ns 0.00923275mA
+ 3.002ns 0.0169727mA
+ 3.004ns 0.0247117mA
+ 3.006ns 0.0324516mA
+ 3.008ns 0.0401916mA
+ 3.01ns 0.0479306mA
+ 3.012ns 0.0556705mA
+ 3.014ns 0.0634095mA
+ 3.016ns 0.0711495mA
+ 3.018ns 0.0788894mA
+ 3.02ns 0.0866284mA
+ 3.022ns 0.0943684mA
+ 3.024ns 0.102108mA
+ 3.026ns 0.109847mA
+ 3.028ns 0.117587mA
+ 3.03ns 0.125326mA
+ 3.032ns 0.133066mA
+ 3.034ns 0.140806mA
+ 3.036ns 0.148545mA
+ 3.038ns 0.156285mA
+ 3.04ns 0.164024mA
+ 3.042ns 0.171764mA
+ 3.044ns 0.179504mA
+ 3.046ns 0.187243mA
+ 3.048ns 0.194983mA
+ 3.05ns 0.202722mA
+ 3.052ns 0.210462mA
+ 3.054ns 0.218202mA
+ 3.056ns 0.225941mA
+ 3.058ns 0.233681mA
+ 3.06ns 0.24142mA
+ 3.062ns 0.24916mA
+ 3.064ns 0.2569mA
+ 3.066ns 0.264639mA
+ 3.068ns 0.272379mA
+ 3.07ns 0.280118mA
+ 3.072ns 0.287858mA
+ 3.074ns 0.295598mA
+ 3.076ns 0.303337mA
+ 3.078ns 0.311076mA
+ 3.08ns 0.318816mA
+ 3.082ns 0.326555mA
+ 3.084ns 0.334295mA
+ 3.086ns 0.342034mA
+ 3.088ns 0.349774mA
+ 3.09ns 0.357514mA
+ 3.092ns 0.365253mA
+ 3.094ns 0.372993mA
+ 3.096ns 0.380732mA
+ 3.098ns 0.388472mA
+ 3.1ns 0.396212mA
+ 3.102ns 0.403951mA
+ 3.104ns 0.411691mA
+ 3.106ns 0.41943mA
+ 3.108ns 0.42717mA
+ 3.11ns 0.43491mA
+ 3.112ns 0.442649mA
+ 3.114ns 0.450389mA
+ 3.116ns 0.458128mA
+ 3.118ns 0.465868mA
+ 3.12ns 0.473608mA
+ 3.122ns 0.481347mA
+ 3.124ns 0.489087mA
+ 3.126ns 0.496827mA
+ 3.128ns 0.504566mA
+ 3.13ns 0.512306mA
+ 3.132ns 0.520045mA
+ 3.134ns 0.527785mA
+ 3.136ns 0.535525mA
+ 3.138ns 0.543264mA
+ 3.14ns 0.551003mA
+ 3.142ns 0.549107mA
+ 3.144ns 0.546714mA
+ 3.146ns 0.544331mA
+ 3.148ns 0.54196mA
+ 3.15ns 0.539598mA
+ 3.152ns 0.537246mA
+ 3.154ns 0.534905mA
+ 3.156ns 0.532574mA
+ 3.158ns 0.530253mA
+ 3.16ns 0.527942mA
+ 3.162ns 0.525642mA
+ 3.164ns 0.523351mA
+ 3.166ns 0.52107mA
+ 3.168ns 0.518799mA
+ 3.17ns 0.516538mA
+ 3.172ns 0.514287mA
+ 3.174ns 0.512046mA
+ 3.176ns 0.509815mA
+ 3.178ns 0.507593mA
+ 3.18ns 0.505381mA
+ 3.182ns 0.503178mA
+ 3.184ns 0.500986mA
+ 3.186ns 0.498802mA
+ 3.188ns 0.496629mA
+ 3.19ns 0.494464mA
+ 3.192ns 0.492309mA
+ 3.194ns 0.490164mA
+ 3.196ns 0.488028mA
+ 3.198ns 0.485901mA
+ 3.2ns 0.483783mA
+ 3.202ns 0.481675mA
+ 3.204ns 0.479576mA
+ 3.206ns 0.477486mA
+ 3.208ns 0.475405mA
+ 3.21ns 0.473333mA
+ 3.212ns 0.47127mA
+ 3.214ns 0.469217mA
+ 3.216ns 0.467172mA
+ 3.218ns 0.465136mA
+ 3.22ns 0.463109mA
+ 3.222ns 0.461091mA
+ 3.224ns 0.459081mA
+ 3.226ns 0.45708mA
+ 3.228ns 0.455088mA
+ 3.23ns 0.453105mA
+ 3.232ns 0.45113mA
+ 3.234ns 0.449165mA
+ 3.236ns 0.447207mA
+ 3.238ns 0.445258mA
+ 3.24ns 0.443318mA
+ 3.242ns 0.441385mA
+ 3.244ns 0.439462mA
+ 3.246ns 0.437547mA
+ 3.248ns 0.43564mA
+ 3.25ns 0.433741mA
+ 3.252ns 0.431851mA
+ 3.254ns 0.429969mA
+ 3.256ns 0.428095mA
+ 3.258ns 0.426229mA
+ 3.26ns 0.424372mA
+ 3.262ns 0.422522mA
+ 3.264ns 0.420681mA
+ 3.266ns 0.418848mA
+ 3.268ns 0.417022mA
+ 3.27ns 0.415205mA
+ 3.272ns 0.413395mA
+ 3.274ns 0.411593mA
+ 3.276ns 0.4098mA
+ 3.278ns 0.408014mA
+ 3.28ns 0.406236mA
+ 3.282ns 0.404465mA
+ 3.284ns 0.402702mA
+ 3.286ns 0.400947mA
+ 3.288ns 0.3992mA
+ 3.29ns 0.39746mA
+ 3.292ns 0.395728mA
+ 3.294ns 0.394003mA
+ 3.296ns 0.392286mA
+ 3.298ns 0.390576mA
+ 3.3ns 0.388874mA
+ 3.302ns 0.387179mA
+ 3.304ns 0.385492mA
+ 3.306ns 0.383812mA
+ 3.308ns 0.382139mA
+ 3.31ns 0.380474mA
+ 3.312ns 0.378816mA
+ 3.314ns 0.377164mA
+ 3.316ns 0.375521mA
+ 3.318ns 0.373884mA
+ 3.32ns 0.372255mA
+ 3.322ns 0.370632mA
+ 3.324ns 0.369017mA
+ 3.326ns 0.367409mA
+ 3.328ns 0.365807mA
+ 3.33ns 0.364213mA
+ 3.332ns 0.362626mA
+ 3.334ns 0.361045mA
+ 3.336ns 0.359472mA
+ 3.338ns 0.357905mA
+ 3.34ns 0.356345mA
+ 3.342ns 0.354792mA
+ 3.344ns 0.353246mA
+ 3.346ns 0.351706mA
+ 3.348ns 0.350173mA
+ 3.35ns 0.348647mA
+ 3.352ns 0.347128mA
+ 3.354ns 0.345615mA
+ 3.356ns 0.344109mA
+ 3.358ns 0.342609mA
+ 3.36ns 0.341116mA
+ 3.362ns 0.339629mA
+ 3.364ns 0.338149mA
+ 3.366ns 0.336675mA
+ 3.368ns 0.335208mA
+ 3.37ns 0.333747mA
+ 3.372ns 0.332292mA
+ 3.374ns 0.330844mA
+ 3.376ns 0.329402mA
+ 3.378ns 0.327966mA
+ 3.38ns 0.326537mA
+ 3.382ns 0.325114mA
+ 3.384ns 0.323697mA
+ 3.386ns 0.322286mA
+ 3.388ns 0.320881mA
+ 3.39ns 0.319483mA
+ 3.392ns 0.31809mA
+ 3.394ns 0.316704mA
+ 3.396ns 0.315323mA
+ 3.398ns 0.313949mA
+ 3.4ns 0.312581mA
+ 3.402ns 0.311218mA
+ 3.404ns 0.309862mA
+ 3.406ns 0.308511mA
+ 3.408ns 0.307167mA
+ 3.41ns 0.305828mA
+ 3.412ns 0.304495mA
+ 3.414ns 0.303168mA
+ 3.416ns 0.301847mA
+ 3.418ns 0.300531mA
+ 3.42ns 0.299221mA
+ 3.422ns 0.297917mA
+ 3.424ns 0.296618mA
+ 3.426ns 0.295326mA
+ 3.428ns 0.294039mA
+ 3.43ns 0.292757mA
+ 3.432ns 0.291481mA
+ 3.434ns 0.290211mA
+ 3.436ns 0.288946mA
+ 3.438ns 0.287686mA
+ 3.44ns 0.286432mA
+ 3.442ns 0.285184mA
+ 3.444ns 0.283941mA
+ 3.446ns 0.282703mA
+ 3.448ns 0.281471mA
+ 3.45ns 0.280244mA
+ 3.452ns 0.279023mA
+ 3.454ns 0.277807mA
+ 3.456ns 0.276596mA
+ 3.458ns 0.27539mA
+ 3.46ns 0.27419mA
+ 3.462ns 0.272995mA
+ 3.464ns 0.271805mA
+ 3.466ns 0.27062mA
+ 3.468ns 0.269441mA
+ 3.47ns 0.268266mA
+ 3.472ns 0.267097mA
+ 3.474ns 0.265933mA
+ 3.476ns 0.264774mA
+ 3.478ns 0.26362mA
+ 3.48ns 0.262471mA
+ 3.482ns 0.261327mA
+ 3.484ns 0.260188mA
+ 3.486ns 0.259054mA
+ 3.488ns 0.257924mA
+ 3.49ns 0.2568mA
+ 3.492ns 0.255681mA
+ 3.494ns 0.254567mA
+ 3.496ns 0.253457mA
+ 3.498ns 0.252352mA
+ 3.5ns 0.251252mA
+ 3.502ns 0.250157mA
+ 3.504ns 0.249067mA
+ 3.506ns 0.247981mA
+ 3.508ns 0.2469mA
+ 3.51ns 0.245824mA
+ 3.512ns 0.244753mA
+ 3.514ns 0.243686mA
+ 3.516ns 0.242624mA
+ 3.518ns 0.241566mA
+ 3.52ns 0.240513mA
+ 3.522ns 0.239465mA
+ 3.524ns 0.238421mA
+ 3.526ns 0.237382mA
+ 3.528ns 0.236347mA
+ 3.53ns 0mA
I15 21 0 PWL 0 0
+ 2.636ns 0mA
+ 2.638ns 0.000917718mA
+ 2.64ns 0.00560332mA
+ 2.642ns 0.0102884mA
+ 2.644ns 0.014974mA
+ 2.646ns 0.0196596mA
+ 2.648ns 0.0243446mA
+ 2.65ns 0.0290302mA
+ 2.652ns 0.0337152mA
+ 2.654ns 0.0384008mA
+ 2.656ns 0.0430864mA
+ 2.658ns 0.0477715mA
+ 2.66ns 0.0524571mA
+ 2.662ns 0.0571421mA
+ 2.664ns 0.0618277mA
+ 2.666ns 0.0665133mA
+ 2.668ns 0.0711984mA
+ 2.67ns 0.075884mA
+ 2.672ns 0.080569mA
+ 2.674ns 0.0852546mA
+ 2.676ns 0.0899402mA
+ 2.678ns 0.0946252mA
+ 2.68ns 0.0993109mA
+ 2.682ns 0.103996mA
+ 2.684ns 0.106562mA
+ 2.686ns 0.102854mA
+ 2.688ns 0.0992764mA
+ 2.69ns 0.0958224mA
+ 2.692ns 0.0924885mA
+ 2.694ns 0.089271mA
+ 2.696ns 0.0861651mA
+ 2.698ns 0.0831675mA
+ 2.7ns 0.0802738mA
+ 2.702ns 0.0774808mA
+ 2.704ns 0.0747853mA
+ 2.706ns 0.0721832mA
+ 2.708ns 0.0696719mA
+ 2.71ns 0.0672477mA
+ 2.712ns 0.0649078mA
+ 2.714ns 0.0626496mA
+ 2.716ns 0.0604697mA
+ 2.718ns 0.0583659mA
+ 2.72ns 0.056335mA
+ 2.722ns 0.0543747mA
+ 2.724ns 0.0524829mA
+ 2.726ns 0.0506566mA
+ 2.728ns 0.0488941mA
+ 2.73ns 0.0471927mA
+ 2.732ns 0.0455505mA
+ 2.734ns 0.0439656mA
+ 2.736ns 0.0424357mA
+ 2.738ns 0.0409591mA
+ 2.74ns 0.0395338mA
+ 2.742ns 0.0381581mA
+ 2.744ns 0.0368303mA
+ 2.746ns 0mA
I16 22 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.00997265mA
+ 2.654ns 0.0209576mA
+ 2.656ns 0.0319426mA
+ 2.658ns 0.0429263mA
+ 2.66ns 0.0539113mA
+ 2.662ns 0.064895mA
+ 2.664ns 0.07588mA
+ 2.666ns 0.0691998mA
+ 2.668ns 0.0570924mA
+ 2.67ns 0.0471018mA
+ 2.672ns 0.03886mA
+ 2.674ns 0.0320593mA
+ 2.676ns 0.0264485mA
+ 2.678ns 0.02182mA
+ 2.68ns 0mA
I17 24 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00695591mA
+ 2.656ns 0.0184617mA
+ 2.658ns 0.0299661mA
+ 2.66ns 0.0414719mA
+ 2.662ns 0.0529763mA
+ 2.664ns 0.064482mA
+ 2.666ns 0.0759878mA
+ 2.668ns 0.0874922mA
+ 2.67ns 0.098998mA
+ 2.672ns 0.110502mA
+ 2.674ns 0.104617mA
+ 2.676ns 0.0910152mA
+ 2.678ns 0.0791832mA
+ 2.68ns 0.0688879mA
+ 2.682ns 0.0599318mA
+ 2.684ns 0.052139mA
+ 2.686ns 0.0453593mA
+ 2.688ns 0.0394616mA
+ 2.69ns 0.0343301mA
+ 2.692ns 0.0298656mA
+ 2.694ns 0mA
I18 25 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00645204mA
+ 2.656ns 0.0177767mA
+ 2.658ns 0.0291mA
+ 2.66ns 0.0404247mA
+ 2.662ns 0.051748mA
+ 2.664ns 0.0630727mA
+ 2.666ns 0.0743974mA
+ 2.668ns 0.0857207mA
+ 2.67ns 0.0970454mA
+ 2.672ns 0.108369mA
+ 2.674ns 0.117001mA
+ 2.676ns 0.10249mA
+ 2.678ns 0.0897795mA
+ 2.68ns 0.0786439mA
+ 2.682ns 0.0688902mA
+ 2.684ns 0.060345mA
+ 2.686ns 0.0528596mA
+ 2.688ns 0.0463032mA
+ 2.69ns 0.0405592mA
+ 2.692ns 0.0355276mA
+ 2.694ns 0.0311205mA
+ 2.696ns 0mA
I19 29 0 PWL 0 0
+ 2.892ns 0mA
+ 2.894ns 0.000355067mA
+ 2.896ns 0.00431605mA
+ 2.898ns 0.00827656mA
+ 2.9ns 0.0122375mA
+ 2.902ns 0.0161981mA
+ 2.904ns 0.020159mA
+ 2.906ns 0.02412mA
+ 2.908ns 0.0280805mA
+ 2.91ns 0.0320415mA
+ 2.912ns 0.036002mA
+ 2.914ns 0.039963mA
+ 2.916ns 0.043924mA
+ 2.918ns 0.0478845mA
+ 2.92ns 0.0518455mA
+ 2.922ns 0.055806mA
+ 2.924ns 0.059767mA
+ 2.926ns 0.063728mA
+ 2.928ns 0.0676885mA
+ 2.93ns 0.0716494mA
+ 2.932ns 0.0756104mA
+ 2.934ns 0.0795709mA
+ 2.936ns 0.0835319mA
+ 2.938ns 0.0874924mA
+ 2.94ns 0.0914534mA
+ 2.942ns 0.0954144mA
+ 2.944ns 0.0993749mA
+ 2.946ns 0.103336mA
+ 2.948ns 0.107296mA
+ 2.95ns 0.111257mA
+ 2.952ns 0.115218mA
+ 2.954ns 0.119179mA
+ 2.956ns 0.12314mA
+ 2.958ns 0.1271mA
+ 2.96ns 0.131061mA
+ 2.962ns 0.135022mA
+ 2.964ns 0.138983mA
+ 2.966ns 0.142944mA
+ 2.968ns 0.146904mA
+ 2.97ns 0.150865mA
+ 2.972ns 0.154826mA
+ 2.974ns 0.158787mA
+ 2.976ns 0.162748mA
+ 2.978ns 0.166709mA
+ 2.98ns 0.170669mA
+ 2.982ns 0.17463mA
+ 2.984ns 0.178591mA
+ 2.986ns 0.182552mA
+ 2.988ns 0.186513mA
+ 2.99ns 0.190473mA
+ 2.992ns 0.194434mA
+ 2.994ns 0.198395mA
+ 2.996ns 0.202356mA
+ 2.998ns 0.206317mA
+ 3ns 0.210277mA
+ 3.002ns 0.214238mA
+ 3.004ns 0.218199mA
+ 3.006ns 0.22216mA
+ 3.008ns 0.226121mA
+ 3.01ns 0.230081mA
+ 3.012ns 0.234042mA
+ 3.014ns 0.238003mA
+ 3.016ns 0.241964mA
+ 3.018ns 0.245925mA
+ 3.02ns 0.249885mA
+ 3.022ns 0.253846mA
+ 3.024ns 0.257807mA
+ 3.026ns 0.261768mA
+ 3.028ns 0.265729mA
+ 3.03ns 0.269689mA
+ 3.032ns 0.27365mA
+ 3.034ns 0.277611mA
+ 3.036ns 0.281572mA
+ 3.038ns 0.285533mA
+ 3.04ns 0.289493mA
+ 3.042ns 0.293454mA
+ 3.044ns 0.297415mA
+ 3.046ns 0.301376mA
+ 3.048ns 0.305337mA
+ 3.05ns 0.309297mA
+ 3.052ns 0.313258mA
+ 3.054ns 0.317219mA
+ 3.056ns 0.32118mA
+ 3.058ns 0.325141mA
+ 3.06ns 0.329101mA
+ 3.062ns 0.333062mA
+ 3.064ns 0.337023mA
+ 3.066ns 0.340984mA
+ 3.068ns 0.344944mA
+ 3.07ns 0.348905mA
+ 3.072ns 0.352866mA
+ 3.074ns 0.356827mA
+ 3.076ns 0.360787mA
+ 3.078ns 0.364748mA
+ 3.08ns 0.368709mA
+ 3.082ns 0.37267mA
+ 3.084ns 0.376631mA
+ 3.086ns 0.380591mA
+ 3.088ns 0.384552mA
+ 3.09ns 0.388513mA
+ 3.092ns 0.392474mA
+ 3.094ns 0.396435mA
+ 3.096ns 0.400395mA
+ 3.098ns 0.404356mA
+ 3.1ns 0.408317mA
+ 3.102ns 0.412278mA
+ 3.104ns 0.416239mA
+ 3.106ns 0.420199mA
+ 3.108ns 0.42416mA
+ 3.11ns 0.428121mA
+ 3.112ns 0.432082mA
+ 3.114ns 0.431707mA
+ 3.116ns 0.430254mA
+ 3.118ns 0.428806mA
+ 3.12ns 0.427362mA
+ 3.122ns 0.425924mA
+ 3.124ns 0.42449mA
+ 3.126ns 0.423061mA
+ 3.128ns 0.421637mA
+ 3.13ns 0.420217mA
+ 3.132ns 0.418803mA
+ 3.134ns 0.417393mA
+ 3.136ns 0.415988mA
+ 3.138ns 0.414588mA
+ 3.14ns 0.413192mA
+ 3.142ns 0.411801mA
+ 3.144ns 0.410415mA
+ 3.146ns 0.409033mA
+ 3.148ns 0.407656mA
+ 3.15ns 0.406284mA
+ 3.152ns 0.404916mA
+ 3.154ns 0.403553mA
+ 3.156ns 0.402195mA
+ 3.158ns 0.400841mA
+ 3.16ns 0.399492mA
+ 3.162ns 0.398147mA
+ 3.164ns 0.396806mA
+ 3.166ns 0.395471mA
+ 3.168ns 0.394139mA
+ 3.17ns 0.392813mA
+ 3.172ns 0.39149mA
+ 3.174ns 0.390172mA
+ 3.176ns 0.388859mA
+ 3.178ns 0.38755mA
+ 3.18ns 0.386245mA
+ 3.182ns 0.384945mA
+ 3.184ns 0.383649mA
+ 3.186ns 0.382358mA
+ 3.188ns 0.38107mA
+ 3.19ns 0.379788mA
+ 3.192ns 0.378509mA
+ 3.194ns 0.377235mA
+ 3.196ns 0.375965mA
+ 3.198ns 0.374699mA
+ 3.2ns 0.373438mA
+ 3.202ns 0.372181mA
+ 3.204ns 0.370928mA
+ 3.206ns 0.369679mA
+ 3.208ns 0.368435mA
+ 3.21ns 0.367194mA
+ 3.212ns 0.365958mA
+ 3.214ns 0.364726mA
+ 3.216ns 0.363499mA
+ 3.218ns 0.362275mA
+ 3.22ns 0.361055mA
+ 3.222ns 0.35984mA
+ 3.224ns 0.358629mA
+ 3.226ns 0.357421mA
+ 3.228ns 0.356218mA
+ 3.23ns 0.355019mA
+ 3.232ns 0.353824mA
+ 3.234ns 0.352633mA
+ 3.236ns 0.351445mA
+ 3.238ns 0.350262mA
+ 3.24ns 0.349083mA
+ 3.242ns 0.347908mA
+ 3.244ns 0.346737mA
+ 3.246ns 0.34557mA
+ 3.248ns 0.344406mA
+ 3.25ns 0.343247mA
+ 3.252ns 0.342091mA
+ 3.254ns 0.34094mA
+ 3.256ns 0.339792mA
+ 3.258ns 0.338648mA
+ 3.26ns 0.337508mA
+ 3.262ns 0.336372mA
+ 3.264ns 0.335239mA
+ 3.266ns 0.334111mA
+ 3.268ns 0.332986mA
+ 3.27ns 0.331865mA
+ 3.272ns 0.330748mA
+ 3.274ns 0.329634mA
+ 3.276ns 0.328525mA
+ 3.278ns 0.327419mA
+ 3.28ns 0.326316mA
+ 3.282ns 0.325218mA
+ 3.284ns 0.324123mA
+ 3.286ns 0.323032mA
+ 3.288ns 0.321944mA
+ 3.29ns 0.320861mA
+ 3.292ns 0.31978mA
+ 3.294ns 0.318704mA
+ 3.296ns 0.317631mA
+ 3.298ns 0.316562mA
+ 3.3ns 0.315496mA
+ 3.302ns 0.314434mA
+ 3.304ns 0.313375mA
+ 3.306ns 0.31232mA
+ 3.308ns 0.311269mA
+ 3.31ns 0.310221mA
+ 3.312ns 0.309176mA
+ 3.314ns 0.308136mA
+ 3.316ns 0.307098mA
+ 3.318ns 0.306064mA
+ 3.32ns 0.305034mA
+ 3.322ns 0.304007mA
+ 3.324ns 0.302984mA
+ 3.326ns 0.301964mA
+ 3.328ns 0.300947mA
+ 3.33ns 0.299934mA
+ 3.332ns 0.298924mA
+ 3.334ns 0.297918mA
+ 3.336ns 0.296915mA
+ 3.338ns 0.295915mA
+ 3.34ns 0.294919mA
+ 3.342ns 0.293926mA
+ 3.344ns 0.292937mA
+ 3.346ns 0.291951mA
+ 3.348ns 0.290968mA
+ 3.35ns 0.289988mA
+ 3.352ns 0.289012mA
+ 3.354ns 0.288039mA
+ 3.356ns 0.287069mA
+ 3.358ns 0.286103mA
+ 3.36ns 0.285139mA
+ 3.362ns 0.284179mA
+ 3.364ns 0.283223mA
+ 3.366ns 0.282269mA
+ 3.368ns 0.281319mA
+ 3.37ns 0.280372mA
+ 3.372ns 0.279428mA
+ 3.374ns 0.278487mA
+ 3.376ns 0.27755mA
+ 3.378ns 0.276615mA
+ 3.38ns 0.275684mA
+ 3.382ns 0.274756mA
+ 3.384ns 0.273831mA
+ 3.386ns 0.272909mA
+ 3.388ns 0.27199mA
+ 3.39ns 0.271074mA
+ 3.392ns 0.270162mA
+ 3.394ns 0.269252mA
+ 3.396ns 0.268346mA
+ 3.398ns 0.267442mA
+ 3.4ns 0.266542mA
+ 3.402ns 0.265645mA
+ 3.404ns 0.26475mA
+ 3.406ns 0.263859mA
+ 3.408ns 0.262971mA
+ 3.41ns 0.262085mA
+ 3.412ns 0.261203mA
+ 3.414ns 0.260324mA
+ 3.416ns 0.259447mA
+ 3.418ns 0.258574mA
+ 3.42ns 0.257703mA
+ 3.422ns 0.256836mA
+ 3.424ns 0.255971mA
+ 3.426ns 0.255109mA
+ 3.428ns 0.25425mA
+ 3.43ns 0.253394mA
+ 3.432ns 0.252541mA
+ 3.434ns 0.251691mA
+ 3.436ns 0.250844mA
+ 3.438ns 0.249999mA
+ 3.44ns 0.249157mA
+ 3.442ns 0.248318mA
+ 3.444ns 0.247483mA
+ 3.446ns 0.246649mA
+ 3.448ns 0.245819mA
+ 3.45ns 0.244991mA
+ 3.452ns 0.244166mA
+ 3.454ns 0.243344mA
+ 3.456ns 0.242525mA
+ 3.458ns 0.241709mA
+ 3.46ns 0.240895mA
+ 3.462ns 0.240084mA
+ 3.464ns 0.239276mA
+ 3.466ns 0.23847mA
+ 3.468ns 0.237667mA
+ 3.47ns 0.236867mA
+ 3.472ns 0.236069mA
+ 3.474ns 0.235275mA
+ 3.476ns 0.234483mA
+ 3.478ns 0.233693mA
+ 3.48ns 0.232906mA
+ 3.482ns 0.232122mA
+ 3.484ns 0.231341mA
+ 3.486ns 0.230562mA
+ 3.488ns 0.229786mA
+ 3.49ns 0.229012mA
+ 3.492ns 0.228241mA
+ 3.494ns 0.227472mA
+ 3.496ns 0.226707mA
+ 3.498ns 0.225943mA
+ 3.5ns 0.225183mA
+ 3.502ns 0.224424mA
+ 3.504ns 0.223669mA
+ 3.506ns 0.222916mA
+ 3.508ns 0.222165mA
+ 3.51ns 0.221417mA
+ 3.512ns 0.220672mA
+ 3.514ns 0.219929mA
+ 3.516ns 0.219188mA
+ 3.518ns 0.21845mA
+ 3.52ns 0.217715mA
+ 3.522ns 0.216982mA
+ 3.524ns 0.216251mA
+ 3.526ns 0.215523mA
+ 3.528ns 0.214798mA
+ 3.53ns 0.214075mA
+ 3.532ns 0.213354mA
+ 3.534ns 0.212635mA
+ 3.536ns 0.21192mA
+ 3.538ns 0.211206mA
+ 3.54ns 0.210495mA
+ 3.542ns 0.209786mA
+ 3.544ns 0.20908mA
+ 3.546ns 0.208376mA
+ 3.548ns 0.207674mA
+ 3.55ns 0.206975mA
+ 3.552ns 0.206278mA
+ 3.554ns 0.205584mA
+ 3.556ns 0.204892mA
+ 3.558ns 0.204202mA
+ 3.56ns 0.203514mA
+ 3.562ns 0.202829mA
+ 3.564ns 0.202146mA
+ 3.566ns 0.201466mA
+ 3.568ns 0.200787mA
+ 3.57ns 0.200111mA
+ 3.572ns 0.199437mA
+ 3.574ns 0.198766mA
+ 3.576ns 0.198097mA
+ 3.578ns 0.19743mA
+ 3.58ns 0.196765mA
+ 3.582ns 0.196103mA
+ 3.584ns 0.195442mA
+ 3.586ns 0.194784mA
+ 3.588ns 0.194128mA
+ 3.59ns 0.193475mA
+ 3.592ns 0.192823mA
+ 3.594ns 0.192174mA
+ 3.596ns 0.191527mA
+ 3.598ns 0.190882mA
+ 3.6ns 0.19024mA
+ 3.602ns 0.189599mA
+ 3.604ns 0.188961mA
+ 3.606ns 0.188324mA
+ 3.608ns 0.18769mA
+ 3.61ns 0.187058mA
+ 3.612ns 0.186429mA
+ 3.614ns 0.185801mA
+ 3.616ns 0.185175mA
+ 3.618ns 0.184552mA
+ 3.62ns 0.18393mA
+ 3.622ns 0.183311mA
+ 3.624ns 0.182694mA
+ 3.626ns 0.182079mA
+ 3.628ns 0.181466mA
+ 3.63ns 0.180855mA
+ 3.632ns 0.180246mA
+ 3.634ns 0mA
I20 30 0 PWL 0 0
+ 5.516ns 0mA
+ 5.518ns 0.00100391mA
+ 5.52ns 0.00863665mA
+ 5.522ns 0.0162694mA
+ 5.524ns 0.0239039mA
+ 5.526ns 0.0315367mA
+ 5.528ns 0.0391694mA
+ 5.53ns 0.046804mA
+ 5.532ns 0.0544367mA
+ 5.534ns 0.0620694mA
+ 5.536ns 0.069704mA
+ 5.538ns 0.0773367mA
+ 5.54ns 0.0849695mA
+ 5.542ns 0.092604mA
+ 5.544ns 0.100237mA
+ 5.546ns 0.107869mA
+ 5.548ns 0.115502mA
+ 5.55ns 0.123137mA
+ 5.552ns 0.13077mA
+ 5.554ns 0.138402mA
+ 5.556ns 0.146037mA
+ 5.558ns 0.15367mA
+ 5.56ns 0.161302mA
+ 5.562ns 0.168937mA
+ 5.564ns 0.17657mA
+ 5.566ns 0.184202mA
+ 5.568ns 0.191835mA
+ 5.57ns 0.19947mA
+ 5.572ns 0.207102mA
+ 5.574ns 0.214735mA
+ 5.576ns 0.22237mA
+ 5.578ns 0.230002mA
+ 5.58ns 0.237635mA
+ 5.582ns 0.24527mA
+ 5.584ns 0.252902mA
+ 5.586ns 0.260535mA
+ 5.588ns 0.26817mA
+ 5.59ns 0.275802mA
+ 5.592ns 0.283435mA
+ 5.594ns 0.291068mA
+ 5.596ns 0.298702mA
+ 5.598ns 0.306335mA
+ 5.6ns 0.313968mA
+ 5.602ns 0.321602mA
+ 5.604ns 0.329235mA
+ 5.606ns 0.336868mA
+ 5.608ns 0.344503mA
+ 5.61ns 0.352135mA
+ 5.612ns 0.359768mA
+ 5.614ns 0.367401mA
+ 5.616ns 0.375035mA
+ 5.618ns 0.382668mA
+ 5.62ns 0.390301mA
+ 5.622ns 0.397935mA
+ 5.624ns 0.405568mA
+ 5.626ns 0.413201mA
+ 5.628ns 0.420835mA
+ 5.63ns 0.428468mA
+ 5.632ns 0.436101mA
+ 5.634ns 0.443735mA
+ 5.636ns 0.451368mA
+ 5.638ns 0.459001mA
+ 5.64ns 0.466634mA
+ 5.642ns 0.474268mA
+ 5.644ns 0.481901mA
+ 5.646ns 0.489534mA
+ 5.648ns 0.497168mA
+ 5.65ns 0.504801mA
+ 5.652ns 0.512434mA
+ 5.654ns 0.520068mA
+ 5.656ns 0.527701mA
+ 5.658ns 0.535334mA
+ 5.66ns 0.540478mA
+ 5.662ns 0.538168mA
+ 5.664ns 0.535868mA
+ 5.666ns 0.533578mA
+ 5.668ns 0.531297mA
+ 5.67ns 0.529027mA
+ 5.672ns 0.526766mA
+ 5.674ns 0.524514mA
+ 5.676ns 0.522273mA
+ 5.678ns 0.520041mA
+ 5.68ns 0.517818mA
+ 5.682ns 0.515605mA
+ 5.684ns 0.513402mA
+ 5.686ns 0.511208mA
+ 5.688ns 0.509023mA
+ 5.69ns 0.506847mA
+ 5.692ns 0.504681mA
+ 5.694ns 0.502524mA
+ 5.696ns 0.500377mA
+ 5.698ns 0.498238mA
+ 5.7ns 0.496109mA
+ 5.702ns 0.493988mA
+ 5.704ns 0.491877mA
+ 5.706ns 0.489775mA
+ 5.708ns 0.487682mA
+ 5.71ns 0.485598mA
+ 5.712ns 0.483522mA
+ 5.714ns 0.481456mA
+ 5.716ns 0.479398mA
+ 5.718ns 0.477349mA
+ 5.72ns 0.475309mA
+ 5.722ns 0.473278mA
+ 5.724ns 0.471255mA
+ 5.726ns 0.469241mA
+ 5.728ns 0.467235mA
+ 5.73ns 0.465239mA
+ 5.732ns 0.46325mA
+ 5.734ns 0.46127mA
+ 5.736ns 0.459299mA
+ 5.738ns 0.457336mA
+ 5.74ns 0.455381mA
+ 5.742ns 0.453435mA
+ 5.744ns 0.451497mA
+ 5.746ns 0.449567mA
+ 5.748ns 0.447646mA
+ 5.75ns 0.445733mA
+ 5.752ns 0.443828mA
+ 5.754ns 0.441931mA
+ 5.756ns 0.440042mA
+ 5.758ns 0.438162mA
+ 5.76ns 0.436289mA
+ 5.762ns 0.434424mA
+ 5.764ns 0.432567mA
+ 5.766ns 0.430718mA
+ 5.768ns 0.428878mA
+ 5.77ns 0.427045mA
+ 5.772ns 0.425219mA
+ 5.774ns 0.423402mA
+ 5.776ns 0.421593mA
+ 5.778ns 0.419791mA
+ 5.78ns 0.417996mA
+ 5.782ns 0.41621mA
+ 5.784ns 0.414431mA
+ 5.786ns 0.41266mA
+ 5.788ns 0.410896mA
+ 5.79ns 0.40914mA
+ 5.792ns 0.407391mA
+ 5.794ns 0.40565mA
+ 5.796ns 0.403916mA
+ 5.798ns 0.40219mA
+ 5.8ns 0.400471mA
+ 5.802ns 0.398759mA
+ 5.804ns 0.397055mA
+ 5.806ns 0.395358mA
+ 5.808ns 0.393668mA
+ 5.81ns 0.391986mA
+ 5.812ns 0.39031mA
+ 5.814ns 0.388642mA
+ 5.816ns 0.386981mA
+ 5.818ns 0.385327mA
+ 5.82ns 0.38368mA
+ 5.822ns 0.38204mA
+ 5.824ns 0.380408mA
+ 5.826ns 0.378781mA
+ 5.828ns 0.377163mA
+ 5.83ns 0.375551mA
+ 5.832ns 0.373945mA
+ 5.834ns 0.372347mA
+ 5.836ns 0.370756mA
+ 5.838ns 0.369171mA
+ 5.84ns 0.367593mA
+ 5.842ns 0.366022mA
+ 5.844ns 0.364458mA
+ 5.846ns 0.3629mA
+ 5.848ns 0.361349mA
+ 5.85ns 0.359804mA
+ 5.852ns 0.358266mA
+ 5.854ns 0.356735mA
+ 5.856ns 0.355211mA
+ 5.858ns 0.353692mA
+ 5.86ns 0.35218mA
+ 5.862ns 0.350675mA
+ 5.864ns 0.349176mA
+ 5.866ns 0.347684mA
+ 5.868ns 0.346198mA
+ 5.87ns 0.344718mA
+ 5.872ns 0.343245mA
+ 5.874ns 0.341778mA
+ 5.876ns 0.340317mA
+ 5.878ns 0.338862mA
+ 5.88ns 0.337414mA
+ 5.882ns 0.335972mA
+ 5.884ns 0.334536mA
+ 5.886ns 0.333106mA
+ 5.888ns 0.331682mA
+ 5.89ns 0.330264mA
+ 5.892ns 0.328853mA
+ 5.894ns 0.327447mA
+ 5.896ns 0.326048mA
+ 5.898ns 0.324654mA
+ 5.9ns 0.323266mA
+ 5.902ns 0.321885mA
+ 5.904ns 0.320509mA
+ 5.906ns 0.319139mA
+ 5.908ns 0.317775mA
+ 5.91ns 0.316416mA
+ 5.912ns 0.315064mA
+ 5.914ns 0.313717mA
+ 5.916ns 0.312377mA
+ 5.918ns 0.311041mA
+ 5.92ns 0.309712mA
+ 5.922ns 0.308388mA
+ 5.924ns 0.30707mA
+ 5.926ns 0.305757mA
+ 5.928ns 0.30445mA
+ 5.93ns 0.303149mA
+ 5.932ns 0.301853mA
+ 5.934ns 0.300563mA
+ 5.936ns 0.299278mA
+ 5.938ns 0.297999mA
+ 5.94ns 0.296725mA
+ 5.942ns 0.295457mA
+ 5.944ns 0.294194mA
+ 5.946ns 0.292937mA
+ 5.948ns 0.291685mA
+ 5.95ns 0.290438mA
+ 5.952ns 0.289196mA
+ 5.954ns 0.28796mA
+ 5.956ns 0.286729mA
+ 5.958ns 0.285504mA
+ 5.96ns 0.284284mA
+ 5.962ns 0.283068mA
+ 5.964ns 0.281858mA
+ 5.966ns 0.280654mA
+ 5.968ns 0.279454mA
+ 5.97ns 0.278259mA
+ 5.972ns 0.27707mA
+ 5.974ns 0.275886mA
+ 5.976ns 0.274706mA
+ 5.978ns 0.273532mA
+ 5.98ns 0.272363mA
+ 5.982ns 0.271199mA
+ 5.984ns 0.27004mA
+ 5.986ns 0.268885mA
+ 5.988ns 0.267736mA
+ 5.99ns 0.266592mA
+ 5.992ns 0.265452mA
+ 5.994ns 0.264318mA
+ 5.996ns 0.263188mA
+ 5.998ns 0.262063mA
+ 6ns 0.260943mA
+ 6.002ns 0.259827mA
+ 6.004ns 0.258716mA
+ 6.006ns 0.257611mA
+ 6.008ns 0.25651mA
+ 6.01ns 0.255413mA
+ 6.012ns 0.254321mA
+ 6.014ns 0.253234mA
+ 6.016ns 0.252152mA
+ 6.018ns 0.251074mA
+ 6.02ns 0.250001mA
+ 6.022ns 0.248932mA
+ 6.024ns 0.247868mA
+ 6.026ns 0.246808mA
+ 6.028ns 0.245754mA
+ 6.03ns 0.244703mA
+ 6.032ns 0.243657mA
+ 6.034ns 0.242616mA
+ 6.036ns 0.241579mA
+ 6.038ns 0.240546mA
+ 6.04ns 0.239518mA
+ 6.042ns 0.238494mA
+ 6.044ns 0.237474mA
+ 6.046ns 0.236459mA
+ 6.048ns 0.235448mA
+ 6.05ns 0.234442mA
+ 6.052ns 0.23344mA
+ 6.054ns 0.232442mA
+ 6.056ns 0mA
I21 31 0 PWL 0 0
+ 7.636ns 0mA
+ 7.638ns 0.00323499mA
+ 7.64ns 0.0076844mA
+ 7.642ns 0.0121349mA
+ 7.644ns 0.0165843mA
+ 7.646ns 0.0210337mA
+ 7.648ns 0.0254841mA
+ 7.65ns 0.0299336mA
+ 7.652ns 0.034383mA
+ 7.654ns 0.0388334mA
+ 7.656ns 0.0432828mA
+ 7.658ns 0.0477322mA
+ 7.66ns 0.0521816mA
+ 7.662ns 0.0566321mA
+ 7.664ns 0.0610815mA
+ 7.666ns 0.0655309mA
+ 7.668ns 0.0699814mA
+ 7.67ns 0.0744308mA
+ 7.672ns 0.0788802mA
+ 7.674ns 0.0833307mA
+ 7.676ns 0.0877801mA
+ 7.678ns 0.0922295mA
+ 7.68ns 0.09668mA
+ 7.682ns 0.101129mA
+ 7.684ns 0.105579mA
+ 7.686ns 0.110028mA
+ 7.688ns 0.109311mA
+ 7.69ns 0.105902mA
+ 7.692ns 0.1026mA
+ 7.694ns 0.0994001mA
+ 7.696ns 0.0963006mA
+ 7.698ns 0.0932978mA
+ 7.7ns 0.0903879mA
+ 7.702ns 0.0875693mA
+ 7.704ns 0.0848387mA
+ 7.706ns 0.0821931mA
+ 7.708ns 0.0796295mA
+ 7.71ns 0.0771463mA
+ 7.712ns 0.0747406mA
+ 7.714ns 0.0724094mA
+ 7.716ns 0.0701513mA
+ 7.718ns 0.0679637mA
+ 7.72ns 0.0658438mA
+ 7.722ns 0.0637904mA
+ 7.724ns 0.0618011mA
+ 7.726ns 0.0598734mA
+ 7.728ns 0.0580062mA
+ 7.73ns 0.0561972mA
+ 7.732ns 0.0544446mA
+ 7.734ns 0.0527463mA
+ 7.736ns 0.0511013mA
+ 7.738ns 0.0495076mA
+ 7.74ns 0.0479633mA
+ 7.742ns 0.0464674mA
+ 7.744ns 0.0450182mA
+ 7.746ns 0.0436139mA
+ 7.748ns 0.0422536mA
+ 7.75ns 0.0409358mA
+ 7.752ns 0.0396591mA
+ 7.754ns 0.0384219mA
+ 7.756ns 0mA
I22 32 0 PWL 0 0
+ 5.144ns 0mA
+ 5.146ns 0.00197935mA
+ 5.148ns 0.00624281mA
+ 5.15ns 0.0105053mA
+ 5.152ns 0.0147677mA
+ 5.154ns 0.0190312mA
+ 5.156ns 0.0232936mA
+ 5.158ns 0.0275561mA
+ 5.16ns 0.0318185mA
+ 5.162ns 0.036082mA
+ 5.164ns 0.0403444mA
+ 5.166ns 0.0446069mA
+ 5.168ns 0.0488704mA
+ 5.17ns 0.0531328mA
+ 5.172ns 0.0573953mA
+ 5.174ns 0.0616587mA
+ 5.176ns 0.0659212mA
+ 5.178ns 0.0701836mA
+ 5.18ns 0.0744461mA
+ 5.182ns 0.0787095mA
+ 5.184ns 0.082972mA
+ 5.186ns 0.0872344mA
+ 5.188ns 0.0914979mA
+ 5.19ns 0.0957603mA
+ 5.192ns 0.100023mA
+ 5.194ns 0.104286mA
+ 5.196ns 0.108549mA
+ 5.198ns 0.112811mA
+ 5.2ns 0.117075mA
+ 5.202ns 0.121337mA
+ 5.204ns 0.1256mA
+ 5.206ns 0.129862mA
+ 5.208ns 0.134125mA
+ 5.21ns 0.133058mA
+ 5.212ns 0.130266mA
+ 5.214ns 0.127533mA
+ 5.216ns 0.124857mA
+ 5.218ns 0.122238mA
+ 5.22ns 0.119673mA
+ 5.222ns 0.117162mA
+ 5.224ns 0.114705mA
+ 5.226ns 0.112298mA
+ 5.228ns 0.109942mA
+ 5.23ns 0.107635mA
+ 5.232ns 0.105377mA
+ 5.234ns 0.103166mA
+ 5.236ns 0.101001mA
+ 5.238ns 0.0988825mA
+ 5.24ns 0.0968075mA
+ 5.242ns 0.0947764mA
+ 5.244ns 0.092788mA
+ 5.246ns 0.0908409mA
+ 5.248ns 0.088935mA
+ 5.25ns 0.0870691mA
+ 5.252ns 0.0852424mA
+ 5.254ns 0.0834536mA
+ 5.256ns 0.0817026mA
+ 5.258ns 0.0799885mA
+ 5.26ns 0.0783098mA
+ 5.262ns 0.0766668mA
+ 5.264ns 0.0750583mA
+ 5.266ns 0.0734831mA
+ 5.268ns 0.0719413mA
+ 5.27ns 0.0704319mA
+ 5.272ns 0.0689542mA
+ 5.274ns 0.067507mA
+ 5.276ns 0.0660906mA
+ 5.278ns 0.0647039mA
+ 5.28ns 0.063346mA
+ 5.282ns 0.0620169mA
+ 5.284ns 0.0607156mA
+ 5.286ns 0.0594414mA
+ 5.288ns 0.0581942mA
+ 5.29ns 0.0569731mA
+ 5.292ns 0.0557774mA
+ 5.294ns 0.054607mA
+ 5.296ns 0.0534612mA
+ 5.298ns 0.0523395mA
+ 5.3ns 0.051241mA
+ 5.302ns 0.0501658mA
+ 5.304ns 0.0491131mA
+ 5.306ns 0mA
I23 33 0 PWL 0 0
+ 5.51ns 0mA
+ 5.512ns 0.00596968mA
+ 5.514ns 0.0135374mA
+ 5.516ns 0.0211069mA
+ 5.518ns 0.0286746mA
+ 5.52ns 0.0362424mA
+ 5.522ns 0.0438101mA
+ 5.524ns 0.0513796mA
+ 5.526ns 0.0589473mA
+ 5.528ns 0.0665151mA
+ 5.53ns 0.0740846mA
+ 5.532ns 0.0816523mA
+ 5.534ns 0.08922mA
+ 5.536ns 0.0967895mA
+ 5.538ns 0.104357mA
+ 5.54ns 0.111925mA
+ 5.542ns 0.119495mA
+ 5.544ns 0.127062mA
+ 5.546ns 0.13463mA
+ 5.548ns 0.142198mA
+ 5.55ns 0.149767mA
+ 5.552ns 0.157335mA
+ 5.554ns 0.164903mA
+ 5.556ns 0.172472mA
+ 5.558ns 0.18004mA
+ 5.56ns 0.187608mA
+ 5.562ns 0.195177mA
+ 5.564ns 0.202745mA
+ 5.566ns 0.210313mA
+ 5.568ns 0.21788mA
+ 5.57ns 0.22545mA
+ 5.572ns 0.233018mA
+ 5.574ns 0.240585mA
+ 5.576ns 0.248155mA
+ 5.578ns 0.255722mA
+ 5.58ns 0.26329mA
+ 5.582ns 0.27086mA
+ 5.584ns 0.278427mA
+ 5.586ns 0.285995mA
+ 5.588ns 0.293565mA
+ 5.59ns 0.301132mA
+ 5.592ns 0.3087mA
+ 5.594ns 0.316268mA
+ 5.596ns 0.323837mA
+ 5.598ns 0.331405mA
+ 5.6ns 0.338973mA
+ 5.602ns 0.346542mA
+ 5.604ns 0.35411mA
+ 5.606ns 0.361678mA
+ 5.608ns 0.369247mA
+ 5.61ns 0.376815mA
+ 5.612ns 0.384383mA
+ 5.614ns 0.39195mA
+ 5.616ns 0.39952mA
+ 5.618ns 0.407088mA
+ 5.62ns 0.414655mA
+ 5.622ns 0.422225mA
+ 5.624ns 0.429793mA
+ 5.626ns 0.43736mA
+ 5.628ns 0.44493mA
+ 5.63ns 0.452498mA
+ 5.632ns 0.460065mA
+ 5.634ns 0.467635mA
+ 5.636ns 0.475203mA
+ 5.638ns 0.48277mA
+ 5.64ns 0.490338mA
+ 5.642ns 0.497908mA
+ 5.644ns 0.505475mA
+ 5.646ns 0.513043mA
+ 5.648ns 0.520613mA
+ 5.65ns 0.52818mA
+ 5.652ns 0.535748mA
+ 5.654ns 0.543317mA
+ 5.656ns 0.542944mA
+ 5.658ns 0.540596mA
+ 5.66ns 0.538259mA
+ 5.662ns 0.535931mA
+ 5.664ns 0.533614mA
+ 5.666ns 0.531307mA
+ 5.668ns 0.529009mA
+ 5.67ns 0.526721mA
+ 5.672ns 0.524444mA
+ 5.674ns 0.522176mA
+ 5.676ns 0.519918mA
+ 5.678ns 0.51767mA
+ 5.68ns 0.515431mA
+ 5.682ns 0.513203mA
+ 5.684ns 0.510984mA
+ 5.686ns 0.508774mA
+ 5.688ns 0.506574mA
+ 5.69ns 0.504384mA
+ 5.692ns 0.502203mA
+ 5.694ns 0.500031mA
+ 5.696ns 0.497869mA
+ 5.698ns 0.495716mA
+ 5.7ns 0.493572mA
+ 5.702ns 0.491438mA
+ 5.704ns 0.489313mA
+ 5.706ns 0.487197mA
+ 5.708ns 0.48509mA
+ 5.71ns 0.482993mA
+ 5.712ns 0.480904mA
+ 5.714ns 0.478825mA
+ 5.716ns 0.476754mA
+ 5.718ns 0.474693mA
+ 5.72ns 0.47264mA
+ 5.722ns 0.470596mA
+ 5.724ns 0.468561mA
+ 5.726ns 0.466535mA
+ 5.728ns 0.464518mA
+ 5.73ns 0.462509mA
+ 5.732ns 0.460509mA
+ 5.734ns 0.458518mA
+ 5.736ns 0.456535mA
+ 5.738ns 0.454561mA
+ 5.74ns 0.452595mA
+ 5.742ns 0.450638mA
+ 5.744ns 0.448689mA
+ 5.746ns 0.446749mA
+ 5.748ns 0.444817mA
+ 5.75ns 0.442894mA
+ 5.752ns 0.440979mA
+ 5.754ns 0.439072mA
+ 5.756ns 0.437173mA
+ 5.758ns 0.435283mA
+ 5.76ns 0.4334mA
+ 5.762ns 0.431526mA
+ 5.764ns 0.42966mA
+ 5.766ns 0.427802mA
+ 5.768ns 0.425952mA
+ 5.77ns 0.42411mA
+ 5.772ns 0.422276mA
+ 5.774ns 0.42045mA
+ 5.776ns 0.418632mA
+ 5.778ns 0.416822mA
+ 5.78ns 0.415019mA
+ 5.782ns 0.413225mA
+ 5.784ns 0.411438mA
+ 5.786ns 0.409658mA
+ 5.788ns 0.407887mA
+ 5.79ns 0.406123mA
+ 5.792ns 0.404367mA
+ 5.794ns 0.402618mA
+ 5.796ns 0.400877mA
+ 5.798ns 0.399144mA
+ 5.8ns 0.397417mA
+ 5.802ns 0.395699mA
+ 5.804ns 0.393988mA
+ 5.806ns 0.392284mA
+ 5.808ns 0.390588mA
+ 5.81ns 0.388899mA
+ 5.812ns 0.387217mA
+ 5.814ns 0.385542mA
+ 5.816ns 0.383875mA
+ 5.818ns 0.382215mA
+ 5.82ns 0.380562mA
+ 5.822ns 0.378917mA
+ 5.824ns 0.377278mA
+ 5.826ns 0.375646mA
+ 5.828ns 0.374022mA
+ 5.83ns 0.372405mA
+ 5.832ns 0.370794mA
+ 5.834ns 0.369191mA
+ 5.836ns 0.367594mA
+ 5.838ns 0.366004mA
+ 5.84ns 0.364422mA
+ 5.842ns 0.362846mA
+ 5.844ns 0.361277mA
+ 5.846ns 0.359714mA
+ 5.848ns 0.358159mA
+ 5.85ns 0.35661mA
+ 5.852ns 0.355067mA
+ 5.854ns 0.353532mA
+ 5.856ns 0.352003mA
+ 5.858ns 0.350481mA
+ 5.86ns 0.348965mA
+ 5.862ns 0.347456mA
+ 5.864ns 0.345954mA
+ 5.866ns 0.344458mA
+ 5.868ns 0.342968mA
+ 5.87ns 0.341485mA
+ 5.872ns 0.340008mA
+ 5.874ns 0.338538mA
+ 5.876ns 0.337074mA
+ 5.878ns 0.335616mA
+ 5.88ns 0.334165mA
+ 5.882ns 0.33272mA
+ 5.884ns 0.33128mA
+ 5.886ns 0.329848mA
+ 5.888ns 0.328422mA
+ 5.89ns 0.327001mA
+ 5.892ns 0.325587mA
+ 5.894ns 0.324179mA
+ 5.896ns 0.322777mA
+ 5.898ns 0.321381mA
+ 5.9ns 0.319991mA
+ 5.902ns 0.318608mA
+ 5.904ns 0.31723mA
+ 5.906ns 0.315858mA
+ 5.908ns 0.314492mA
+ 5.91ns 0.313132mA
+ 5.912ns 0.311778mA
+ 5.914ns 0.310429mA
+ 5.916ns 0.309087mA
+ 5.918ns 0.30775mA
+ 5.92ns 0.306419mA
+ 5.922ns 0.305094mA
+ 5.924ns 0.303774mA
+ 5.926ns 0.302461mA
+ 5.928ns 0.301153mA
+ 5.93ns 0.29985mA
+ 5.932ns 0.298554mA
+ 5.934ns 0.297263mA
+ 5.936ns 0.295977mA
+ 5.938ns 0.294697mA
+ 5.94ns 0.293422mA
+ 5.942ns 0.292154mA
+ 5.944ns 0.29089mA
+ 5.946ns 0.289632mA
+ 5.948ns 0.288379mA
+ 5.95ns 0.287132mA
+ 5.952ns 0.28589mA
+ 5.954ns 0.284654mA
+ 5.956ns 0.283423mA
+ 5.958ns 0.282197mA
+ 5.96ns 0.280977mA
+ 5.962ns 0.279762mA
+ 5.964ns 0.278552mA
+ 5.966ns 0.277347mA
+ 5.968ns 0.276148mA
+ 5.97ns 0.274953mA
+ 5.972ns 0.273764mA
+ 5.974ns 0.27258mA
+ 5.976ns 0.271401mA
+ 5.978ns 0.270228mA
+ 5.98ns 0.269059mA
+ 5.982ns 0.267896mA
+ 5.984ns 0.266737mA
+ 5.986ns 0.265583mA
+ 5.988ns 0.264435mA
+ 5.99ns 0.263291mA
+ 5.992ns 0.262152mA
+ 5.994ns 0.261019mA
+ 5.996ns 0.25989mA
+ 5.998ns 0.258766mA
+ 6ns 0.257647mA
+ 6.002ns 0.256532mA
+ 6.004ns 0.255423mA
+ 6.006ns 0.254318mA
+ 6.008ns 0.253218mA
+ 6.01ns 0.252123mA
+ 6.012ns 0.251033mA
+ 6.014ns 0.249947mA
+ 6.016ns 0.248866mA
+ 6.018ns 0.24779mA
+ 6.02ns 0.246718mA
+ 6.022ns 0.245651mA
+ 6.024ns 0.244589mA
+ 6.026ns 0.243531mA
+ 6.028ns 0.242478mA
+ 6.03ns 0.241429mA
+ 6.032ns 0.240385mA
+ 6.034ns 0.239345mA
+ 6.036ns 0.23831mA
+ 6.038ns 0.237279mA
+ 6.04ns 0.236253mA
+ 6.042ns 0.235231mA
+ 6.044ns 0.234214mA
+ 6.046ns 0.233201mA
+ 6.048ns 0mA
I24 34 0 PWL 0 0
+ 0.16ns 0mA
+ 0.162ns 0.00278506mA
+ 0.164ns 0.00738694mA
+ 0.166ns 0.0119888mA
+ 0.168ns 0.0165907mA
+ 0.17ns 0.0211925mA
+ 0.172ns 0.0257944mA
+ 0.174ns 0.0303963mA
+ 0.176ns 0.0349981mA
+ 0.178ns 0.0396mA
+ 0.18ns 0.0442019mA
+ 0.182ns 0.0488037mA
+ 0.184ns 0.0534056mA
+ 0.186ns 0.0580074mA
+ 0.188ns 0.0626093mA
+ 0.19ns 0.0672112mA
+ 0.192ns 0.071813mA
+ 0.194ns 0.0764149mA
+ 0.196ns 0.0810168mA
+ 0.198ns 0.0856186mA
+ 0.2ns 0.0902205mA
+ 0.202ns 0.0948224mA
+ 0.204ns 0.0994242mA
+ 0.206ns 0.104026mA
+ 0.208ns 0.108628mA
+ 0.21ns 0.11323mA
+ 0.212ns 0.117832mA
+ 0.214ns 0.122434mA
+ 0.216ns 0.127035mA
+ 0.218ns 0.131637mA
+ 0.22ns 0.136239mA
+ 0.222ns 0.140841mA
+ 0.224ns 0.145443mA
+ 0.226ns 0.144655mA
+ 0.228ns 0.142112mA
+ 0.23ns 0.139612mA
+ 0.232ns 0.137157mA
+ 0.234ns 0.134745mA
+ 0.236ns 0.132375mA
+ 0.238ns 0.130047mA
+ 0.24ns 0.12776mA
+ 0.242ns 0.125513mA
+ 0.244ns 0.123306mA
+ 0.246ns 0.121137mA
+ 0.248ns 0.119007mA
+ 0.25ns 0.116914mA
+ 0.252ns 0.114858mA
+ 0.254ns 0.112838mA
+ 0.256ns 0.110853mA
+ 0.258ns 0.108903mA
+ 0.26ns 0.106988mA
+ 0.262ns 0.105106mA
+ 0.264ns 0.103258mA
+ 0.266ns 0.101442mA
+ 0.268ns 0.0996576mA
+ 0.27ns 0.0979048mA
+ 0.272ns 0.0961829mA
+ 0.274ns 0.0944912mA
+ 0.276ns 0.0928293mA
+ 0.278ns 0.0911966mA
+ 0.28ns 0.0895926mA
+ 0.282ns 0.0880168mA
+ 0.284ns 0.0864687mA
+ 0.286ns 0.0849479mA
+ 0.288ns 0.0834537mA
+ 0.29ns 0.0819859mA
+ 0.292ns 0.0805439mA
+ 0.294ns 0.0791272mA
+ 0.296ns 0.0777354mA
+ 0.298ns 0.0763682mA
+ 0.3ns 0.0750249mA
+ 0.302ns 0.0737053mA
+ 0.304ns 0.0724089mA
+ 0.306ns 0.0711352mA
+ 0.308ns 0.069884mA
+ 0.31ns 0.0686548mA
+ 0.312ns 0.0674472mA
+ 0.314ns 0.0662608mA
+ 0.316ns 0.0650953mA
+ 0.318ns 0.0639503mA
+ 0.32ns 0.0628254mA
+ 0.322ns 0.0617204mA
+ 0.324ns 0.0606347mA
+ 0.326ns 0.0595681mA
+ 0.328ns 0.0585203mA
+ 0.33ns 0.0574909mA
+ 0.332ns 0.0564797mA
+ 0.334ns 0.0554862mA
+ 0.336ns 0mA
I25 36 0 PWL 0 0
+ 8.008ns 0mA
+ 8.01ns 0.0050499mA
+ 8.012ns 0.0126079mA
+ 8.014ns 0.0201658mA
+ 8.016ns 0.0277238mA
+ 8.018ns 0.0352817mA
+ 8.02ns 0.0428433mA
+ 8.022ns 0.0504013mA
+ 8.024ns 0.0579592mA
+ 8.026ns 0.0655172mA
+ 8.028ns 0.0730752mA
+ 8.03ns 0.0806331mA
+ 8.032ns 0.0881911mA
+ 8.034ns 0.0957526mA
+ 8.036ns 0.103311mA
+ 8.038ns 0.110869mA
+ 8.04ns 0.118427mA
+ 8.042ns 0.125984mA
+ 8.044ns 0.133542mA
+ 8.046ns 0.1411mA
+ 8.048ns 0.148662mA
+ 8.05ns 0.15622mA
+ 8.052ns 0.163778mA
+ 8.054ns 0.171336mA
+ 8.056ns 0.178894mA
+ 8.058ns 0.186452mA
+ 8.06ns 0.194013mA
+ 8.062ns 0.201571mA
+ 8.064ns 0.209129mA
+ 8.066ns 0.216687mA
+ 8.068ns 0.224245mA
+ 8.07ns 0.231803mA
+ 8.072ns 0.239361mA
+ 8.074ns 0.246923mA
+ 8.076ns 0.254481mA
+ 8.078ns 0.262039mA
+ 8.08ns 0.269597mA
+ 8.082ns 0.277155mA
+ 8.084ns 0.284712mA
+ 8.086ns 0.292274mA
+ 8.088ns 0.299832mA
+ 8.09ns 0.30739mA
+ 8.092ns 0.314948mA
+ 8.094ns 0.322506mA
+ 8.096ns 0.330064mA
+ 8.098ns 0.337622mA
+ 8.1ns 0.345183mA
+ 8.102ns 0.352741mA
+ 8.104ns 0.360299mA
+ 8.106ns 0.367857mA
+ 8.108ns 0.375415mA
+ 8.11ns 0.382973mA
+ 8.112ns 0.390535mA
+ 8.114ns 0.398093mA
+ 8.116ns 0.405651mA
+ 8.118ns 0.413209mA
+ 8.12ns 0.420767mA
+ 8.122ns 0.428325mA
+ 8.124ns 0.435883mA
+ 8.126ns 0.443444mA
+ 8.128ns 0.451002mA
+ 8.13ns 0.45856mA
+ 8.132ns 0.466118mA
+ 8.134ns 0.473676mA
+ 8.136ns 0.481234mA
+ 8.138ns 0.488792mA
+ 8.14ns 0.496353mA
+ 8.142ns 0.503911mA
+ 8.144ns 0.511469mA
+ 8.146ns 0.519027mA
+ 8.148ns 0.526585mA
+ 8.15ns 0.534143mA
+ 8.152ns 0.541705mA
+ 8.154ns 0.54331mA
+ 8.156ns 0.54096mA
+ 8.158ns 0.538621mA
+ 8.16ns 0.536292mA
+ 8.162ns 0.533973mA
+ 8.164ns 0.531664mA
+ 8.166ns 0.529363mA
+ 8.168ns 0.527074mA
+ 8.17ns 0.524795mA
+ 8.172ns 0.522526mA
+ 8.174ns 0.520266mA
+ 8.176ns 0.518016mA
+ 8.178ns 0.515775mA
+ 8.18ns 0.513545mA
+ 8.182ns 0.511324mA
+ 8.184ns 0.509113mA
+ 8.186ns 0.506911mA
+ 8.188ns 0.504719mA
+ 8.19ns 0.502536mA
+ 8.192ns 0.500362mA
+ 8.194ns 0.498198mA
+ 8.196ns 0.496044mA
+ 8.198ns 0.493899mA
+ 8.2ns 0.491763mA
+ 8.202ns 0.489637mA
+ 8.204ns 0.487518mA
+ 8.206ns 0.48541mA
+ 8.208ns 0.483311mA
+ 8.21ns 0.481221mA
+ 8.212ns 0.47914mA
+ 8.214ns 0.477068mA
+ 8.216ns 0.475005mA
+ 8.218ns 0.47295mA
+ 8.22ns 0.470904mA
+ 8.222ns 0.468868mA
+ 8.224ns 0.46684mA
+ 8.226ns 0.464821mA
+ 8.228ns 0.462811mA
+ 8.23ns 0.46081mA
+ 8.232ns 0.458816mA
+ 8.234ns 0.456832mA
+ 8.236ns 0.454856mA
+ 8.238ns 0.452889mA
+ 8.24ns 0.450931mA
+ 8.242ns 0.448981mA
+ 8.244ns 0.447038mA
+ 8.246ns 0.445105mA
+ 8.248ns 0.44318mA
+ 8.25ns 0.441264mA
+ 8.252ns 0.439355mA
+ 8.254ns 0.437455mA
+ 8.256ns 0.435564mA
+ 8.258ns 0.433679mA
+ 8.26ns 0.431804mA
+ 8.262ns 0.429936mA
+ 8.264ns 0.428077mA
+ 8.266ns 0.426226mA
+ 8.268ns 0.424383mA
+ 8.27ns 0.422546mA
+ 8.272ns 0.420719mA
+ 8.274ns 0.4189mA
+ 8.276ns 0.417088mA
+ 8.278ns 0.415284mA
+ 8.28ns 0.413488mA
+ 8.282ns 0.4117mA
+ 8.284ns 0.409919mA
+ 8.286ns 0.408146mA
+ 8.288ns 0.406381mA
+ 8.29ns 0.404624mA
+ 8.292ns 0.402874mA
+ 8.294ns 0.401132mA
+ 8.296ns 0.399396mA
+ 8.298ns 0.397669mA
+ 8.3ns 0.395949mA
+ 8.302ns 0.394237mA
+ 8.304ns 0.392532mA
+ 8.306ns 0.390834mA
+ 8.308ns 0.389144mA
+ 8.31ns 0.38746mA
+ 8.312ns 0.385785mA
+ 8.314ns 0.384116mA
+ 8.316ns 0.382455mA
+ 8.318ns 0.380801mA
+ 8.32ns 0.379154mA
+ 8.322ns 0.377514mA
+ 8.324ns 0.375881mA
+ 8.326ns 0.374255mA
+ 8.328ns 0.372637mA
+ 8.33ns 0.371025mA
+ 8.332ns 0.369421mA
+ 8.334ns 0.367823mA
+ 8.336ns 0.366232mA
+ 8.338ns 0.364648mA
+ 8.34ns 0.363071mA
+ 8.342ns 0.361501mA
+ 8.344ns 0.359937mA
+ 8.346ns 0.358381mA
+ 8.348ns 0.356831mA
+ 8.35ns 0.355287mA
+ 8.352ns 0.35375mA
+ 8.354ns 0.35222mA
+ 8.356ns 0.350697mA
+ 8.358ns 0.34918mA
+ 8.36ns 0.34767mA
+ 8.362ns 0.346166mA
+ 8.364ns 0.344669mA
+ 8.366ns 0.343178mA
+ 8.368ns 0.341694mA
+ 8.37ns 0.340216mA
+ 8.372ns 0.338745mA
+ 8.374ns 0.33728mA
+ 8.376ns 0.33582mA
+ 8.378ns 0.334368mA
+ 8.38ns 0.332922mA
+ 8.382ns 0.331482mA
+ 8.384ns 0.330049mA
+ 8.386ns 0.328621mA
+ 8.388ns 0.327199mA
+ 8.39ns 0.325784mA
+ 8.392ns 0.324375mA
+ 8.394ns 0.322972mA
+ 8.396ns 0.321576mA
+ 8.398ns 0.320185mA
+ 8.4ns 0.3188mA
+ 8.402ns 0.317421mA
+ 8.404ns 0.316048mA
+ 8.406ns 0.314681mA
+ 8.408ns 0.31332mA
+ 8.41ns 0.311965mA
+ 8.412ns 0.310616mA
+ 8.414ns 0.309272mA
+ 8.416ns 0.307934mA
+ 8.418ns 0.306602mA
+ 8.42ns 0.305276mA
+ 8.422ns 0.303956mA
+ 8.424ns 0.302641mA
+ 8.426ns 0.301332mA
+ 8.428ns 0.300029mA
+ 8.43ns 0.298731mA
+ 8.432ns 0.297439mA
+ 8.434ns 0.296153mA
+ 8.436ns 0.294872mA
+ 8.438ns 0.293596mA
+ 8.44ns 0.292327mA
+ 8.442ns 0.291062mA
+ 8.444ns 0.289803mA
+ 8.446ns 0.28855mA
+ 8.448ns 0.287302mA
+ 8.45ns 0.286059mA
+ 8.452ns 0.284822mA
+ 8.454ns 0.283589mA
+ 8.456ns 0.282363mA
+ 8.458ns 0.281142mA
+ 8.46ns 0.279926mA
+ 8.462ns 0.278715mA
+ 8.464ns 0.27751mA
+ 8.466ns 0.276309mA
+ 8.468ns 0.275114mA
+ 8.47ns 0.273924mA
+ 8.472ns 0.272739mA
+ 8.474ns 0.271559mA
+ 8.476ns 0.270385mA
+ 8.478ns 0.269216mA
+ 8.48ns 0.268051mA
+ 8.482ns 0.266891mA
+ 8.484ns 0.265737mA
+ 8.486ns 0.264588mA
+ 8.488ns 0.263443mA
+ 8.49ns 0.262304mA
+ 8.492ns 0.261169mA
+ 8.494ns 0.260039mA
+ 8.496ns 0.258915mA
+ 8.498ns 0.257795mA
+ 8.5ns 0.25668mA
+ 8.502ns 0.25557mA
+ 8.504ns 0.254464mA
+ 8.506ns 0.253364mA
+ 8.508ns 0.252267mA
+ 8.51ns 0.251176mA
+ 8.512ns 0.25009mA
+ 8.514ns 0.249008mA
+ 8.516ns 0.247931mA
+ 8.518ns 0.246859mA
+ 8.52ns 0.245791mA
+ 8.522ns 0.244728mA
+ 8.524ns 0.243669mA
+ 8.526ns 0.242615mA
+ 8.528ns 0.241566mA
+ 8.53ns 0.240521mA
+ 8.532ns 0.239481mA
+ 8.534ns 0.238444mA
+ 8.536ns 0.237413mA
+ 8.538ns 0.236386mA
+ 8.54ns 0.235364mA
+ 8.542ns 0.234346mA
+ 8.544ns 0.233332mA
+ 8.546ns 0mA
I26 37 0 PWL 0 0
+ 8.018ns 0mA
+ 8.02ns 0.00159731mA
+ 8.022ns 0.00911599mA
+ 8.024ns 0.0166347mA
+ 8.026ns 0.0241533mA
+ 8.028ns 0.031672mA
+ 8.03ns 0.0391907mA
+ 8.032ns 0.0467093mA
+ 8.034ns 0.0542316mA
+ 8.036ns 0.0617503mA
+ 8.038ns 0.0692689mA
+ 8.04ns 0.0767876mA
+ 8.042ns 0.0843063mA
+ 8.044ns 0.091825mA
+ 8.046ns 0.0993436mA
+ 8.048ns 0.106866mA
+ 8.05ns 0.114385mA
+ 8.052ns 0.121903mA
+ 8.054ns 0.129422mA
+ 8.056ns 0.136941mA
+ 8.058ns 0.144459mA
+ 8.06ns 0.151982mA
+ 8.062ns 0.1595mA
+ 8.064ns 0.167019mA
+ 8.066ns 0.174538mA
+ 8.068ns 0.182056mA
+ 8.07ns 0.189575mA
+ 8.072ns 0.197094mA
+ 8.074ns 0.204616mA
+ 8.076ns 0.212134mA
+ 8.078ns 0.219653mA
+ 8.08ns 0.227172mA
+ 8.082ns 0.23469mA
+ 8.084ns 0.242209mA
+ 8.086ns 0.249731mA
+ 8.088ns 0.25725mA
+ 8.09ns 0.264769mA
+ 8.092ns 0.272287mA
+ 8.094ns 0.279806mA
+ 8.096ns 0.287325mA
+ 8.098ns 0.294843mA
+ 8.1ns 0.302366mA
+ 8.102ns 0.309884mA
+ 8.104ns 0.317403mA
+ 8.106ns 0.324922mA
+ 8.108ns 0.33244mA
+ 8.11ns 0.339959mA
+ 8.112ns 0.347481mA
+ 8.114ns 0.355mA
+ 8.116ns 0.362519mA
+ 8.118ns 0.370037mA
+ 8.12ns 0.377556mA
+ 8.122ns 0.385075mA
+ 8.124ns 0.392593mA
+ 8.126ns 0.400116mA
+ 8.128ns 0.407634mA
+ 8.13ns 0.415153mA
+ 8.132ns 0.422672mA
+ 8.134ns 0.43019mA
+ 8.136ns 0.437709mA
+ 8.138ns 0.445228mA
+ 8.14ns 0.45275mA
+ 8.142ns 0.460269mA
+ 8.144ns 0.467787mA
+ 8.146ns 0.475306mA
+ 8.148ns 0.482825mA
+ 8.15ns 0.490343mA
+ 8.152ns 0.497866mA
+ 8.154ns 0.505384mA
+ 8.156ns 0.512903mA
+ 8.158ns 0.520422mA
+ 8.16ns 0.52794mA
+ 8.162ns 0.535459mA
+ 8.164ns 0.542978mA
+ 8.166ns 0.541617mA
+ 8.168ns 0.53928mA
+ 8.17ns 0.536952mA
+ 8.172ns 0.534635mA
+ 8.174ns 0.532327mA
+ 8.176ns 0.530029mA
+ 8.178ns 0.527741mA
+ 8.18ns 0.525463mA
+ 8.182ns 0.523195mA
+ 8.184ns 0.520937mA
+ 8.186ns 0.518689mA
+ 8.188ns 0.51645mA
+ 8.19ns 0.514221mA
+ 8.192ns 0.512mA
+ 8.194ns 0.50979mA
+ 8.196ns 0.50759mA
+ 8.198ns 0.505399mA
+ 8.2ns 0.503218mA
+ 8.202ns 0.501046mA
+ 8.204ns 0.498883mA
+ 8.206ns 0.496729mA
+ 8.208ns 0.494585mA
+ 8.21ns 0.492451mA
+ 8.212ns 0.490325mA
+ 8.214ns 0.488209mA
+ 8.216ns 0.486102mA
+ 8.218ns 0.484003mA
+ 8.22ns 0.481914mA
+ 8.222ns 0.479834mA
+ 8.224ns 0.477763mA
+ 8.226ns 0.4757mA
+ 8.228ns 0.473647mA
+ 8.23ns 0.471603mA
+ 8.232ns 0.469566mA
+ 8.234ns 0.46754mA
+ 8.236ns 0.465522mA
+ 8.238ns 0.463512mA
+ 8.24ns 0.461512mA
+ 8.242ns 0.45952mA
+ 8.244ns 0.457536mA
+ 8.246ns 0.455561mA
+ 8.248ns 0.453594mA
+ 8.25ns 0.451637mA
+ 8.252ns 0.449687mA
+ 8.254ns 0.447746mA
+ 8.256ns 0.445814mA
+ 8.258ns 0.443889mA
+ 8.26ns 0.441973mA
+ 8.262ns 0.440065mA
+ 8.264ns 0.438166mA
+ 8.266ns 0.436274mA
+ 8.268ns 0.434391mA
+ 8.27ns 0.432515mA
+ 8.272ns 0.430649mA
+ 8.274ns 0.42879mA
+ 8.276ns 0.426939mA
+ 8.278ns 0.425096mA
+ 8.28ns 0.423261mA
+ 8.282ns 0.421435mA
+ 8.284ns 0.419615mA
+ 8.286ns 0.417803mA
+ 8.288ns 0.416mA
+ 8.29ns 0.414205mA
+ 8.292ns 0.412417mA
+ 8.294ns 0.410637mA
+ 8.296ns 0.408863mA
+ 8.298ns 0.407099mA
+ 8.3ns 0.405341mA
+ 8.302ns 0.403592mA
+ 8.304ns 0.40185mA
+ 8.306ns 0.400115mA
+ 8.308ns 0.398388mA
+ 8.31ns 0.396668mA
+ 8.312ns 0.394956mA
+ 8.314ns 0.393251mA
+ 8.316ns 0.391553mA
+ 8.318ns 0.389863mA
+ 8.32ns 0.388181mA
+ 8.322ns 0.386505mA
+ 8.324ns 0.384836mA
+ 8.326ns 0.383175mA
+ 8.328ns 0.381521mA
+ 8.33ns 0.379874mA
+ 8.332ns 0.378234mA
+ 8.334ns 0.376602mA
+ 8.336ns 0.374975mA
+ 8.338ns 0.373357mA
+ 8.34ns 0.371745mA
+ 8.342ns 0.370141mA
+ 8.344ns 0.368543mA
+ 8.346ns 0.366952mA
+ 8.348ns 0.365368mA
+ 8.35ns 0.363791mA
+ 8.352ns 0.36222mA
+ 8.354ns 0.360657mA
+ 8.356ns 0.3591mA
+ 8.358ns 0.35755mA
+ 8.36ns 0.356007mA
+ 8.362ns 0.354469mA
+ 8.364ns 0.352939mA
+ 8.366ns 0.351416mA
+ 8.368ns 0.349899mA
+ 8.37ns 0.348388mA
+ 8.372ns 0.346885mA
+ 8.374ns 0.345387mA
+ 8.376ns 0.343896mA
+ 8.378ns 0.342411mA
+ 8.38ns 0.340933mA
+ 8.382ns 0.339462mA
+ 8.384ns 0.337996mA
+ 8.386ns 0.336537mA
+ 8.388ns 0.335084mA
+ 8.39ns 0.333638mA
+ 8.392ns 0.332197mA
+ 8.394ns 0.330764mA
+ 8.396ns 0.329336mA
+ 8.398ns 0.327914mA
+ 8.4ns 0.326499mA
+ 8.402ns 0.325089mA
+ 8.404ns 0.323685mA
+ 8.406ns 0.322288mA
+ 8.408ns 0.320897mA
+ 8.41ns 0.319512mA
+ 8.412ns 0.318133mA
+ 8.414ns 0.316759mA
+ 8.416ns 0.315392mA
+ 8.418ns 0.31403mA
+ 8.42ns 0.312675mA
+ 8.422ns 0.311325mA
+ 8.424ns 0.309981mA
+ 8.426ns 0.308643mA
+ 8.428ns 0.30731mA
+ 8.43ns 0.305983mA
+ 8.432ns 0.304663mA
+ 8.434ns 0.303348mA
+ 8.436ns 0.302038mA
+ 8.438ns 0.300734mA
+ 8.44ns 0.299436mA
+ 8.442ns 0.298143mA
+ 8.444ns 0.296856mA
+ 8.446ns 0.295575mA
+ 8.448ns 0.294299mA
+ 8.45ns 0.293028mA
+ 8.452ns 0.291763mA
+ 8.454ns 0.290503mA
+ 8.456ns 0.289249mA
+ 8.458ns 0.288001mA
+ 8.46ns 0.286758mA
+ 8.462ns 0.28552mA
+ 8.464ns 0.284287mA
+ 8.466ns 0.28306mA
+ 8.468ns 0.281838mA
+ 8.47ns 0.280621mA
+ 8.472ns 0.27941mA
+ 8.474ns 0.278203mA
+ 8.476ns 0.277002mA
+ 8.478ns 0.275807mA
+ 8.48ns 0.274616mA
+ 8.482ns 0.27343mA
+ 8.484ns 0.27225mA
+ 8.486ns 0.271075mA
+ 8.488ns 0.269904mA
+ 8.49ns 0.268739mA
+ 8.492ns 0.267579mA
+ 8.494ns 0.266424mA
+ 8.496ns 0.265274mA
+ 8.498ns 0.264128mA
+ 8.5ns 0.262988mA
+ 8.502ns 0.261853mA
+ 8.504ns 0.260723mA
+ 8.506ns 0.259597mA
+ 8.508ns 0.258476mA
+ 8.51ns 0.25736mA
+ 8.512ns 0.256249mA
+ 8.514ns 0.255143mA
+ 8.516ns 0.254042mA
+ 8.518ns 0.252945mA
+ 8.52ns 0.251853mA
+ 8.522ns 0.250765mA
+ 8.524ns 0.249683mA
+ 8.526ns 0.248605mA
+ 8.528ns 0.247532mA
+ 8.53ns 0.246463mA
+ 8.532ns 0.245399mA
+ 8.534ns 0.244339mA
+ 8.536ns 0.243285mA
+ 8.538ns 0.242234mA
+ 8.54ns 0.241189mA
+ 8.542ns 0.240148mA
+ 8.544ns 0.239111mA
+ 8.546ns 0.238078mA
+ 8.548ns 0.23705mA
+ 8.55ns 0.236027mA
+ 8.552ns 0.235008mA
+ 8.554ns 0.233994mA
+ 8.556ns 0.232984mA
+ 8.558ns 0mA
I27 38 0 PWL 0 0
+ 3.016ns 0mA
+ 3.018ns 0.00159406mA
+ 3.02ns 0.00935546mA
+ 3.022ns 0.0171178mA
+ 3.024ns 0.0248801mA
+ 3.026ns 0.0326415mA
+ 3.028ns 0.0404038mA
+ 3.03ns 0.0481652mA
+ 3.032ns 0.0559276mA
+ 3.034ns 0.0636899mA
+ 3.036ns 0.0714513mA
+ 3.038ns 0.0792136mA
+ 3.04ns 0.086975mA
+ 3.042ns 0.0947374mA
+ 3.044ns 0.1025mA
+ 3.046ns 0.110261mA
+ 3.048ns 0.118023mA
+ 3.05ns 0.125785mA
+ 3.052ns 0.133547mA
+ 3.054ns 0.141309mA
+ 3.056ns 0.149071mA
+ 3.058ns 0.156833mA
+ 3.06ns 0.164595mA
+ 3.062ns 0.172357mA
+ 3.064ns 0.180119mA
+ 3.066ns 0.187881mA
+ 3.068ns 0.195643mA
+ 3.07ns 0.203404mA
+ 3.072ns 0.211167mA
+ 3.074ns 0.218929mA
+ 3.076ns 0.22669mA
+ 3.078ns 0.234453mA
+ 3.08ns 0.242215mA
+ 3.082ns 0.249976mA
+ 3.084ns 0.257739mA
+ 3.086ns 0.2655mA
+ 3.088ns 0.273263mA
+ 3.09ns 0.281025mA
+ 3.092ns 0.288786mA
+ 3.094ns 0.296549mA
+ 3.096ns 0.30431mA
+ 3.098ns 0.312072mA
+ 3.1ns 0.319835mA
+ 3.102ns 0.327596mA
+ 3.104ns 0.335358mA
+ 3.106ns 0.34312mA
+ 3.108ns 0.350882mA
+ 3.11ns 0.358644mA
+ 3.112ns 0.366406mA
+ 3.114ns 0.374168mA
+ 3.116ns 0.38193mA
+ 3.118ns 0.389692mA
+ 3.12ns 0.397454mA
+ 3.122ns 0.405216mA
+ 3.124ns 0.412978mA
+ 3.126ns 0.42074mA
+ 3.128ns 0.428502mA
+ 3.13ns 0.436264mA
+ 3.132ns 0.444025mA
+ 3.134ns 0.451788mA
+ 3.136ns 0.45955mA
+ 3.138ns 0.467311mA
+ 3.14ns 0.475074mA
+ 3.142ns 0.482835mA
+ 3.144ns 0.490598mA
+ 3.146ns 0.49836mA
+ 3.148ns 0.506121mA
+ 3.15ns 0.513884mA
+ 3.152ns 0.521645mA
+ 3.154ns 0.529407mA
+ 3.156ns 0.53717mA
+ 3.158ns 0.544931mA
+ 3.16ns 0.549138mA
+ 3.162ns 0.546753mA
+ 3.164ns 0.544378mA
+ 3.166ns 0.542013mA
+ 3.168ns 0.539659mA
+ 3.17ns 0.537315mA
+ 3.172ns 0.534981mA
+ 3.174ns 0.532657mA
+ 3.176ns 0.530344mA
+ 3.178ns 0.52804mA
+ 3.18ns 0.525746mA
+ 3.182ns 0.523463mA
+ 3.184ns 0.521189mA
+ 3.186ns 0.518925mA
+ 3.188ns 0.516671mA
+ 3.19ns 0.514427mA
+ 3.192ns 0.512192mA
+ 3.194ns 0.509967mA
+ 3.196ns 0.507752mA
+ 3.198ns 0.505547mA
+ 3.2ns 0.503351mA
+ 3.202ns 0.501164mA
+ 3.204ns 0.498987mA
+ 3.206ns 0.49682mA
+ 3.208ns 0.494662mA
+ 3.21ns 0.492513mA
+ 3.212ns 0.490374mA
+ 3.214ns 0.488244mA
+ 3.216ns 0.486123mA
+ 3.218ns 0.484011mA
+ 3.22ns 0.481909mA
+ 3.222ns 0.479815mA
+ 3.224ns 0.477731mA
+ 3.226ns 0.475656mA
+ 3.228ns 0.47359mA
+ 3.23ns 0.471533mA
+ 3.232ns 0.469484mA
+ 3.234ns 0.467445mA
+ 3.236ns 0.465415mA
+ 3.238ns 0.463393mA
+ 3.24ns 0.46138mA
+ 3.242ns 0.459376mA
+ 3.244ns 0.457381mA
+ 3.246ns 0.455394mA
+ 3.248ns 0.453415mA
+ 3.25ns 0.451446mA
+ 3.252ns 0.449485mA
+ 3.254ns 0.447533mA
+ 3.256ns 0.445588mA
+ 3.258ns 0.443653mA
+ 3.26ns 0.441726mA
+ 3.262ns 0.439807mA
+ 3.264ns 0.437896mA
+ 3.266ns 0.435994mA
+ 3.268ns 0.4341mA
+ 3.27ns 0.432215mA
+ 3.272ns 0.430337mA
+ 3.274ns 0.428468mA
+ 3.276ns 0.426607mA
+ 3.278ns 0.424753mA
+ 3.28ns 0.422908mA
+ 3.282ns 0.421071mA
+ 3.284ns 0.419242mA
+ 3.286ns 0.417421mA
+ 3.288ns 0.415608mA
+ 3.29ns 0.413802mA
+ 3.292ns 0.412005mA
+ 3.294ns 0.410215mA
+ 3.296ns 0.408433mA
+ 3.298ns 0.406659mA
+ 3.3ns 0.404892mA
+ 3.302ns 0.403134mA
+ 3.304ns 0.401382mA
+ 3.306ns 0.399639mA
+ 3.308ns 0.397903mA
+ 3.31ns 0.396174mA
+ 3.312ns 0.394453mA
+ 3.314ns 0.39274mA
+ 3.316ns 0.391034mA
+ 3.318ns 0.389335mA
+ 3.32ns 0.387644mA
+ 3.322ns 0.38596mA
+ 3.324ns 0.384283mA
+ 3.326ns 0.382614mA
+ 3.328ns 0.380952mA
+ 3.33ns 0.379297mA
+ 3.332ns 0.377649mA
+ 3.334ns 0.376009mA
+ 3.336ns 0.374375mA
+ 3.338ns 0.372749mA
+ 3.34ns 0.37113mA
+ 3.342ns 0.369518mA
+ 3.344ns 0.367912mA
+ 3.346ns 0.366314mA
+ 3.348ns 0.364723mA
+ 3.35ns 0.363138mA
+ 3.352ns 0.361561mA
+ 3.354ns 0.35999mA
+ 3.356ns 0.358427mA
+ 3.358ns 0.356869mA
+ 3.36ns 0.355319mA
+ 3.362ns 0.353776mA
+ 3.364ns 0.352239mA
+ 3.366ns 0.350708mA
+ 3.368ns 0.349185mA
+ 3.37ns 0.347668mA
+ 3.372ns 0.346158mA
+ 3.374ns 0.344654mA
+ 3.376ns 0.343157mA
+ 3.378ns 0.341666mA
+ 3.38ns 0.340182mA
+ 3.382ns 0.338704mA
+ 3.384ns 0.337233mA
+ 3.386ns 0.335768mA
+ 3.388ns 0.334309mA
+ 3.39ns 0.332857mA
+ 3.392ns 0.331411mA
+ 3.394ns 0.329971mA
+ 3.396ns 0.328538mA
+ 3.398ns 0.32711mA
+ 3.4ns 0.325689mA
+ 3.402ns 0.324275mA
+ 3.404ns 0.322866mA
+ 3.406ns 0.321463mA
+ 3.408ns 0.320067mA
+ 3.41ns 0.318676mA
+ 3.412ns 0.317292mA
+ 3.414ns 0.315913mA
+ 3.416ns 0.314541mA
+ 3.418ns 0.313175mA
+ 3.42ns 0.311814mA
+ 3.422ns 0.310459mA
+ 3.424ns 0.309111mA
+ 3.426ns 0.307768mA
+ 3.428ns 0.306431mA
+ 3.43ns 0.3051mA
+ 3.432ns 0.303774mA
+ 3.434ns 0.302455mA
+ 3.436ns 0.301141mA
+ 3.438ns 0.299832mA
+ 3.44ns 0.29853mA
+ 3.442ns 0.297233mA
+ 3.444ns 0.295942mA
+ 3.446ns 0.294656mA
+ 3.448ns 0.293376mA
+ 3.45ns 0.292101mA
+ 3.452ns 0.290832mA
+ 3.454ns 0.289569mA
+ 3.456ns 0.288311mA
+ 3.458ns 0.287058mA
+ 3.46ns 0.285811mA
+ 3.462ns 0.28457mA
+ 3.464ns 0.283333mA
+ 3.466ns 0.282103mA
+ 3.468ns 0.280877mA
+ 3.47ns 0.279657mA
+ 3.472ns 0.278442mA
+ 3.474ns 0.277232mA
+ 3.476ns 0.276028mA
+ 3.478ns 0.274829mA
+ 3.48ns 0.273635mA
+ 3.482ns 0.272446mA
+ 3.484ns 0.271262mA
+ 3.486ns 0.270084mA
+ 3.488ns 0.26891mA
+ 3.49ns 0.267742mA
+ 3.492ns 0.266579mA
+ 3.494ns 0.265421mA
+ 3.496ns 0.264268mA
+ 3.498ns 0.26312mA
+ 3.5ns 0.261977mA
+ 3.502ns 0.260838mA
+ 3.504ns 0.259705mA
+ 3.506ns 0.258577mA
+ 3.508ns 0.257454mA
+ 3.51ns 0.256335mA
+ 3.512ns 0.255221mA
+ 3.514ns 0.254113mA
+ 3.516ns 0.253009mA
+ 3.518ns 0.251909mA
+ 3.52ns 0.250815mA
+ 3.522ns 0.249725mA
+ 3.524ns 0.24864mA
+ 3.526ns 0.24756mA
+ 3.528ns 0.246485mA
+ 3.53ns 0.245414mA
+ 3.532ns 0.244348mA
+ 3.534ns 0.243286mA
+ 3.536ns 0.242229mA
+ 3.538ns 0.241177mA
+ 3.54ns 0.240129mA
+ 3.542ns 0.239086mA
+ 3.544ns 0.238047mA
+ 3.546ns 0.237013mA
+ 3.548ns 0.235983mA
+ 3.55ns 0mA
I28 39 0 PWL 0 0
+ 5.498ns 0mA
+ 5.5ns 0.00227949mA
+ 5.502ns 0.0100528mA
+ 5.504ns 0.0178279mA
+ 5.506ns 0.0256012mA
+ 5.508ns 0.0333745mA
+ 5.51ns 0.0411496mA
+ 5.512ns 0.0489229mA
+ 5.514ns 0.0566962mA
+ 5.516ns 0.0644713mA
+ 5.518ns 0.0722446mA
+ 5.52ns 0.0800179mA
+ 5.522ns 0.0877912mA
+ 5.524ns 0.0955663mA
+ 5.526ns 0.10334mA
+ 5.528ns 0.111113mA
+ 5.53ns 0.118888mA
+ 5.532ns 0.126661mA
+ 5.534ns 0.134435mA
+ 5.536ns 0.14221mA
+ 5.538ns 0.149983mA
+ 5.54ns 0.157756mA
+ 5.542ns 0.165531mA
+ 5.544ns 0.173305mA
+ 5.546ns 0.181078mA
+ 5.548ns 0.188851mA
+ 5.55ns 0.196626mA
+ 5.552ns 0.2044mA
+ 5.554ns 0.212173mA
+ 5.556ns 0.219948mA
+ 5.558ns 0.227721mA
+ 5.56ns 0.235495mA
+ 5.562ns 0.24327mA
+ 5.564ns 0.251043mA
+ 5.566ns 0.258816mA
+ 5.568ns 0.26659mA
+ 5.57ns 0.274365mA
+ 5.572ns 0.282138mA
+ 5.574ns 0.289911mA
+ 5.576ns 0.297687mA
+ 5.578ns 0.30546mA
+ 5.58ns 0.313233mA
+ 5.582ns 0.321008mA
+ 5.584ns 0.328782mA
+ 5.586ns 0.336555mA
+ 5.588ns 0.34433mA
+ 5.59ns 0.352103mA
+ 5.592ns 0.359877mA
+ 5.594ns 0.36765mA
+ 5.596ns 0.375425mA
+ 5.598ns 0.383198mA
+ 5.6ns 0.390972mA
+ 5.602ns 0.398747mA
+ 5.604ns 0.40652mA
+ 5.606ns 0.414293mA
+ 5.608ns 0.422068mA
+ 5.61ns 0.429842mA
+ 5.612ns 0.437615mA
+ 5.614ns 0.445388mA
+ 5.616ns 0.453163mA
+ 5.618ns 0.460937mA
+ 5.62ns 0.46871mA
+ 5.622ns 0.476485mA
+ 5.624ns 0.484258mA
+ 5.626ns 0.492032mA
+ 5.628ns 0.499807mA
+ 5.63ns 0.50758mA
+ 5.632ns 0.515353mA
+ 5.634ns 0.523129mA
+ 5.636ns 0.530902mA
+ 5.638ns 0.538675mA
+ 5.64ns 0.546448mA
+ 5.642ns 0.549644mA
+ 5.644ns 0.547253mA
+ 5.646ns 0.544872mA
+ 5.648ns 0.542501mA
+ 5.65ns 0.540141mA
+ 5.652ns 0.537791mA
+ 5.654ns 0.53545mA
+ 5.656ns 0.533121mA
+ 5.658ns 0.530801mA
+ 5.66ns 0.528492mA
+ 5.662ns 0.526192mA
+ 5.664ns 0.523903mA
+ 5.666ns 0.521623mA
+ 5.668ns 0.519353mA
+ 5.67ns 0.517094mA
+ 5.672ns 0.514844mA
+ 5.674ns 0.512604mA
+ 5.676ns 0.510373mA
+ 5.678ns 0.508153mA
+ 5.68ns 0.505941mA
+ 5.682ns 0.50374mA
+ 5.684ns 0.501549mA
+ 5.686ns 0.499366mA
+ 5.688ns 0.497193mA
+ 5.69ns 0.49503mA
+ 5.692ns 0.492876mA
+ 5.694ns 0.490731mA
+ 5.696ns 0.488596mA
+ 5.698ns 0.48647mA
+ 5.7ns 0.484353mA
+ 5.702ns 0.482246mA
+ 5.704ns 0.480148mA
+ 5.706ns 0.478059mA
+ 5.708ns 0.475978mA
+ 5.71ns 0.473908mA
+ 5.712ns 0.471846mA
+ 5.714ns 0.469792mA
+ 5.716ns 0.467748mA
+ 5.718ns 0.465713mA
+ 5.72ns 0.463686mA
+ 5.722ns 0.461669mA
+ 5.724ns 0.45966mA
+ 5.726ns 0.45766mA
+ 5.728ns 0.455669mA
+ 5.73ns 0.453686mA
+ 5.732ns 0.451712mA
+ 5.734ns 0.449746mA
+ 5.736ns 0.447789mA
+ 5.738ns 0.445841mA
+ 5.74ns 0.443901mA
+ 5.742ns 0.44197mA
+ 5.744ns 0.440047mA
+ 5.746ns 0.438131mA
+ 5.748ns 0.436225mA
+ 5.75ns 0.434327mA
+ 5.752ns 0.432437mA
+ 5.754ns 0.430556mA
+ 5.756ns 0.428682mA
+ 5.758ns 0.426817mA
+ 5.76ns 0.42496mA
+ 5.762ns 0.423111mA
+ 5.764ns 0.42127mA
+ 5.766ns 0.419436mA
+ 5.768ns 0.417611mA
+ 5.77ns 0.415794mA
+ 5.772ns 0.413985mA
+ 5.774ns 0.412183mA
+ 5.776ns 0.41039mA
+ 5.778ns 0.408604mA
+ 5.78ns 0.406826mA
+ 5.782ns 0.405056mA
+ 5.784ns 0.403294mA
+ 5.786ns 0.401538mA
+ 5.788ns 0.399791mA
+ 5.79ns 0.398052mA
+ 5.792ns 0.39632mA
+ 5.794ns 0.394595mA
+ 5.796ns 0.392878mA
+ 5.798ns 0.391169mA
+ 5.8ns 0.389466mA
+ 5.802ns 0.387772mA
+ 5.804ns 0.386085mA
+ 5.806ns 0.384404mA
+ 5.808ns 0.382732mA
+ 5.81ns 0.381066mA
+ 5.812ns 0.379408mA
+ 5.814ns 0.377757mA
+ 5.816ns 0.376114mA
+ 5.818ns 0.374477mA
+ 5.82ns 0.372847mA
+ 5.822ns 0.371225mA
+ 5.824ns 0.36961mA
+ 5.826ns 0.368001mA
+ 5.828ns 0.3664mA
+ 5.83ns 0.364806mA
+ 5.832ns 0.363218mA
+ 5.834ns 0.361638mA
+ 5.836ns 0.360064mA
+ 5.838ns 0.358497mA
+ 5.84ns 0.356937mA
+ 5.842ns 0.355384mA
+ 5.844ns 0.353838mA
+ 5.846ns 0.352298mA
+ 5.848ns 0.350765mA
+ 5.85ns 0.349239mA
+ 5.852ns 0.347719mA
+ 5.854ns 0.346206mA
+ 5.856ns 0.344699mA
+ 5.858ns 0.343199mA
+ 5.86ns 0.341706mA
+ 5.862ns 0.340219mA
+ 5.864ns 0.338738mA
+ 5.866ns 0.337264mA
+ 5.868ns 0.335797mA
+ 5.87ns 0.334336mA
+ 5.872ns 0.33288mA
+ 5.874ns 0.331432mA
+ 5.876ns 0.32999mA
+ 5.878ns 0.328554mA
+ 5.88ns 0.327124mA
+ 5.882ns 0.325701mA
+ 5.884ns 0.324283mA
+ 5.886ns 0.322872mA
+ 5.888ns 0.321467mA
+ 5.89ns 0.320068mA
+ 5.892ns 0.318675mA
+ 5.894ns 0.317289mA
+ 5.896ns 0.315908mA
+ 5.898ns 0.314533mA
+ 5.9ns 0.313165mA
+ 5.902ns 0.311802mA
+ 5.904ns 0.310445mA
+ 5.906ns 0.309094mA
+ 5.908ns 0.307749mA
+ 5.91ns 0.30641mA
+ 5.912ns 0.305076mA
+ 5.914ns 0.303749mA
+ 5.916ns 0.302427mA
+ 5.918ns 0.301111mA
+ 5.92ns 0.299801mA
+ 5.922ns 0.298496mA
+ 5.924ns 0.297197mA
+ 5.926ns 0.295904mA
+ 5.928ns 0.294616mA
+ 5.93ns 0.293334mA
+ 5.932ns 0.292057mA
+ 5.934ns 0.290787mA
+ 5.936ns 0.289521mA
+ 5.938ns 0.288261mA
+ 5.94ns 0.287007mA
+ 5.942ns 0.285758mA
+ 5.944ns 0.284514mA
+ 5.946ns 0.283276mA
+ 5.948ns 0.282043mA
+ 5.95ns 0.280816mA
+ 5.952ns 0.279594mA
+ 5.954ns 0.278377mA
+ 5.956ns 0.277166mA
+ 5.958ns 0.27596mA
+ 5.96ns 0.274759mA
+ 5.962ns 0.273563mA
+ 5.964ns 0.272373mA
+ 5.966ns 0.271187mA
+ 5.968ns 0.270007mA
+ 5.97ns 0.268832mA
+ 5.972ns 0.267662mA
+ 5.974ns 0.266498mA
+ 5.976ns 0.265338mA
+ 5.978ns 0.264183mA
+ 5.98ns 0.263033mA
+ 5.982ns 0.261889mA
+ 5.984ns 0.260749mA
+ 5.986ns 0.259614mA
+ 5.988ns 0.258485mA
+ 5.99ns 0.25736mA
+ 5.992ns 0.25624mA
+ 5.994ns 0.255125mA
+ 5.996ns 0.254014mA
+ 5.998ns 0.252909mA
+ 6ns 0.251808mA
+ 6.002ns 0.250713mA
+ 6.004ns 0.249621mA
+ 6.006ns 0.248535mA
+ 6.008ns 0.247454mA
+ 6.01ns 0.246376mA
+ 6.012ns 0.245304mA
+ 6.014ns 0.244237mA
+ 6.016ns 0.243174mA
+ 6.018ns 0.242116mA
+ 6.02ns 0.241062mA
+ 6.022ns 0.240013mA
+ 6.024ns 0.238968mA
+ 6.026ns 0.237929mA
+ 6.028ns 0.236893mA
+ 6.03ns 0mA
I29 40 0 PWL 0 0
+ 3.016ns 0mA
+ 3.018ns 0.00267894mA
+ 3.02ns 0.0104436mA
+ 3.022ns 0.0182092mA
+ 3.024ns 0.0259748mA
+ 3.026ns 0.0337394mA
+ 3.028ns 0.041505mA
+ 3.03ns 0.0492697mA
+ 3.032ns 0.0570353mA
+ 3.034ns 0.0648009mA
+ 3.036ns 0.0725655mA
+ 3.038ns 0.0803311mA
+ 3.04ns 0.0880958mA
+ 3.042ns 0.0958614mA
+ 3.044ns 0.103627mA
+ 3.046ns 0.111392mA
+ 3.048ns 0.119157mA
+ 3.05ns 0.126922mA
+ 3.052ns 0.134687mA
+ 3.054ns 0.142453mA
+ 3.056ns 0.150218mA
+ 3.058ns 0.157983mA
+ 3.06ns 0.165748mA
+ 3.062ns 0.173514mA
+ 3.064ns 0.181279mA
+ 3.066ns 0.189044mA
+ 3.068ns 0.196809mA
+ 3.07ns 0.204574mA
+ 3.072ns 0.21234mA
+ 3.074ns 0.220105mA
+ 3.076ns 0.22787mA
+ 3.078ns 0.235635mA
+ 3.08ns 0.243401mA
+ 3.082ns 0.251166mA
+ 3.084ns 0.258931mA
+ 3.086ns 0.266696mA
+ 3.088ns 0.274462mA
+ 3.09ns 0.282227mA
+ 3.092ns 0.289992mA
+ 3.094ns 0.297757mA
+ 3.096ns 0.305522mA
+ 3.098ns 0.313288mA
+ 3.1ns 0.321053mA
+ 3.102ns 0.328818mA
+ 3.104ns 0.336583mA
+ 3.106ns 0.344348mA
+ 3.108ns 0.352114mA
+ 3.11ns 0.359879mA
+ 3.112ns 0.367644mA
+ 3.114ns 0.37541mA
+ 3.116ns 0.383174mA
+ 3.118ns 0.39094mA
+ 3.12ns 0.398705mA
+ 3.122ns 0.40647mA
+ 3.124ns 0.414236mA
+ 3.126ns 0.422001mA
+ 3.128ns 0.429766mA
+ 3.13ns 0.437531mA
+ 3.132ns 0.445296mA
+ 3.134ns 0.453062mA
+ 3.136ns 0.460827mA
+ 3.138ns 0.468592mA
+ 3.14ns 0.476358mA
+ 3.142ns 0.484122mA
+ 3.144ns 0.491888mA
+ 3.146ns 0.499653mA
+ 3.148ns 0.507418mA
+ 3.15ns 0.515184mA
+ 3.152ns 0.522948mA
+ 3.154ns 0.530714mA
+ 3.156ns 0.538479mA
+ 3.158ns 0.546244mA
+ 3.16ns 0.54893mA
+ 3.162ns 0.546545mA
+ 3.164ns 0.54417mA
+ 3.166ns 0.541805mA
+ 3.168ns 0.539451mA
+ 3.17ns 0.537107mA
+ 3.172ns 0.534773mA
+ 3.174ns 0.532449mA
+ 3.176ns 0.530135mA
+ 3.178ns 0.527832mA
+ 3.18ns 0.525538mA
+ 3.182ns 0.523254mA
+ 3.184ns 0.520981mA
+ 3.186ns 0.518717mA
+ 3.188ns 0.516463mA
+ 3.19ns 0.514218mA
+ 3.192ns 0.511984mA
+ 3.194ns 0.509759mA
+ 3.196ns 0.507544mA
+ 3.198ns 0.505339mA
+ 3.2ns 0.503143mA
+ 3.202ns 0.500956mA
+ 3.204ns 0.49878mA
+ 3.206ns 0.496612mA
+ 3.208ns 0.494454mA
+ 3.21ns 0.492305mA
+ 3.212ns 0.490166mA
+ 3.214ns 0.488036mA
+ 3.216ns 0.485915mA
+ 3.218ns 0.483804mA
+ 3.22ns 0.481702mA
+ 3.222ns 0.479608mA
+ 3.224ns 0.477524mA
+ 3.226ns 0.475449mA
+ 3.228ns 0.473383mA
+ 3.23ns 0.471326mA
+ 3.232ns 0.469278mA
+ 3.234ns 0.467239mA
+ 3.236ns 0.465208mA
+ 3.238ns 0.463187mA
+ 3.24ns 0.461174mA
+ 3.242ns 0.45917mA
+ 3.244ns 0.457175mA
+ 3.246ns 0.455188mA
+ 3.248ns 0.45321mA
+ 3.25ns 0.451241mA
+ 3.252ns 0.44928mA
+ 3.254ns 0.447327mA
+ 3.256ns 0.445383mA
+ 3.258ns 0.443448mA
+ 3.26ns 0.441521mA
+ 3.262ns 0.439602mA
+ 3.264ns 0.437692mA
+ 3.266ns 0.43579mA
+ 3.268ns 0.433896mA
+ 3.27ns 0.432011mA
+ 3.272ns 0.430133mA
+ 3.274ns 0.428264mA
+ 3.276ns 0.426403mA
+ 3.278ns 0.42455mA
+ 3.28ns 0.422705mA
+ 3.282ns 0.420868mA
+ 3.284ns 0.419039mA
+ 3.286ns 0.417218mA
+ 3.288ns 0.415405mA
+ 3.29ns 0.4136mA
+ 3.292ns 0.411803mA
+ 3.294ns 0.410013mA
+ 3.296ns 0.408232mA
+ 3.298ns 0.406457mA
+ 3.3ns 0.404691mA
+ 3.302ns 0.402933mA
+ 3.304ns 0.401181mA
+ 3.306ns 0.399438mA
+ 3.308ns 0.397702mA
+ 3.31ns 0.395974mA
+ 3.312ns 0.394253mA
+ 3.314ns 0.39254mA
+ 3.316ns 0.390834mA
+ 3.318ns 0.389136mA
+ 3.32ns 0.387445mA
+ 3.322ns 0.385761mA
+ 3.324ns 0.384084mA
+ 3.326ns 0.382415mA
+ 3.328ns 0.380754mA
+ 3.33ns 0.379099mA
+ 3.332ns 0.377451mA
+ 3.334ns 0.375811mA
+ 3.336ns 0.374178mA
+ 3.338ns 0.372552mA
+ 3.34ns 0.370933mA
+ 3.342ns 0.369321mA
+ 3.344ns 0.367716mA
+ 3.346ns 0.366118mA
+ 3.348ns 0.364527mA
+ 3.35ns 0.362943mA
+ 3.352ns 0.361366mA
+ 3.354ns 0.359795mA
+ 3.356ns 0.358232mA
+ 3.358ns 0.356675mA
+ 3.36ns 0.355125mA
+ 3.362ns 0.353581mA
+ 3.364ns 0.352045mA
+ 3.366ns 0.350515mA
+ 3.368ns 0.348992mA
+ 3.37ns 0.347475mA
+ 3.372ns 0.345965mA
+ 3.374ns 0.344461mA
+ 3.376ns 0.342964mA
+ 3.378ns 0.341474mA
+ 3.38ns 0.33999mA
+ 3.382ns 0.338513mA
+ 3.384ns 0.337041mA
+ 3.386ns 0.335577mA
+ 3.388ns 0.334118mA
+ 3.39ns 0.332666mA
+ 3.392ns 0.331221mA
+ 3.394ns 0.329781mA
+ 3.396ns 0.328348mA
+ 3.398ns 0.326921mA
+ 3.4ns 0.3255mA
+ 3.402ns 0.324086mA
+ 3.404ns 0.322677mA
+ 3.406ns 0.321275mA
+ 3.408ns 0.319879mA
+ 3.41ns 0.318488mA
+ 3.412ns 0.317104mA
+ 3.414ns 0.315726mA
+ 3.416ns 0.314354mA
+ 3.418ns 0.312988mA
+ 3.42ns 0.311628mA
+ 3.422ns 0.310273mA
+ 3.424ns 0.308925mA
+ 3.426ns 0.307582mA
+ 3.428ns 0.306246mA
+ 3.43ns 0.304915mA
+ 3.432ns 0.30359mA
+ 3.434ns 0.30227mA
+ 3.436ns 0.300957mA
+ 3.438ns 0.299649mA
+ 3.44ns 0.298346mA
+ 3.442ns 0.29705mA
+ 3.444ns 0.295759mA
+ 3.446ns 0.294473mA
+ 3.448ns 0.293194mA
+ 3.45ns 0.29192mA
+ 3.452ns 0.290651mA
+ 3.454ns 0.289388mA
+ 3.456ns 0.28813mA
+ 3.458ns 0.286878mA
+ 3.46ns 0.285631mA
+ 3.462ns 0.28439mA
+ 3.464ns 0.283154mA
+ 3.466ns 0.281923mA
+ 3.468ns 0.280698mA
+ 3.47ns 0.279478mA
+ 3.472ns 0.278263mA
+ 3.474ns 0.277054mA
+ 3.476ns 0.27585mA
+ 3.478ns 0.274651mA
+ 3.48ns 0.273457mA
+ 3.482ns 0.272269mA
+ 3.484ns 0.271086mA
+ 3.486ns 0.269907mA
+ 3.488ns 0.268734mA
+ 3.49ns 0.267567mA
+ 3.492ns 0.266404mA
+ 3.494ns 0.265246mA
+ 3.496ns 0.264093mA
+ 3.498ns 0.262945mA
+ 3.5ns 0.261802mA
+ 3.502ns 0.260665mA
+ 3.504ns 0.259532mA
+ 3.506ns 0.258404mA
+ 3.508ns 0.257281mA
+ 3.51ns 0.256163mA
+ 3.512ns 0.255049mA
+ 3.514ns 0.253941mA
+ 3.516ns 0.252837mA
+ 3.518ns 0.251738mA
+ 3.52ns 0.250644mA
+ 3.522ns 0.249555mA
+ 3.524ns 0.24847mA
+ 3.526ns 0.24739mA
+ 3.528ns 0.246315mA
+ 3.53ns 0.245245mA
+ 3.532ns 0.244179mA
+ 3.534ns 0.243117mA
+ 3.536ns 0.242061mA
+ 3.538ns 0.241009mA
+ 3.54ns 0.239961mA
+ 3.542ns 0.238918mA
+ 3.544ns 0.23788mA
+ 3.546ns 0.236846mA
+ 3.548ns 0.235817mA
+ 3.55ns 0mA
I30 41 0 PWL 0 0
+ 2.638ns 0mA
+ 2.64ns 0.00412693mA
+ 2.642ns 0.00860096mA
+ 2.644ns 0.0130755mA
+ 2.646ns 0.0175501mA
+ 2.648ns 0.0220241mA
+ 2.65ns 0.0264987mA
+ 2.652ns 0.0309727mA
+ 2.654ns 0.0354473mA
+ 2.656ns 0.0399218mA
+ 2.658ns 0.0443958mA
+ 2.66ns 0.0488704mA
+ 2.662ns 0.0533444mA
+ 2.664ns 0.057819mA
+ 2.666ns 0.0622936mA
+ 2.668ns 0.0667676mA
+ 2.67ns 0.0712422mA
+ 2.672ns 0.0757162mA
+ 2.674ns 0.0801907mA
+ 2.676ns 0.0846653mA
+ 2.678ns 0.0891393mA
+ 2.68ns 0.0936139mA
+ 2.682ns 0.0980879mA
+ 2.684ns 0.102562mA
+ 2.686ns 0.107037mA
+ 2.688ns 0.111511mA
+ 2.69ns 0.115986mA
+ 2.692ns 0.118121mA
+ 2.694ns 0.114858mA
+ 2.696ns 0.111686mA
+ 2.698ns 0.108601mA
+ 2.7ns 0.105601mA
+ 2.702ns 0.102684mA
+ 2.704ns 0.0998475mA
+ 2.706ns 0.0970893mA
+ 2.708ns 0.0944076mA
+ 2.71ns 0.0917996mA
+ 2.712ns 0.0892637mA
+ 2.714ns 0.0867981mA
+ 2.716ns 0.0844003mA
+ 2.718ns 0.082069mA
+ 2.72ns 0.0798018mA
+ 2.722ns 0.0775972mA
+ 2.724ns 0.0754538mA
+ 2.726ns 0.0733693mA
+ 2.728ns 0.0713426mA
+ 2.73ns 0.0693716mA
+ 2.732ns 0.0674551mA
+ 2.734ns 0.0655918mA
+ 2.736ns 0.0637797mA
+ 2.738ns 0.0620178mA
+ 2.74ns 0.0603045mA
+ 2.742ns 0.0586384mA
+ 2.744ns 0.0570185mA
+ 2.746ns 0.0554432mA
+ 2.748ns 0.0539115mA
+ 2.75ns 0.0524221mA
+ 2.752ns 0.0509738mA
+ 2.754ns 0.0495656mA
+ 2.756ns 0.0481962mA
+ 2.758ns 0.0468646mA
+ 2.76ns 0.0455699mA
+ 2.762ns 0.0443108mA
+ 2.764ns 0.0430867mA
+ 2.766ns 0.0418962mA
+ 2.768ns 0mA
+ 5.138ns 0mA
+ 5.14ns 0.0041264mA
+ 5.142ns 0.00860149mA
+ 5.144ns 0.0130755mA
+ 5.146ns 0.0175495mA
+ 5.148ns 0.0220246mA
+ 5.15ns 0.0264987mA
+ 5.152ns 0.0309727mA
+ 5.154ns 0.0354478mA
+ 5.156ns 0.0399218mA
+ 5.158ns 0.0443958mA
+ 5.16ns 0.0488699mA
+ 5.162ns 0.053345mA
+ 5.164ns 0.057819mA
+ 5.166ns 0.062293mA
+ 5.168ns 0.0667681mA
+ 5.17ns 0.0712422mA
+ 5.172ns 0.0757162mA
+ 5.174ns 0.0801913mA
+ 5.176ns 0.0846653mA
+ 5.178ns 0.0891393mA
+ 5.18ns 0.0936134mA
+ 5.182ns 0.0980885mA
+ 5.184ns 0.102562mA
+ 5.186ns 0.107037mA
+ 5.188ns 0.111512mA
+ 5.19ns 0.115986mA
+ 5.192ns 0.118121mA
+ 5.194ns 0.114858mA
+ 5.196ns 0.111686mA
+ 5.198ns 0.108601mA
+ 5.2ns 0.1056mA
+ 5.202ns 0.102684mA
+ 5.204ns 0.0998475mA
+ 5.206ns 0.0970896mA
+ 5.208ns 0.0944073mA
+ 5.21ns 0.0917996mA
+ 5.212ns 0.089264mA
+ 5.214ns 0.0867978mA
+ 5.216ns 0.0844003mA
+ 5.218ns 0.082069mA
+ 5.22ns 0.0798015mA
+ 5.222ns 0.0775972mA
+ 5.224ns 0.0754538mA
+ 5.226ns 0.0733695mA
+ 5.228ns 0.0713423mA
+ 5.23ns 0.0693716mA
+ 5.232ns 0.0674554mA
+ 5.234ns 0.0655916mA
+ 5.236ns 0.0637797mA
+ 5.238ns 0.0620178mA
+ 5.24ns 0.0603043mA
+ 5.242ns 0.0586384mA
+ 5.244ns 0.0570185mA
+ 5.246ns 0.0554431mA
+ 5.248ns 0.0539115mA
+ 5.25ns 0.0524221mA
+ 5.252ns 0.050974mA
+ 5.254ns 0.0495655mA
+ 5.256ns 0.0481962mA
+ 5.258ns 0.0468647mA
+ 5.26ns 0.0455697mA
+ 5.262ns 0.0443108mA
+ 5.264ns 0.0430867mA
+ 5.266ns 0.0418961mA
+ 5.268ns 0mA
I31 42 0 PWL 0 0
+ 5.512ns 0mA
+ 5.514ns 0.00756379mA
+ 5.516ns 0.0153194mA
+ 5.518ns 0.0230731mA
+ 5.52ns 0.0308269mA
+ 5.522ns 0.0385806mA
+ 5.524ns 0.0463362mA
+ 5.526ns 0.05409mA
+ 5.528ns 0.0618437mA
+ 5.53ns 0.0695994mA
+ 5.532ns 0.0773531mA
+ 5.534ns 0.0851069mA
+ 5.536ns 0.0928625mA
+ 5.538ns 0.100616mA
+ 5.54ns 0.10837mA
+ 5.542ns 0.116126mA
+ 5.544ns 0.123879mA
+ 5.546ns 0.131633mA
+ 5.548ns 0.139387mA
+ 5.55ns 0.147142mA
+ 5.552ns 0.154896mA
+ 5.554ns 0.16265mA
+ 5.556ns 0.170406mA
+ 5.558ns 0.178159mA
+ 5.56ns 0.185913mA
+ 5.562ns 0.193669mA
+ 5.564ns 0.201422mA
+ 5.566ns 0.209176mA
+ 5.568ns 0.21693mA
+ 5.57ns 0.224685mA
+ 5.572ns 0.232439mA
+ 5.574ns 0.240193mA
+ 5.576ns 0.247949mA
+ 5.578ns 0.255702mA
+ 5.58ns 0.263456mA
+ 5.582ns 0.271212mA
+ 5.584ns 0.278965mA
+ 5.586ns 0.286719mA
+ 5.588ns 0.294475mA
+ 5.59ns 0.302229mA
+ 5.592ns 0.309982mA
+ 5.594ns 0.317736mA
+ 5.596ns 0.325492mA
+ 5.598ns 0.333245mA
+ 5.6ns 0.340999mA
+ 5.602ns 0.348755mA
+ 5.604ns 0.356508mA
+ 5.606ns 0.364262mA
+ 5.608ns 0.372018mA
+ 5.61ns 0.379772mA
+ 5.612ns 0.387525mA
+ 5.614ns 0.395279mA
+ 5.616ns 0.403035mA
+ 5.618ns 0.410788mA
+ 5.62ns 0.418542mA
+ 5.622ns 0.426298mA
+ 5.624ns 0.434052mA
+ 5.626ns 0.441805mA
+ 5.628ns 0.449561mA
+ 5.63ns 0.457315mA
+ 5.632ns 0.465068mA
+ 5.634ns 0.472824mA
+ 5.636ns 0.480578mA
+ 5.638ns 0.488332mA
+ 5.64ns 0.496085mA
+ 5.642ns 0.503841mA
+ 5.644ns 0.511595mA
+ 5.646ns 0.519348mA
+ 5.648ns 0.527104mA
+ 5.65ns 0.534858mA
+ 5.652ns 0.542611mA
+ 5.654ns 0.550367mA
+ 5.656ns 0.548473mA
+ 5.658ns 0.546084mA
+ 5.66ns 0.543705mA
+ 5.662ns 0.541335mA
+ 5.664ns 0.538977mA
+ 5.666ns 0.536628mA
+ 5.668ns 0.53429mA
+ 5.67ns 0.531962mA
+ 5.672ns 0.529644mA
+ 5.674ns 0.527336mA
+ 5.676ns 0.525039mA
+ 5.678ns 0.522751mA
+ 5.68ns 0.520473mA
+ 5.682ns 0.518206mA
+ 5.684ns 0.515948mA
+ 5.686ns 0.5137mA
+ 5.688ns 0.511461mA
+ 5.69ns 0.509233mA
+ 5.692ns 0.507014mA
+ 5.694ns 0.504805mA
+ 5.696ns 0.502605mA
+ 5.698ns 0.500415mA
+ 5.7ns 0.498235mA
+ 5.702ns 0.496064mA
+ 5.704ns 0.493903mA
+ 5.706ns 0.491751mA
+ 5.708ns 0.489608mA
+ 5.71ns 0.487475mA
+ 5.712ns 0.485351mA
+ 5.714ns 0.483235mA
+ 5.716ns 0.48113mA
+ 5.718ns 0.479034mA
+ 5.72ns 0.476946mA
+ 5.722ns 0.474868mA
+ 5.724ns 0.472799mA
+ 5.726ns 0.470739mA
+ 5.728ns 0.468688mA
+ 5.73ns 0.466646mA
+ 5.732ns 0.464613mA
+ 5.734ns 0.462588mA
+ 5.736ns 0.460572mA
+ 5.738ns 0.458566mA
+ 5.74ns 0.456567mA
+ 5.742ns 0.454578mA
+ 5.744ns 0.452597mA
+ 5.746ns 0.450625mA
+ 5.748ns 0.448661mA
+ 5.75ns 0.446707mA
+ 5.752ns 0.44476mA
+ 5.754ns 0.442822mA
+ 5.756ns 0.440893mA
+ 5.758ns 0.438972mA
+ 5.76ns 0.437059mA
+ 5.762ns 0.435154mA
+ 5.764ns 0.433258mA
+ 5.766ns 0.43137mA
+ 5.768ns 0.429491mA
+ 5.77ns 0.427619mA
+ 5.772ns 0.425756mA
+ 5.774ns 0.423901mA
+ 5.776ns 0.422054mA
+ 5.778ns 0.420215mA
+ 5.78ns 0.418383mA
+ 5.782ns 0.416561mA
+ 5.784ns 0.414746mA
+ 5.786ns 0.412938mA
+ 5.788ns 0.411139mA
+ 5.79ns 0.409347mA
+ 5.792ns 0.407563mA
+ 5.794ns 0.405788mA
+ 5.796ns 0.40402mA
+ 5.798ns 0.402259mA
+ 5.8ns 0.400506mA
+ 5.802ns 0.398761mA
+ 5.804ns 0.397024mA
+ 5.806ns 0.395293mA
+ 5.808ns 0.393571mA
+ 5.81ns 0.391856mA
+ 5.812ns 0.390148mA
+ 5.814ns 0.388448mA
+ 5.816ns 0.386756mA
+ 5.818ns 0.38507mA
+ 5.82ns 0.383392mA
+ 5.822ns 0.381722mA
+ 5.824ns 0.380059mA
+ 5.826ns 0.378402mA
+ 5.828ns 0.376754mA
+ 5.83ns 0.375112mA
+ 5.832ns 0.373477mA
+ 5.834ns 0.37185mA
+ 5.836ns 0.37023mA
+ 5.838ns 0.368616mA
+ 5.84ns 0.36701mA
+ 5.842ns 0.365411mA
+ 5.844ns 0.363819mA
+ 5.846ns 0.362233mA
+ 5.848ns 0.360655mA
+ 5.85ns 0.359083mA
+ 5.852ns 0.357518mA
+ 5.854ns 0.35596mA
+ 5.856ns 0.354409mA
+ 5.858ns 0.352865mA
+ 5.86ns 0.351327mA
+ 5.862ns 0.349796mA
+ 5.864ns 0.348272mA
+ 5.866ns 0.346754mA
+ 5.868ns 0.345243mA
+ 5.87ns 0.343739mA
+ 5.872ns 0.342241mA
+ 5.874ns 0.34075mA
+ 5.876ns 0.339265mA
+ 5.878ns 0.337786mA
+ 5.88ns 0.336314mA
+ 5.882ns 0.334849mA
+ 5.884ns 0.33339mA
+ 5.886ns 0.331937mA
+ 5.888ns 0.330491mA
+ 5.89ns 0.329051mA
+ 5.892ns 0.327616mA
+ 5.894ns 0.326189mA
+ 5.896ns 0.324768mA
+ 5.898ns 0.323352mA
+ 5.9ns 0.321943mA
+ 5.902ns 0.32054mA
+ 5.904ns 0.319143mA
+ 5.906ns 0.317753mA
+ 5.908ns 0.316368mA
+ 5.91ns 0.314989mA
+ 5.912ns 0.313617mA
+ 5.914ns 0.31225mA
+ 5.916ns 0.31089mA
+ 5.918ns 0.309535mA
+ 5.92ns 0.308186mA
+ 5.922ns 0.306843mA
+ 5.924ns 0.305506mA
+ 5.926ns 0.304174mA
+ 5.928ns 0.302849mA
+ 5.93ns 0.301529mA
+ 5.932ns 0.300215mA
+ 5.934ns 0.298907mA
+ 5.936ns 0.297604mA
+ 5.938ns 0.296307mA
+ 5.94ns 0.295016mA
+ 5.942ns 0.293731mA
+ 5.944ns 0.29245mA
+ 5.946ns 0.291176mA
+ 5.948ns 0.289907mA
+ 5.95ns 0.288644mA
+ 5.952ns 0.287386mA
+ 5.954ns 0.286134mA
+ 5.956ns 0.284887mA
+ 5.958ns 0.283645mA
+ 5.96ns 0.282409mA
+ 5.962ns 0.281179mA
+ 5.964ns 0.279953mA
+ 5.966ns 0.278733mA
+ 5.968ns 0.277519mA
+ 5.97ns 0.276309mA
+ 5.972ns 0.275105mA
+ 5.974ns 0.273906mA
+ 5.976ns 0.272712mA
+ 5.978ns 0.271524mA
+ 5.98ns 0.270341mA
+ 5.982ns 0.269163mA
+ 5.984ns 0.26799mA
+ 5.986ns 0.266822mA
+ 5.988ns 0.265659mA
+ 5.99ns 0.264501mA
+ 5.992ns 0.263349mA
+ 5.994ns 0.262201mA
+ 5.996ns 0.261058mA
+ 5.998ns 0.259921mA
+ 6ns 0.258788mA
+ 6.002ns 0.25766mA
+ 6.004ns 0.256537mA
+ 6.006ns 0.255419mA
+ 6.008ns 0.254306mA
+ 6.01ns 0.253198mA
+ 6.012ns 0.252095mA
+ 6.014ns 0.250996mA
+ 6.016ns 0.249902mA
+ 6.018ns 0.248813mA
+ 6.02ns 0.247729mA
+ 6.022ns 0.246649mA
+ 6.024ns 0.245574mA
+ 6.026ns 0.244504mA
+ 6.028ns 0.243439mA
+ 6.03ns 0.242378mA
+ 6.032ns 0.241321mA
+ 6.034ns 0.24027mA
+ 6.036ns 0.239223mA
+ 6.038ns 0.23818mA
+ 6.04ns 0.237142mA
+ 6.042ns 0.236109mA
+ 6.044ns 0mA
I32 43 0 PWL 0 0
+ 3.02ns 0mA
+ 3.022ns 0.00524396mA
+ 3.024ns 0.0129702mA
+ 3.026ns 0.0206956mA
+ 3.028ns 0.0284219mA
+ 3.03ns 0.0361473mA
+ 3.032ns 0.0438736mA
+ 3.034ns 0.0515998mA
+ 3.036ns 0.0593252mA
+ 3.038ns 0.0670515mA
+ 3.04ns 0.0747769mA
+ 3.042ns 0.0825031mA
+ 3.044ns 0.0902294mA
+ 3.046ns 0.0979548mA
+ 3.048ns 0.105681mA
+ 3.05ns 0.113406mA
+ 3.052ns 0.121133mA
+ 3.054ns 0.128859mA
+ 3.056ns 0.136584mA
+ 3.058ns 0.144311mA
+ 3.06ns 0.152036mA
+ 3.062ns 0.159762mA
+ 3.064ns 0.167489mA
+ 3.066ns 0.175214mA
+ 3.068ns 0.18294mA
+ 3.07ns 0.190666mA
+ 3.072ns 0.198392mA
+ 3.074ns 0.206118mA
+ 3.076ns 0.213844mA
+ 3.078ns 0.22157mA
+ 3.08ns 0.229296mA
+ 3.082ns 0.237022mA
+ 3.084ns 0.244748mA
+ 3.086ns 0.252473mA
+ 3.088ns 0.260199mA
+ 3.09ns 0.267926mA
+ 3.092ns 0.275651mA
+ 3.094ns 0.283377mA
+ 3.096ns 0.291103mA
+ 3.098ns 0.298829mA
+ 3.1ns 0.306555mA
+ 3.102ns 0.314281mA
+ 3.104ns 0.322007mA
+ 3.106ns 0.329732mA
+ 3.108ns 0.337459mA
+ 3.11ns 0.345185mA
+ 3.112ns 0.35291mA
+ 3.114ns 0.360637mA
+ 3.116ns 0.368362mA
+ 3.118ns 0.376088mA
+ 3.12ns 0.383815mA
+ 3.122ns 0.39154mA
+ 3.124ns 0.399266mA
+ 3.126ns 0.406992mA
+ 3.128ns 0.414718mA
+ 3.13ns 0.422444mA
+ 3.132ns 0.43017mA
+ 3.134ns 0.437896mA
+ 3.136ns 0.445622mA
+ 3.138ns 0.453347mA
+ 3.14ns 0.461074mA
+ 3.142ns 0.468799mA
+ 3.144ns 0.476525mA
+ 3.146ns 0.484252mA
+ 3.148ns 0.491977mA
+ 3.15ns 0.499703mA
+ 3.152ns 0.507429mA
+ 3.154ns 0.515155mA
+ 3.156ns 0.522881mA
+ 3.158ns 0.530607mA
+ 3.16ns 0.538333mA
+ 3.162ns 0.546058mA
+ 3.164ns 0.549229mA
+ 3.166ns 0.546839mA
+ 3.168ns 0.544459mA
+ 3.17ns 0.54209mA
+ 3.172ns 0.539731mA
+ 3.174ns 0.537382mA
+ 3.176ns 0.535044mA
+ 3.178ns 0.532716mA
+ 3.18ns 0.530397mA
+ 3.182ns 0.528089mA
+ 3.184ns 0.525791mA
+ 3.186ns 0.523503mA
+ 3.188ns 0.521225mA
+ 3.19ns 0.518957mA
+ 3.192ns 0.516699mA
+ 3.194ns 0.51445mA
+ 3.196ns 0.512211mA
+ 3.198ns 0.509983mA
+ 3.2ns 0.507763mA
+ 3.202ns 0.505554mA
+ 3.204ns 0.503354mA
+ 3.206ns 0.501163mA
+ 3.208ns 0.498982mA
+ 3.21ns 0.496811mA
+ 3.212ns 0.494649mA
+ 3.214ns 0.492496mA
+ 3.216ns 0.490353mA
+ 3.218ns 0.488219mA
+ 3.22ns 0.486095mA
+ 3.222ns 0.483979mA
+ 3.224ns 0.481873mA
+ 3.226ns 0.479776mA
+ 3.228ns 0.477688mA
+ 3.23ns 0.47561mA
+ 3.232ns 0.47354mA
+ 3.234ns 0.471479mA
+ 3.236ns 0.469428mA
+ 3.238ns 0.467385mA
+ 3.24ns 0.465351mA
+ 3.242ns 0.463326mA
+ 3.244ns 0.461309mA
+ 3.246ns 0.459302mA
+ 3.248ns 0.457303mA
+ 3.25ns 0.455313mA
+ 3.252ns 0.453332mA
+ 3.254ns 0.451359mA
+ 3.256ns 0.449395mA
+ 3.258ns 0.447439mA
+ 3.26ns 0.445492mA
+ 3.262ns 0.443553mA
+ 3.264ns 0.441623mA
+ 3.266ns 0.439701mA
+ 3.268ns 0.437787mA
+ 3.27ns 0.435882mA
+ 3.272ns 0.433985mA
+ 3.274ns 0.432097mA
+ 3.276ns 0.430216mA
+ 3.278ns 0.428344mA
+ 3.28ns 0.42648mA
+ 3.282ns 0.424624mA
+ 3.284ns 0.422776mA
+ 3.286ns 0.420936mA
+ 3.288ns 0.419104mA
+ 3.29ns 0.417281mA
+ 3.292ns 0.415465mA
+ 3.294ns 0.413657mA
+ 3.296ns 0.411857mA
+ 3.298ns 0.410064mA
+ 3.3ns 0.40828mA
+ 3.302ns 0.406503mA
+ 3.304ns 0.404734mA
+ 3.306ns 0.402972mA
+ 3.308ns 0.401219mA
+ 3.31ns 0.399473mA
+ 3.312ns 0.397734mA
+ 3.314ns 0.396003mA
+ 3.316ns 0.39428mA
+ 3.318ns 0.392564mA
+ 3.32ns 0.390855mA
+ 3.322ns 0.389155mA
+ 3.324ns 0.387461mA
+ 3.326ns 0.385775mA
+ 3.328ns 0.384096mA
+ 3.33ns 0.382424mA
+ 3.332ns 0.38076mA
+ 3.334ns 0.379103mA
+ 3.336ns 0.377453mA
+ 3.338ns 0.375811mA
+ 3.34ns 0.374175mA
+ 3.342ns 0.372547mA
+ 3.344ns 0.370925mA
+ 3.346ns 0.369311mA
+ 3.348ns 0.367704mA
+ 3.35ns 0.366104mA
+ 3.352ns 0.36451mA
+ 3.354ns 0.362924mA
+ 3.356ns 0.361345mA
+ 3.358ns 0.359772mA
+ 3.36ns 0.358206mA
+ 3.362ns 0.356647mA
+ 3.364ns 0.355095mA
+ 3.366ns 0.35355mA
+ 3.368ns 0.352011mA
+ 3.37ns 0.350479mA
+ 3.372ns 0.348954mA
+ 3.374ns 0.347435mA
+ 3.376ns 0.345923mA
+ 3.378ns 0.344418mA
+ 3.38ns 0.342919mA
+ 3.382ns 0.341426mA
+ 3.384ns 0.33994mA
+ 3.386ns 0.338461mA
+ 3.388ns 0.336988mA
+ 3.39ns 0.335521mA
+ 3.392ns 0.334061mA
+ 3.394ns 0.332607mA
+ 3.396ns 0.33116mA
+ 3.398ns 0.329718mA
+ 3.4ns 0.328283mA
+ 3.402ns 0.326855mA
+ 3.404ns 0.325432mA
+ 3.406ns 0.324016mA
+ 3.408ns 0.322606mA
+ 3.41ns 0.321202mA
+ 3.412ns 0.319804mA
+ 3.414ns 0.318412mA
+ 3.416ns 0.317026mA
+ 3.418ns 0.315646mA
+ 3.42ns 0.314273mA
+ 3.422ns 0.312905mA
+ 3.424ns 0.311543mA
+ 3.426ns 0.310187mA
+ 3.428ns 0.308837mA
+ 3.43ns 0.307493mA
+ 3.432ns 0.306155mA
+ 3.434ns 0.304822mA
+ 3.436ns 0.303496mA
+ 3.438ns 0.302175mA
+ 3.44ns 0.30086mA
+ 3.442ns 0.29955mA
+ 3.444ns 0.298247mA
+ 3.446ns 0.296949mA
+ 3.448ns 0.295656mA
+ 3.45ns 0.294369mA
+ 3.452ns 0.293088mA
+ 3.454ns 0.291813mA
+ 3.456ns 0.290543mA
+ 3.458ns 0.289278mA
+ 3.46ns 0.288019mA
+ 3.462ns 0.286766mA
+ 3.464ns 0.285518mA
+ 3.466ns 0.284275mA
+ 3.468ns 0.283038mA
+ 3.47ns 0.281806mA
+ 3.472ns 0.280579mA
+ 3.474ns 0.279358mA
+ 3.476ns 0.278142mA
+ 3.478ns 0.276932mA
+ 3.48ns 0.275726mA
+ 3.482ns 0.274526mA
+ 3.484ns 0.273332mA
+ 3.486ns 0.272142mA
+ 3.488ns 0.270957mA
+ 3.49ns 0.269778mA
+ 3.492ns 0.268604mA
+ 3.494ns 0.267435mA
+ 3.496ns 0.266271mA
+ 3.498ns 0.265112mA
+ 3.5ns 0.263958mA
+ 3.502ns 0.262809mA
+ 3.504ns 0.261666mA
+ 3.506ns 0.260527mA
+ 3.508ns 0.259393mA
+ 3.51ns 0.258264mA
+ 3.512ns 0.25714mA
+ 3.514ns 0.256021mA
+ 3.516ns 0.254906mA
+ 3.518ns 0.253797mA
+ 3.52ns 0.252692mA
+ 3.522ns 0.251592mA
+ 3.524ns 0.250497mA
+ 3.526ns 0.249407mA
+ 3.528ns 0.248322mA
+ 3.53ns 0.247241mA
+ 3.532ns 0.246165mA
+ 3.534ns 0.245093mA
+ 3.536ns 0.244027mA
+ 3.538ns 0.242964mA
+ 3.54ns 0.241907mA
+ 3.542ns 0.240854mA
+ 3.544ns 0.239806mA
+ 3.546ns 0.238762mA
+ 3.548ns 0.237723mA
+ 3.55ns 0.236688mA
+ 3.552ns 0.235658mA
+ 3.554ns 0mA
I33 44 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.0032445mA
+ 2.656ns 0.0134635mA
+ 2.658ns 0.0236813mA
+ 2.66ns 0.0339003mA
+ 2.662ns 0.0441181mA
+ 2.664ns 0.0543372mA
+ 2.666ns 0.0645562mA
+ 2.668ns 0.074774mA
+ 2.67ns 0.084993mA
+ 2.672ns 0.0952108mA
+ 2.674ns 0.10543mA
+ 2.676ns 0.115649mA
+ 2.678ns 0.125867mA
+ 2.68ns 0.136086mA
+ 2.682ns 0.130749mA
+ 2.684ns 0.118137mA
+ 2.686ns 0.106741mA
+ 2.688ns 0.0964449mA
+ 2.69ns 0.0871409mA
+ 2.692ns 0.0787342mA
+ 2.694ns 0.0711392mA
+ 2.696ns 0.0642759mA
+ 2.698ns 0.0580754mA
+ 2.7ns 0.0524722mA
+ 2.702ns 0.0474095mA
+ 2.704ns 0.0428356mA
+ 2.706ns 0.0387025mA
+ 2.708ns 0.0349685mA
+ 2.71ns 0mA
+ 5.152ns 0mA
+ 5.154ns 0.00324572mA
+ 5.156ns 0.0134635mA
+ 5.158ns 0.0236813mA
+ 5.16ns 0.0338991mA
+ 5.162ns 0.0441194mA
+ 5.164ns 0.0543372mA
+ 5.166ns 0.064555mA
+ 5.168ns 0.0747752mA
+ 5.17ns 0.084993mA
+ 5.172ns 0.0952108mA
+ 5.174ns 0.105431mA
+ 5.176ns 0.115649mA
+ 5.178ns 0.125867mA
+ 5.18ns 0.136084mA
+ 5.182ns 0.130748mA
+ 5.184ns 0.118137mA
+ 5.186ns 0.106742mA
+ 5.188ns 0.0964437mA
+ 5.19ns 0.0871409mA
+ 5.192ns 0.0787351mA
+ 5.194ns 0.0711384mA
+ 5.196ns 0.0642759mA
+ 5.198ns 0.0580754mA
+ 5.2ns 0.0524715mA
+ 5.202ns 0.0474095mA
+ 5.204ns 0.0428356mA
+ 5.206ns 0.038703mA
+ 5.208ns 0.0349681mA
+ 5.21ns 0mA
I34 45 0 PWL 0 0
+ 0.514ns 0mA
+ 0.516ns 2.09789e-05mA
+ 0.518ns 0.00784238mA
+ 0.52ns 0.015664mA
+ 0.522ns 0.0234854mA
+ 0.524ns 0.0313071mA
+ 0.526ns 0.0391285mA
+ 0.528ns 0.0469499mA
+ 0.53ns 0.0547715mA
+ 0.532ns 0.0625929mA
+ 0.534ns 0.0704145mA
+ 0.536ns 0.0782359mA
+ 0.538ns 0.0860576mA
+ 0.54ns 0.093879mA
+ 0.542ns 0.101701mA
+ 0.544ns 0.109522mA
+ 0.546ns 0.117343mA
+ 0.548ns 0.125165mA
+ 0.55ns 0.132986mA
+ 0.552ns 0.140808mA
+ 0.554ns 0.148629mA
+ 0.556ns 0.156451mA
+ 0.558ns 0.164273mA
+ 0.56ns 0.172094mA
+ 0.562ns 0.179916mA
+ 0.564ns 0.187737mA
+ 0.566ns 0.195559mA
+ 0.568ns 0.20338mA
+ 0.57ns 0.211202mA
+ 0.572ns 0.219023mA
+ 0.574ns 0.226844mA
+ 0.576ns 0.234666mA
+ 0.578ns 0.242487mA
+ 0.58ns 0.250309mA
+ 0.582ns 0.258131mA
+ 0.584ns 0.265952mA
+ 0.586ns 0.273774mA
+ 0.588ns 0.281595mA
+ 0.59ns 0.289417mA
+ 0.592ns 0.297238mA
+ 0.594ns 0.30506mA
+ 0.596ns 0.312881mA
+ 0.598ns 0.320703mA
+ 0.6ns 0.328524mA
+ 0.602ns 0.336346mA
+ 0.604ns 0.344167mA
+ 0.606ns 0.351989mA
+ 0.608ns 0.35981mA
+ 0.61ns 0.367632mA
+ 0.612ns 0.375453mA
+ 0.614ns 0.383275mA
+ 0.616ns 0.391096mA
+ 0.618ns 0.398918mA
+ 0.62ns 0.406739mA
+ 0.622ns 0.414561mA
+ 0.624ns 0.422382mA
+ 0.626ns 0.430204mA
+ 0.628ns 0.438025mA
+ 0.63ns 0.445847mA
+ 0.632ns 0.453668mA
+ 0.634ns 0.46149mA
+ 0.636ns 0.469311mA
+ 0.638ns 0.477133mA
+ 0.64ns 0.484954mA
+ 0.642ns 0.492776mA
+ 0.644ns 0.500597mA
+ 0.646ns 0.508419mA
+ 0.648ns 0.51624mA
+ 0.65ns 0.524062mA
+ 0.652ns 0.531883mA
+ 0.654ns 0.539705mA
+ 0.656ns 0.547526mA
+ 0.658ns 0.548201mA
+ 0.66ns 0.545822mA
+ 0.662ns 0.543454mA
+ 0.664ns 0.541096mA
+ 0.666ns 0.538748mA
+ 0.668ns 0.53641mA
+ 0.67ns 0.534082mA
+ 0.672ns 0.531765mA
+ 0.674ns 0.529457mA
+ 0.676ns 0.52716mA
+ 0.678ns 0.524872mA
+ 0.68ns 0.522594mA
+ 0.682ns 0.520327mA
+ 0.684ns 0.518069mA
+ 0.686ns 0.515821mA
+ 0.688ns 0.513582mA
+ 0.69ns 0.511354mA
+ 0.692ns 0.509135mA
+ 0.694ns 0.506925mA
+ 0.696ns 0.504726mA
+ 0.698ns 0.502536mA
+ 0.7ns 0.500355mA
+ 0.702ns 0.498184mA
+ 0.704ns 0.496022mA
+ 0.706ns 0.493869mA
+ 0.708ns 0.491726mA
+ 0.71ns 0.489592mA
+ 0.712ns 0.487468mA
+ 0.714ns 0.485352mA
+ 0.716ns 0.483246mA
+ 0.718ns 0.481149mA
+ 0.72ns 0.479061mA
+ 0.722ns 0.476982mA
+ 0.724ns 0.474913mA
+ 0.726ns 0.472852mA
+ 0.728ns 0.4708mA
+ 0.73ns 0.468757mA
+ 0.732ns 0.466723mA
+ 0.734ns 0.464697mA
+ 0.736ns 0.462681mA
+ 0.738ns 0.460673mA
+ 0.74ns 0.458674mA
+ 0.742ns 0.456683mA
+ 0.744ns 0.454702mA
+ 0.746ns 0.452728mA
+ 0.748ns 0.450764mA
+ 0.75ns 0.448808mA
+ 0.752ns 0.44686mA
+ 0.754ns 0.444921mA
+ 0.756ns 0.44299mA
+ 0.758ns 0.441068mA
+ 0.76ns 0.439154mA
+ 0.762ns 0.437248mA
+ 0.764ns 0.435351mA
+ 0.766ns 0.433461mA
+ 0.768ns 0.43158mA
+ 0.77ns 0.429707mA
+ 0.772ns 0.427843mA
+ 0.774ns 0.425986mA
+ 0.776ns 0.424138mA
+ 0.778ns 0.422297mA
+ 0.78ns 0.420464mA
+ 0.782ns 0.41864mA
+ 0.784ns 0.416823mA
+ 0.786ns 0.415014mA
+ 0.788ns 0.413213mA
+ 0.79ns 0.41142mA
+ 0.792ns 0.409635mA
+ 0.794ns 0.407857mA
+ 0.796ns 0.406087mA
+ 0.798ns 0.404325mA
+ 0.8ns 0.40257mA
+ 0.802ns 0.400823mA
+ 0.804ns 0.399084mA
+ 0.806ns 0.397352mA
+ 0.808ns 0.395627mA
+ 0.81ns 0.39391mA
+ 0.812ns 0.392201mA
+ 0.814ns 0.390499mA
+ 0.816ns 0.388804mA
+ 0.818ns 0.387117mA
+ 0.82ns 0.385437mA
+ 0.822ns 0.383764mA
+ 0.824ns 0.382099mA
+ 0.826ns 0.380441mA
+ 0.828ns 0.37879mA
+ 0.83ns 0.377146mA
+ 0.832ns 0.375509mA
+ 0.834ns 0.37388mA
+ 0.836ns 0.372257mA
+ 0.838ns 0.370642mA
+ 0.84ns 0.369033mA
+ 0.842ns 0.367432mA
+ 0.844ns 0.365837mA
+ 0.846ns 0.364249mA
+ 0.848ns 0.362669mA
+ 0.85ns 0.361095mA
+ 0.852ns 0.359528mA
+ 0.854ns 0.357967mA
+ 0.856ns 0.356414mA
+ 0.858ns 0.354867mA
+ 0.86ns 0.353327mA
+ 0.862ns 0.351794mA
+ 0.864ns 0.350267mA
+ 0.866ns 0.348747mA
+ 0.868ns 0.347234mA
+ 0.87ns 0.345727mA
+ 0.872ns 0.344226mA
+ 0.874ns 0.342732mA
+ 0.876ns 0.341245mA
+ 0.878ns 0.339764mA
+ 0.88ns 0.338289mA
+ 0.882ns 0.336821mA
+ 0.884ns 0.33536mA
+ 0.886ns 0.333904mA
+ 0.888ns 0.332455mA
+ 0.89ns 0.331012mA
+ 0.892ns 0.329576mA
+ 0.894ns 0.328145mA
+ 0.896ns 0.326721mA
+ 0.898ns 0.325303mA
+ 0.9ns 0.323892mA
+ 0.902ns 0.322486mA
+ 0.904ns 0.321086mA
+ 0.906ns 0.319693mA
+ 0.908ns 0.318306mA
+ 0.91ns 0.316924mA
+ 0.912ns 0.315549mA
+ 0.914ns 0.314179mA
+ 0.916ns 0.312816mA
+ 0.918ns 0.311458mA
+ 0.92ns 0.310107mA
+ 0.922ns 0.308761mA
+ 0.924ns 0.307421mA
+ 0.926ns 0.306086mA
+ 0.928ns 0.304758mA
+ 0.93ns 0.303435mA
+ 0.932ns 0.302119mA
+ 0.934ns 0.300807mA
+ 0.936ns 0.299502mA
+ 0.938ns 0.298202mA
+ 0.94ns 0.296908mA
+ 0.942ns 0.295619mA
+ 0.944ns 0.294336mA
+ 0.946ns 0.293059mA
+ 0.948ns 0.291787mA
+ 0.95ns 0.290521mA
+ 0.952ns 0.28926mA
+ 0.954ns 0.288004mA
+ 0.956ns 0.286755mA
+ 0.958ns 0.28551mA
+ 0.96ns 0.284271mA
+ 0.962ns 0.283037mA
+ 0.964ns 0.281809mA
+ 0.966ns 0.280586mA
+ 0.968ns 0.279368mA
+ 0.97ns 0.278156mA
+ 0.972ns 0.276948mA
+ 0.974ns 0.275746mA
+ 0.976ns 0.27455mA
+ 0.978ns 0.273358mA
+ 0.98ns 0.272172mA
+ 0.982ns 0.27099mA
+ 0.984ns 0.269814mA
+ 0.986ns 0.268643mA
+ 0.988ns 0.267477mA
+ 0.99ns 0.266316mA
+ 0.992ns 0.265161mA
+ 0.994ns 0.26401mA
+ 0.996ns 0.262864mA
+ 0.998ns 0.261723mA
+ 1ns 0.260587mA
+ 1.002ns 0.259456mA
+ 1.004ns 0.25833mA
+ 1.006ns 0.257209mA
+ 1.008ns 0.256093mA
+ 1.01ns 0.254981mA
+ 1.012ns 0.253875mA
+ 1.014ns 0.252773mA
+ 1.016ns 0.251676mA
+ 1.018ns 0.250583mA
+ 1.02ns 0.249496mA
+ 1.022ns 0.248413mA
+ 1.024ns 0.247335mA
+ 1.026ns 0.246261mA
+ 1.028ns 0.245193mA
+ 1.03ns 0.244128mA
+ 1.032ns 0.243069mA
+ 1.034ns 0.242014mA
+ 1.036ns 0.240963mA
+ 1.038ns 0.239918mA
+ 1.04ns 0.238876mA
+ 1.042ns 0.23784mA
+ 1.044ns 0.236807mA
+ 1.046ns 0mA
I35 46 0 PWL 0 0
+ 0.378ns 0mA
+ 0.38ns 0.000301272mA
+ 0.382ns 0.00407259mA
+ 0.384ns 0.00784386mA
+ 0.386ns 0.0116152mA
+ 0.388ns 0.0153865mA
+ 0.39ns 0.0191578mA
+ 0.392ns 0.0229291mA
+ 0.394ns 0.0267005mA
+ 0.396ns 0.0304718mA
+ 0.398ns 0.0342431mA
+ 0.4ns 0.0380144mA
+ 0.402ns 0.0417857mA
+ 0.404ns 0.045557mA
+ 0.406ns 0.0493283mA
+ 0.408ns 0.0530996mA
+ 0.41ns 0.056871mA
+ 0.412ns 0.0606423mA
+ 0.414ns 0.0644136mA
+ 0.416ns 0.0681849mA
+ 0.418ns 0.0719562mA
+ 0.42ns 0.0757275mA
+ 0.422ns 0.0794988mA
+ 0.424ns 0.0832701mA
+ 0.426ns 0.0870415mA
+ 0.428ns 0.0908128mA
+ 0.43ns 0.0945841mA
+ 0.432ns 0.0983554mA
+ 0.434ns 0.102127mA
+ 0.436ns 0.105898mA
+ 0.438ns 0.109669mA
+ 0.44ns 0.113441mA
+ 0.442ns 0.117212mA
+ 0.444ns 0.120983mA
+ 0.446ns 0.124755mA
+ 0.448ns 0.128526mA
+ 0.45ns 0.132297mA
+ 0.452ns 0.136069mA
+ 0.454ns 0.13984mA
+ 0.456ns 0.143611mA
+ 0.458ns 0.147382mA
+ 0.46ns 0.151154mA
+ 0.462ns 0.154925mA
+ 0.464ns 0.158696mA
+ 0.466ns 0.162468mA
+ 0.468ns 0.166239mA
+ 0.47ns 0.17001mA
+ 0.472ns 0.173782mA
+ 0.474ns 0.177553mA
+ 0.476ns 0.181324mA
+ 0.478ns 0.185096mA
+ 0.48ns 0.188867mA
+ 0.482ns 0.192638mA
+ 0.484ns 0.19641mA
+ 0.486ns 0.200181mA
+ 0.488ns 0.203952mA
+ 0.49ns 0.207723mA
+ 0.492ns 0.211495mA
+ 0.494ns 0.215266mA
+ 0.496ns 0.219037mA
+ 0.498ns 0.222809mA
+ 0.5ns 0.22658mA
+ 0.502ns 0.230351mA
+ 0.504ns 0.234123mA
+ 0.506ns 0.237894mA
+ 0.508ns 0.241665mA
+ 0.51ns 0.245437mA
+ 0.512ns 0.249208mA
+ 0.514ns 0.252979mA
+ 0.516ns 0.256751mA
+ 0.518ns 0.260522mA
+ 0.52ns 0.264293mA
+ 0.522ns 0.268064mA
+ 0.524ns 0.271836mA
+ 0.526ns 0.275607mA
+ 0.528ns 0.279378mA
+ 0.53ns 0.28315mA
+ 0.532ns 0.286921mA
+ 0.534ns 0.290692mA
+ 0.536ns 0.294464mA
+ 0.538ns 0.298235mA
+ 0.54ns 0.302006mA
+ 0.542ns 0.305778mA
+ 0.544ns 0.309549mA
+ 0.546ns 0.31332mA
+ 0.548ns 0.317092mA
+ 0.55ns 0.320863mA
+ 0.552ns 0.324634mA
+ 0.554ns 0.328405mA
+ 0.556ns 0.332177mA
+ 0.558ns 0.335948mA
+ 0.56ns 0.339719mA
+ 0.562ns 0.343491mA
+ 0.564ns 0.347262mA
+ 0.566ns 0.351033mA
+ 0.568ns 0.354805mA
+ 0.57ns 0.358576mA
+ 0.572ns 0.362347mA
+ 0.574ns 0.366119mA
+ 0.576ns 0.36989mA
+ 0.578ns 0.373661mA
+ 0.58ns 0.377433mA
+ 0.582ns 0.381204mA
+ 0.584ns 0.384975mA
+ 0.586ns 0.388746mA
+ 0.588ns 0.392518mA
+ 0.59ns 0.396289mA
+ 0.592ns 0.40006mA
+ 0.594ns 0.403832mA
+ 0.596ns 0.407603mA
+ 0.598ns 0.411374mA
+ 0.6ns 0.415146mA
+ 0.602ns 0.418917mA
+ 0.604ns 0.422688mA
+ 0.606ns 0.42646mA
+ 0.608ns 0.430231mA
+ 0.61ns 0.433476mA
+ 0.612ns 0.431992mA
+ 0.614ns 0.430513mA
+ 0.616ns 0.429039mA
+ 0.618ns 0.427571mA
+ 0.62ns 0.426107mA
+ 0.622ns 0.424648mA
+ 0.624ns 0.423194mA
+ 0.626ns 0.421745mA
+ 0.628ns 0.420302mA
+ 0.63ns 0.418863mA
+ 0.632ns 0.417429mA
+ 0.634ns 0.416mA
+ 0.636ns 0.414575mA
+ 0.638ns 0.413156mA
+ 0.64ns 0.411742mA
+ 0.642ns 0.410332mA
+ 0.644ns 0.408927mA
+ 0.646ns 0.407527mA
+ 0.648ns 0.406132mA
+ 0.65ns 0.404742mA
+ 0.652ns 0.403356mA
+ 0.654ns 0.401975mA
+ 0.656ns 0.400599mA
+ 0.658ns 0.399227mA
+ 0.66ns 0.397861mA
+ 0.662ns 0.396499mA
+ 0.664ns 0.395141mA
+ 0.666ns 0.393788mA
+ 0.668ns 0.39244mA
+ 0.67ns 0.391097mA
+ 0.672ns 0.389758mA
+ 0.674ns 0.388423mA
+ 0.676ns 0.387093mA
+ 0.678ns 0.385768mA
+ 0.68ns 0.384447mA
+ 0.682ns 0.383131mA
+ 0.684ns 0.38182mA
+ 0.686ns 0.380512mA
+ 0.688ns 0.37921mA
+ 0.69ns 0.377911mA
+ 0.692ns 0.376618mA
+ 0.694ns 0.375328mA
+ 0.696ns 0.374043mA
+ 0.698ns 0.372763mA
+ 0.7ns 0.371486mA
+ 0.702ns 0.370215mA
+ 0.704ns 0.368947mA
+ 0.706ns 0.367684mA
+ 0.708ns 0.366425mA
+ 0.71ns 0.365171mA
+ 0.712ns 0.36392mA
+ 0.714ns 0.362674mA
+ 0.716ns 0.361433mA
+ 0.718ns 0.360195mA
+ 0.72ns 0.358962mA
+ 0.722ns 0.357733mA
+ 0.724ns 0.356508mA
+ 0.726ns 0.355288mA
+ 0.728ns 0.354071mA
+ 0.73ns 0.352859mA
+ 0.732ns 0.351651mA
+ 0.734ns 0.350447mA
+ 0.736ns 0.349247mA
+ 0.738ns 0.348052mA
+ 0.74ns 0.34686mA
+ 0.742ns 0.345673mA
+ 0.744ns 0.344489mA
+ 0.746ns 0.34331mA
+ 0.748ns 0.342134mA
+ 0.75ns 0.340963mA
+ 0.752ns 0.339796mA
+ 0.754ns 0.338632mA
+ 0.756ns 0.337473mA
+ 0.758ns 0.336317mA
+ 0.76ns 0.335166mA
+ 0.762ns 0.334018mA
+ 0.764ns 0.332875mA
+ 0.766ns 0.331735mA
+ 0.768ns 0.330599mA
+ 0.77ns 0.329467mA
+ 0.772ns 0.328339mA
+ 0.774ns 0.327215mA
+ 0.776ns 0.326095mA
+ 0.778ns 0.324979mA
+ 0.78ns 0.323866mA
+ 0.782ns 0.322757mA
+ 0.784ns 0.321652mA
+ 0.786ns 0.320551mA
+ 0.788ns 0.319453mA
+ 0.79ns 0.31836mA
+ 0.792ns 0.31727mA
+ 0.794ns 0.316183mA
+ 0.796ns 0.315101mA
+ 0.798ns 0.314022mA
+ 0.8ns 0.312947mA
+ 0.802ns 0.311875mA
+ 0.804ns 0.310808mA
+ 0.806ns 0.309743mA
+ 0.808ns 0.308683mA
+ 0.81ns 0.307626mA
+ 0.812ns 0.306573mA
+ 0.814ns 0.305523mA
+ 0.816ns 0.304477mA
+ 0.818ns 0.303435mA
+ 0.82ns 0.302396mA
+ 0.822ns 0.30136mA
+ 0.824ns 0.300329mA
+ 0.826ns 0.2993mA
+ 0.828ns 0.298276mA
+ 0.83ns 0.297254mA
+ 0.832ns 0.296237mA
+ 0.834ns 0.295222mA
+ 0.836ns 0.294212mA
+ 0.838ns 0.293204mA
+ 0.84ns 0.2922mA
+ 0.842ns 0.2912mA
+ 0.844ns 0.290203mA
+ 0.846ns 0.289209mA
+ 0.848ns 0.288219mA
+ 0.85ns 0.287232mA
+ 0.852ns 0.286249mA
+ 0.854ns 0.285269mA
+ 0.856ns 0.284292mA
+ 0.858ns 0.283319mA
+ 0.86ns 0.282349mA
+ 0.862ns 0.281382mA
+ 0.864ns 0.280418mA
+ 0.866ns 0.279458mA
+ 0.868ns 0.278502mA
+ 0.87ns 0.277548mA
+ 0.872ns 0.276598mA
+ 0.874ns 0.275651mA
+ 0.876ns 0.274707mA
+ 0.878ns 0.273766mA
+ 0.88ns 0.272829mA
+ 0.882ns 0.271895mA
+ 0.884ns 0.270964mA
+ 0.886ns 0.270036mA
+ 0.888ns 0.269111mA
+ 0.89ns 0.26819mA
+ 0.892ns 0.267272mA
+ 0.894ns 0.266357mA
+ 0.896ns 0.265445mA
+ 0.898ns 0.264536mA
+ 0.9ns 0.26363mA
+ 0.902ns 0.262727mA
+ 0.904ns 0.261828mA
+ 0.906ns 0.260931mA
+ 0.908ns 0.260038mA
+ 0.91ns 0.259148mA
+ 0.912ns 0.25826mA
+ 0.914ns 0.257376mA
+ 0.916ns 0.256495mA
+ 0.918ns 0.255617mA
+ 0.92ns 0.254741mA
+ 0.922ns 0.253869mA
+ 0.924ns 0.253mA
+ 0.926ns 0.252134mA
+ 0.928ns 0.25127mA
+ 0.93ns 0.25041mA
+ 0.932ns 0.249553mA
+ 0.934ns 0.248698mA
+ 0.936ns 0.247847mA
+ 0.938ns 0.246998mA
+ 0.94ns 0.246152mA
+ 0.942ns 0.24531mA
+ 0.944ns 0.24447mA
+ 0.946ns 0.243633mA
+ 0.948ns 0.242798mA
+ 0.95ns 0.241967mA
+ 0.952ns 0.241139mA
+ 0.954ns 0.240313mA
+ 0.956ns 0.23949mA
+ 0.958ns 0.23867mA
+ 0.96ns 0.237853mA
+ 0.962ns 0.237038mA
+ 0.964ns 0.236227mA
+ 0.966ns 0.235418mA
+ 0.968ns 0.234612mA
+ 0.97ns 0.233809mA
+ 0.972ns 0.233008mA
+ 0.974ns 0.23221mA
+ 0.976ns 0.231415mA
+ 0.978ns 0.230623mA
+ 0.98ns 0.229833mA
+ 0.982ns 0.229046mA
+ 0.984ns 0.228262mA
+ 0.986ns 0.22748mA
+ 0.988ns 0.226701mA
+ 0.99ns 0.225925mA
+ 0.992ns 0.225151mA
+ 0.994ns 0.224381mA
+ 0.996ns 0.223612mA
+ 0.998ns 0.222847mA
+ 1ns 0.222084mA
+ 1.002ns 0.221323mA
+ 1.004ns 0.220565mA
+ 1.006ns 0.21981mA
+ 1.008ns 0.219057mA
+ 1.01ns 0.218307mA
+ 1.012ns 0.21756mA
+ 1.014ns 0.216815mA
+ 1.016ns 0.216073mA
+ 1.018ns 0.215333mA
+ 1.02ns 0.214595mA
+ 1.022ns 0.213861mA
+ 1.024ns 0.213128mA
+ 1.026ns 0.212399mA
+ 1.028ns 0.211671mA
+ 1.03ns 0.210946mA
+ 1.032ns 0.210224mA
+ 1.034ns 0.209504mA
+ 1.036ns 0.208787mA
+ 1.038ns 0.208072mA
+ 1.04ns 0.20736mA
+ 1.042ns 0.20665mA
+ 1.044ns 0.205942mA
+ 1.046ns 0.205237mA
+ 1.048ns 0.204534mA
+ 1.05ns 0.203834mA
+ 1.052ns 0.203136mA
+ 1.054ns 0.20244mA
+ 1.056ns 0.201747mA
+ 1.058ns 0.201056mA
+ 1.06ns 0.200368mA
+ 1.062ns 0.199682mA
+ 1.064ns 0.198998mA
+ 1.066ns 0.198316mA
+ 1.068ns 0.197637mA
+ 1.07ns 0.196961mA
+ 1.072ns 0.196286mA
+ 1.074ns 0.195614mA
+ 1.076ns 0.194944mA
+ 1.078ns 0.194277mA
+ 1.08ns 0.193612mA
+ 1.082ns 0.192949mA
+ 1.084ns 0.192288mA
+ 1.086ns 0.191629mA
+ 1.088ns 0.190973mA
+ 1.09ns 0.190319mA
+ 1.092ns 0.189668mA
+ 1.094ns 0.189018mA
+ 1.096ns 0.188371mA
+ 1.098ns 0.187726mA
+ 1.1ns 0.187083mA
+ 1.102ns 0.186443mA
+ 1.104ns 0.185804mA
+ 1.106ns 0.185168mA
+ 1.108ns 0.184534mA
+ 1.11ns 0.183902mA
+ 1.112ns 0.183272mA
+ 1.114ns 0.182645mA
+ 1.116ns 0.182019mA
+ 1.118ns 0.181396mA
+ 1.12ns 0.180775mA
+ 1.122ns 0.180156mA
+ 1.124ns 0.179539mA
+ 1.126ns 0.178924mA
+ 1.128ns 0.178311mA
+ 1.13ns 0mA
+ 5.378ns 0mA
+ 5.38ns 0.000301665mA
+ 5.382ns 0.0040727mA
+ 5.384ns 0.00784464mA
+ 5.386ns 0.0116157mA
+ 5.388ns 0.0153867mA
+ 5.39ns 0.0191578mA
+ 5.392ns 0.0229297mA
+ 5.394ns 0.0267007mA
+ 5.396ns 0.0304718mA
+ 5.398ns 0.0342437mA
+ 5.4ns 0.0380148mA
+ 5.402ns 0.0417858mA
+ 5.404ns 0.0455577mA
+ 5.406ns 0.0493288mA
+ 5.408ns 0.0530998mA
+ 5.41ns 0.0568709mA
+ 5.412ns 0.0606428mA
+ 5.414ns 0.0644138mA
+ 5.416ns 0.0681849mA
+ 5.418ns 0.0719568mA
+ 5.42ns 0.0757278mA
+ 5.422ns 0.0794989mA
+ 5.424ns 0.0832708mA
+ 5.426ns 0.0870419mA
+ 5.428ns 0.0908129mA
+ 5.43ns 0.0945848mA
+ 5.432ns 0.0983559mA
+ 5.434ns 0.102127mA
+ 5.436ns 0.105898mA
+ 5.438ns 0.10967mA
+ 5.44ns 0.113441mA
+ 5.442ns 0.117212mA
+ 5.444ns 0.120984mA
+ 5.446ns 0.124755mA
+ 5.448ns 0.128526mA
+ 5.45ns 0.132298mA
+ 5.452ns 0.136069mA
+ 5.454ns 0.13984mA
+ 5.456ns 0.143611mA
+ 5.458ns 0.147383mA
+ 5.46ns 0.151154mA
+ 5.462ns 0.154925mA
+ 5.464ns 0.158697mA
+ 5.466ns 0.162468mA
+ 5.468ns 0.166239mA
+ 5.47ns 0.170011mA
+ 5.472ns 0.173782mA
+ 5.474ns 0.177553mA
+ 5.476ns 0.181324mA
+ 5.478ns 0.185096mA
+ 5.48ns 0.188867mA
+ 5.482ns 0.192638mA
+ 5.484ns 0.19641mA
+ 5.486ns 0.200181mA
+ 5.488ns 0.203952mA
+ 5.49ns 0.207724mA
+ 5.492ns 0.211495mA
+ 5.494ns 0.215266mA
+ 5.496ns 0.219038mA
+ 5.498ns 0.222809mA
+ 5.5ns 0.22658mA
+ 5.502ns 0.230351mA
+ 5.504ns 0.234123mA
+ 5.506ns 0.237894mA
+ 5.508ns 0.241665mA
+ 5.51ns 0.245437mA
+ 5.512ns 0.249208mA
+ 5.514ns 0.252979mA
+ 5.516ns 0.256751mA
+ 5.518ns 0.260522mA
+ 5.52ns 0.264293mA
+ 5.522ns 0.268064mA
+ 5.524ns 0.271836mA
+ 5.526ns 0.275607mA
+ 5.528ns 0.279378mA
+ 5.53ns 0.28315mA
+ 5.532ns 0.286921mA
+ 5.534ns 0.290692mA
+ 5.536ns 0.294464mA
+ 5.538ns 0.298235mA
+ 5.54ns 0.302006mA
+ 5.542ns 0.305778mA
+ 5.544ns 0.309549mA
+ 5.546ns 0.31332mA
+ 5.548ns 0.317091mA
+ 5.55ns 0.320863mA
+ 5.552ns 0.324634mA
+ 5.554ns 0.328405mA
+ 5.556ns 0.332177mA
+ 5.558ns 0.335948mA
+ 5.56ns 0.339719mA
+ 5.562ns 0.343491mA
+ 5.564ns 0.347262mA
+ 5.566ns 0.351034mA
+ 5.568ns 0.354805mA
+ 5.57ns 0.358576mA
+ 5.572ns 0.362348mA
+ 5.574ns 0.366119mA
+ 5.576ns 0.36989mA
+ 5.578ns 0.373662mA
+ 5.58ns 0.377433mA
+ 5.582ns 0.381205mA
+ 5.584ns 0.384976mA
+ 5.586ns 0.388747mA
+ 5.588ns 0.392519mA
+ 5.59ns 0.39629mA
+ 5.592ns 0.400061mA
+ 5.594ns 0.403832mA
+ 5.596ns 0.407604mA
+ 5.598ns 0.411375mA
+ 5.6ns 0.415146mA
+ 5.602ns 0.418918mA
+ 5.604ns 0.422689mA
+ 5.606ns 0.42646mA
+ 5.608ns 0.430232mA
+ 5.61ns 0.433476mA
+ 5.612ns 0.431992mA
+ 5.614ns 0.430513mA
+ 5.616ns 0.429039mA
+ 5.618ns 0.427571mA
+ 5.62ns 0.426107mA
+ 5.622ns 0.424648mA
+ 5.624ns 0.423194mA
+ 5.626ns 0.421745mA
+ 5.628ns 0.420301mA
+ 5.63ns 0.418863mA
+ 5.632ns 0.417429mA
+ 5.634ns 0.415999mA
+ 5.636ns 0.414575mA
+ 5.638ns 0.413156mA
+ 5.64ns 0.411742mA
+ 5.642ns 0.410332mA
+ 5.644ns 0.408927mA
+ 5.646ns 0.407527mA
+ 5.648ns 0.406132mA
+ 5.65ns 0.404742mA
+ 5.652ns 0.403356mA
+ 5.654ns 0.401975mA
+ 5.656ns 0.400599mA
+ 5.658ns 0.399227mA
+ 5.66ns 0.397861mA
+ 5.662ns 0.396498mA
+ 5.664ns 0.395141mA
+ 5.666ns 0.393788mA
+ 5.668ns 0.39244mA
+ 5.67ns 0.391096mA
+ 5.672ns 0.389758mA
+ 5.674ns 0.388423mA
+ 5.676ns 0.387093mA
+ 5.678ns 0.385768mA
+ 5.68ns 0.384447mA
+ 5.682ns 0.383131mA
+ 5.684ns 0.381819mA
+ 5.686ns 0.380512mA
+ 5.688ns 0.379209mA
+ 5.69ns 0.377911mA
+ 5.692ns 0.376618mA
+ 5.694ns 0.375328mA
+ 5.696ns 0.374043mA
+ 5.698ns 0.372763mA
+ 5.7ns 0.371486mA
+ 5.702ns 0.370214mA
+ 5.704ns 0.368947mA
+ 5.706ns 0.367684mA
+ 5.708ns 0.366425mA
+ 5.71ns 0.365171mA
+ 5.712ns 0.36392mA
+ 5.714ns 0.362674mA
+ 5.716ns 0.361433mA
+ 5.718ns 0.360195mA
+ 5.72ns 0.358962mA
+ 5.722ns 0.357733mA
+ 5.724ns 0.356508mA
+ 5.726ns 0.355288mA
+ 5.728ns 0.354071mA
+ 5.73ns 0.352859mA
+ 5.732ns 0.351651mA
+ 5.734ns 0.350447mA
+ 5.736ns 0.349247mA
+ 5.738ns 0.348052mA
+ 5.74ns 0.34686mA
+ 5.742ns 0.345672mA
+ 5.744ns 0.344489mA
+ 5.746ns 0.343309mA
+ 5.748ns 0.342134mA
+ 5.75ns 0.340963mA
+ 5.752ns 0.339796mA
+ 5.754ns 0.338632mA
+ 5.756ns 0.337473mA
+ 5.758ns 0.336317mA
+ 5.76ns 0.335166mA
+ 5.762ns 0.334018mA
+ 5.764ns 0.332875mA
+ 5.766ns 0.331735mA
+ 5.768ns 0.330599mA
+ 5.77ns 0.329467mA
+ 5.772ns 0.328339mA
+ 5.774ns 0.327215mA
+ 5.776ns 0.326095mA
+ 5.778ns 0.324979mA
+ 5.78ns 0.323866mA
+ 5.782ns 0.322757mA
+ 5.784ns 0.321652mA
+ 5.786ns 0.320551mA
+ 5.788ns 0.319453mA
+ 5.79ns 0.31836mA
+ 5.792ns 0.317269mA
+ 5.794ns 0.316183mA
+ 5.796ns 0.315101mA
+ 5.798ns 0.314022mA
+ 5.8ns 0.312947mA
+ 5.802ns 0.311875mA
+ 5.804ns 0.310808mA
+ 5.806ns 0.309743mA
+ 5.808ns 0.308683mA
+ 5.81ns 0.307626mA
+ 5.812ns 0.306573mA
+ 5.814ns 0.305523mA
+ 5.816ns 0.304477mA
+ 5.818ns 0.303434mA
+ 5.82ns 0.302396mA
+ 5.822ns 0.30136mA
+ 5.824ns 0.300329mA
+ 5.826ns 0.2993mA
+ 5.828ns 0.298276mA
+ 5.83ns 0.297254mA
+ 5.832ns 0.296236mA
+ 5.834ns 0.295222mA
+ 5.836ns 0.294212mA
+ 5.838ns 0.293204mA
+ 5.84ns 0.2922mA
+ 5.842ns 0.2912mA
+ 5.844ns 0.290203mA
+ 5.846ns 0.289209mA
+ 5.848ns 0.288219mA
+ 5.85ns 0.287232mA
+ 5.852ns 0.286249mA
+ 5.854ns 0.285269mA
+ 5.856ns 0.284292mA
+ 5.858ns 0.283318mA
+ 5.86ns 0.282348mA
+ 5.862ns 0.281382mA
+ 5.864ns 0.280418mA
+ 5.866ns 0.279458mA
+ 5.868ns 0.278501mA
+ 5.87ns 0.277548mA
+ 5.872ns 0.276597mA
+ 5.874ns 0.275651mA
+ 5.876ns 0.274707mA
+ 5.878ns 0.273766mA
+ 5.88ns 0.272829mA
+ 5.882ns 0.271895mA
+ 5.884ns 0.270964mA
+ 5.886ns 0.270036mA
+ 5.888ns 0.269111mA
+ 5.89ns 0.26819mA
+ 5.892ns 0.267272mA
+ 5.894ns 0.266357mA
+ 5.896ns 0.265445mA
+ 5.898ns 0.264536mA
+ 5.9ns 0.26363mA
+ 5.902ns 0.262727mA
+ 5.904ns 0.261828mA
+ 5.906ns 0.260931mA
+ 5.908ns 0.260038mA
+ 5.91ns 0.259147mA
+ 5.912ns 0.25826mA
+ 5.914ns 0.257376mA
+ 5.916ns 0.256495mA
+ 5.918ns 0.255617mA
+ 5.92ns 0.254741mA
+ 5.922ns 0.253869mA
+ 5.924ns 0.253mA
+ 5.926ns 0.252134mA
+ 5.928ns 0.25127mA
+ 5.93ns 0.25041mA
+ 5.932ns 0.249553mA
+ 5.934ns 0.248698mA
+ 5.936ns 0.247847mA
+ 5.938ns 0.246998mA
+ 5.94ns 0.246152mA
+ 5.942ns 0.24531mA
+ 5.944ns 0.244469mA
+ 5.946ns 0.243632mA
+ 5.948ns 0.242798mA
+ 5.95ns 0.241967mA
+ 5.952ns 0.241138mA
+ 5.954ns 0.240313mA
+ 5.956ns 0.23949mA
+ 5.958ns 0.23867mA
+ 5.96ns 0.237853mA
+ 5.962ns 0.237038mA
+ 5.964ns 0.236227mA
+ 5.966ns 0.235418mA
+ 5.968ns 0.234612mA
+ 5.97ns 0.233808mA
+ 5.972ns 0.233008mA
+ 5.974ns 0.23221mA
+ 5.976ns 0.231415mA
+ 5.978ns 0.230623mA
+ 5.98ns 0.229833mA
+ 5.982ns 0.229046mA
+ 5.984ns 0.228262mA
+ 5.986ns 0.22748mA
+ 5.988ns 0.226701mA
+ 5.99ns 0.225925mA
+ 5.992ns 0.225151mA
+ 5.994ns 0.224381mA
+ 5.996ns 0.223612mA
+ 5.998ns 0.222847mA
+ 6ns 0.222084mA
+ 6.002ns 0.221323mA
+ 6.004ns 0.220565mA
+ 6.006ns 0.21981mA
+ 6.008ns 0.219057mA
+ 6.01ns 0.218307mA
+ 6.012ns 0.21756mA
+ 6.014ns 0.216815mA
+ 6.016ns 0.216073mA
+ 6.018ns 0.215333mA
+ 6.02ns 0.214595mA
+ 6.022ns 0.213861mA
+ 6.024ns 0.213128mA
+ 6.026ns 0.212398mA
+ 6.028ns 0.211671mA
+ 6.03ns 0.210946mA
+ 6.032ns 0.210224mA
+ 6.034ns 0.209504mA
+ 6.036ns 0.208787mA
+ 6.038ns 0.208072mA
+ 6.04ns 0.20736mA
+ 6.042ns 0.20665mA
+ 6.044ns 0.205942mA
+ 6.046ns 0.205237mA
+ 6.048ns 0.204534mA
+ 6.05ns 0.203834mA
+ 6.052ns 0.203136mA
+ 6.054ns 0.20244mA
+ 6.056ns 0.201747mA
+ 6.058ns 0.201056mA
+ 6.06ns 0.200368mA
+ 6.062ns 0.199682mA
+ 6.064ns 0.198998mA
+ 6.066ns 0.198316mA
+ 6.068ns 0.197637mA
+ 6.07ns 0.196961mA
+ 6.072ns 0.196286mA
+ 6.074ns 0.195614mA
+ 6.076ns 0.194944mA
+ 6.078ns 0.194277mA
+ 6.08ns 0.193612mA
+ 6.082ns 0.192949mA
+ 6.084ns 0.192288mA
+ 6.086ns 0.191629mA
+ 6.088ns 0.190973mA
+ 6.09ns 0.190319mA
+ 6.092ns 0.189668mA
+ 6.094ns 0.189018mA
+ 6.096ns 0.188371mA
+ 6.098ns 0.187726mA
+ 6.1ns 0.187083mA
+ 6.102ns 0.186442mA
+ 6.104ns 0.185804mA
+ 6.106ns 0.185168mA
+ 6.108ns 0.184534mA
+ 6.11ns 0.183902mA
+ 6.112ns 0.183272mA
+ 6.114ns 0.182645mA
+ 6.116ns 0.182019mA
+ 6.118ns 0.181396mA
+ 6.12ns 0.180775mA
+ 6.122ns 0.180156mA
+ 6.124ns 0.179539mA
+ 6.126ns 0.178924mA
+ 6.128ns 0.178312mA
+ 6.13ns 0mA
I36 47 0 PWL 0 0
+ 5.136ns 0mA
+ 5.138ns 0.000697657mA
+ 5.14ns 0.00540711mA
+ 5.142ns 0.0101177mA
+ 5.144ns 0.0148272mA
+ 5.146ns 0.0195366mA
+ 5.148ns 0.0242472mA
+ 5.15ns 0.0289566mA
+ 5.152ns 0.0336661mA
+ 5.154ns 0.0383767mA
+ 5.156ns 0.0430861mA
+ 5.158ns 0.0477956mA
+ 5.16ns 0.0525051mA
+ 5.162ns 0.0572156mA
+ 5.164ns 0.0619251mA
+ 5.166ns 0.0666346mA
+ 5.168ns 0.0713451mA
+ 5.17ns 0.0760546mA
+ 5.172ns 0.0807641mA
+ 5.174ns 0.0854746mA
+ 5.176ns 0.0901841mA
+ 5.178ns 0.0948936mA
+ 5.18ns 0.099603mA
+ 5.182ns 0.104314mA
+ 5.184ns 0.105623mA
+ 5.186ns 0.101927mA
+ 5.188ns 0.098359mA
+ 5.19ns 0.0949171mA
+ 5.192ns 0.0915955mA
+ 5.194ns 0.0883894mA
+ 5.196ns 0.0852963mA
+ 5.198ns 0.0823113mA
+ 5.2ns 0.0794301mA
+ 5.202ns 0.0766504mA
+ 5.204ns 0.0739679mA
+ 5.206ns 0.0713793mA
+ 5.208ns 0.0688807mA
+ 5.21ns 0.0664701mA
+ 5.212ns 0.0641438mA
+ 5.214ns 0.0618984mA
+ 5.216ns 0.0597321mA
+ 5.218ns 0.0576416mA
+ 5.22ns 0.0556238mA
+ 5.222ns 0.053677mA
+ 5.224ns 0.0517984mA
+ 5.226ns 0.0499854mA
+ 5.228ns 0.0482356mA
+ 5.23ns 0.0465473mA
+ 5.232ns 0.0449182mA
+ 5.234ns 0.0433456mA
+ 5.236ns 0.0418285mA
+ 5.238ns 0.0403645mA
+ 5.24ns 0.0389513mA
+ 5.242ns 0.0375879mA
+ 5.244ns 0.0362723mA
+ 5.246ns 0mA
I37 49 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00642434mA
+ 0.156ns 0.0170289mA
+ 0.158ns 0.0276336mA
+ 0.16ns 0.0382382mA
+ 0.162ns 0.0488428mA
+ 0.164ns 0.0594474mA
+ 0.166ns 0.0700521mA
+ 0.168ns 0.0806568mA
+ 0.17ns 0.0912613mA
+ 0.172ns 0.101866mA
+ 0.174ns 0.112471mA
+ 0.176ns 0.123075mA
+ 0.178ns 0.120012mA
+ 0.18ns 0.106975mA
+ 0.182ns 0.0953545mA
+ 0.184ns 0.0849958mA
+ 0.186ns 0.0757622mA
+ 0.188ns 0.0675314mA
+ 0.19ns 0.0601946mA
+ 0.192ns 0.0536548mA
+ 0.194ns 0.0478253mA
+ 0.196ns 0.042629mA
+ 0.198ns 0.0379972mA
+ 0.2ns 0.0338686mA
+ 0.202ns 0mA
I38 51 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00345438mA
+ 0.156ns 0.0129657mA
+ 0.158ns 0.0224771mA
+ 0.16ns 0.0319884mA
+ 0.162ns 0.0414997mA
+ 0.164ns 0.0510111mA
+ 0.166ns 0.0605225mA
+ 0.168ns 0.0700339mA
+ 0.17ns 0.0795452mA
+ 0.172ns 0.0890565mA
+ 0.174ns 0.0985679mA
+ 0.176ns 0.108079mA
+ 0.178ns 0.117591mA
+ 0.18ns 0.127102mA
+ 0.182ns 0.136613mA
+ 0.184ns 0.142733mA
+ 0.186ns 0.130302mA
+ 0.188ns 0.118953mA
+ 0.19ns 0.108592mA
+ 0.192ns 0.0991331mA
+ 0.194ns 0.0904981mA
+ 0.196ns 0.0826151mA
+ 0.198ns 0.0754187mA
+ 0.2ns 0.068849mA
+ 0.202ns 0.0628514mA
+ 0.204ns 0.0573761mA
+ 0.206ns 0.0523778mA
+ 0.208ns 0.0478148mA
+ 0.21ns 0.0436492mA
+ 0.212ns 0.0398464mA
+ 0.214ns 0.0363748mA
+ 0.216ns 0mA
I39 52 0 PWL 0 0
+ 7.652ns 0mA
+ 7.654ns 0.00640346mA
+ 7.656ns 0.0171722mA
+ 7.658ns 0.0279409mA
+ 7.66ns 0.0387097mA
+ 7.662ns 0.049481mA
+ 7.664ns 0.0602497mA
+ 7.666ns 0.0710184mA
+ 7.668ns 0.0817897mA
+ 7.67ns 0.0925585mA
+ 7.672ns 0.103327mA
+ 7.674ns 0.114099mA
+ 7.676ns 0.124867mA
+ 7.678ns 0.113198mA
+ 7.68ns 0.100541mA
+ 7.682ns 0.0893021mA
+ 7.684ns 0.0793191mA
+ 7.686ns 0.0704518mA
+ 7.688ns 0.0625739mA
+ 7.69ns 0.0555782mA
+ 7.692ns 0.0493644mA
+ 7.694ns 0.043844mA
+ 7.696ns 0.0389419mA
+ 7.698ns 0.0345878mA
+ 7.7ns 0mA
I40 53 0 PWL 0 0
+ 3.016ns 0mA
+ 3.018ns 0.00615717mA
+ 3.02ns 0.0139078mA
+ 3.022ns 0.0216594mA
+ 3.024ns 0.0294109mA
+ 3.026ns 0.0371616mA
+ 3.028ns 0.0449131mA
+ 3.03ns 0.0526637mA
+ 3.032ns 0.0604153mA
+ 3.034ns 0.0681669mA
+ 3.036ns 0.0759175mA
+ 3.038ns 0.0836691mA
+ 3.04ns 0.0914197mA
+ 3.042ns 0.0991712mA
+ 3.044ns 0.106923mA
+ 3.046ns 0.114673mA
+ 3.048ns 0.122425mA
+ 3.05ns 0.130176mA
+ 3.052ns 0.137927mA
+ 3.054ns 0.145679mA
+ 3.056ns 0.153429mA
+ 3.058ns 0.161181mA
+ 3.06ns 0.168932mA
+ 3.062ns 0.176683mA
+ 3.064ns 0.184435mA
+ 3.066ns 0.192185mA
+ 3.068ns 0.199937mA
+ 3.07ns 0.207687mA
+ 3.072ns 0.215439mA
+ 3.074ns 0.223191mA
+ 3.076ns 0.230941mA
+ 3.078ns 0.238693mA
+ 3.08ns 0.246444mA
+ 3.082ns 0.254195mA
+ 3.084ns 0.261947mA
+ 3.086ns 0.269697mA
+ 3.088ns 0.277449mA
+ 3.09ns 0.2852mA
+ 3.092ns 0.292951mA
+ 3.094ns 0.300703mA
+ 3.096ns 0.308453mA
+ 3.098ns 0.316205mA
+ 3.1ns 0.323956mA
+ 3.102ns 0.331707mA
+ 3.104ns 0.339458mA
+ 3.106ns 0.347209mA
+ 3.108ns 0.354961mA
+ 3.11ns 0.362712mA
+ 3.112ns 0.370463mA
+ 3.114ns 0.378214mA
+ 3.116ns 0.385965mA
+ 3.118ns 0.393717mA
+ 3.12ns 0.401468mA
+ 3.122ns 0.409219mA
+ 3.124ns 0.41697mA
+ 3.126ns 0.424722mA
+ 3.128ns 0.432472mA
+ 3.13ns 0.440224mA
+ 3.132ns 0.447975mA
+ 3.134ns 0.455726mA
+ 3.136ns 0.463478mA
+ 3.138ns 0.471228mA
+ 3.14ns 0.47898mA
+ 3.142ns 0.486731mA
+ 3.144ns 0.494482mA
+ 3.146ns 0.502234mA
+ 3.148ns 0.509984mA
+ 3.15ns 0.517736mA
+ 3.152ns 0.525487mA
+ 3.154ns 0.533238mA
+ 3.156ns 0.54099mA
+ 3.158ns 0.543191mA
+ 3.16ns 0.540861mA
+ 3.162ns 0.538541mA
+ 3.164ns 0.536231mA
+ 3.166ns 0.533931mA
+ 3.168ns 0.531641mA
+ 3.17ns 0.529361mA
+ 3.172ns 0.52709mA
+ 3.174ns 0.524829mA
+ 3.176ns 0.522578mA
+ 3.178ns 0.520337mA
+ 3.18ns 0.518105mA
+ 3.182ns 0.515882mA
+ 3.184ns 0.51367mA
+ 3.186ns 0.511466mA
+ 3.188ns 0.509273mA
+ 3.19ns 0.507088mA
+ 3.192ns 0.504913mA
+ 3.194ns 0.502747mA
+ 3.196ns 0.500591mA
+ 3.198ns 0.498444mA
+ 3.2ns 0.496306mA
+ 3.202ns 0.494177mA
+ 3.204ns 0.492057mA
+ 3.206ns 0.489947mA
+ 3.208ns 0.487845mA
+ 3.21ns 0.485752mA
+ 3.212ns 0.483669mA
+ 3.214ns 0.481594mA
+ 3.216ns 0.479528mA
+ 3.218ns 0.477472mA
+ 3.22ns 0.475424mA
+ 3.222ns 0.473384mA
+ 3.224ns 0.471354mA
+ 3.226ns 0.469332mA
+ 3.228ns 0.467319mA
+ 3.23ns 0.465314mA
+ 3.232ns 0.463318mA
+ 3.234ns 0.461331mA
+ 3.236ns 0.459352mA
+ 3.238ns 0.457382mA
+ 3.24ns 0.45542mA
+ 3.242ns 0.453466mA
+ 3.244ns 0.451521mA
+ 3.246ns 0.449584mA
+ 3.248ns 0.447656mA
+ 3.25ns 0.445736mA
+ 3.252ns 0.443824mA
+ 3.254ns 0.44192mA
+ 3.256ns 0.440024mA
+ 3.258ns 0.438137mA
+ 3.26ns 0.436258mA
+ 3.262ns 0.434386mA
+ 3.264ns 0.432523mA
+ 3.266ns 0.430668mA
+ 3.268ns 0.42882mA
+ 3.27ns 0.426981mA
+ 3.272ns 0.425149mA
+ 3.274ns 0.423326mA
+ 3.276ns 0.42151mA
+ 3.278ns 0.419702mA
+ 3.28ns 0.417901mA
+ 3.282ns 0.416109mA
+ 3.284ns 0.414324mA
+ 3.286ns 0.412547mA
+ 3.288ns 0.410777mA
+ 3.29ns 0.409015mA
+ 3.292ns 0.40726mA
+ 3.294ns 0.405513mA
+ 3.296ns 0.403774mA
+ 3.298ns 0.402042mA
+ 3.3ns 0.400317mA
+ 3.302ns 0.3986mA
+ 3.304ns 0.39689mA
+ 3.306ns 0.395188mA
+ 3.308ns 0.393493mA
+ 3.31ns 0.391805mA
+ 3.312ns 0.390124mA
+ 3.314ns 0.388451mA
+ 3.316ns 0.386784mA
+ 3.318ns 0.385125mA
+ 3.32ns 0.383473mA
+ 3.322ns 0.381828mA
+ 3.324ns 0.38019mA
+ 3.326ns 0.378559mA
+ 3.328ns 0.376935mA
+ 3.33ns 0.375318mA
+ 3.332ns 0.373709mA
+ 3.334ns 0.372105mA
+ 3.336ns 0.370509mA
+ 3.338ns 0.36892mA
+ 3.34ns 0.367337mA
+ 3.342ns 0.365762mA
+ 3.344ns 0.364193mA
+ 3.346ns 0.36263mA
+ 3.348ns 0.361075mA
+ 3.35ns 0.359526mA
+ 3.352ns 0.357984mA
+ 3.354ns 0.356448mA
+ 3.356ns 0.354919mA
+ 3.358ns 0.353397mA
+ 3.36ns 0.35188mA
+ 3.362ns 0.350371mA
+ 3.364ns 0.348868mA
+ 3.366ns 0.347371mA
+ 3.368ns 0.345881mA
+ 3.37ns 0.344398mA
+ 3.372ns 0.34292mA
+ 3.374ns 0.341449mA
+ 3.376ns 0.339984mA
+ 3.378ns 0.338526mA
+ 3.38ns 0.337074mA
+ 3.382ns 0.335628mA
+ 3.384ns 0.334188mA
+ 3.386ns 0.332754mA
+ 3.388ns 0.331327mA
+ 3.39ns 0.329906mA
+ 3.392ns 0.328491mA
+ 3.394ns 0.327081mA
+ 3.396ns 0.325678mA
+ 3.398ns 0.324281mA
+ 3.4ns 0.32289mA
+ 3.402ns 0.321505mA
+ 3.404ns 0.320126mA
+ 3.406ns 0.318752mA
+ 3.408ns 0.317385mA
+ 3.41ns 0.316024mA
+ 3.412ns 0.314668mA
+ 3.414ns 0.313318mA
+ 3.416ns 0.311974mA
+ 3.418ns 0.310636mA
+ 3.42ns 0.309303mA
+ 3.422ns 0.307976mA
+ 3.424ns 0.306655mA
+ 3.426ns 0.305339mA
+ 3.428ns 0.30403mA
+ 3.43ns 0.302725mA
+ 3.432ns 0.301427mA
+ 3.434ns 0.300134mA
+ 3.436ns 0.298846mA
+ 3.438ns 0.297564mA
+ 3.44ns 0.296288mA
+ 3.442ns 0.295017mA
+ 3.444ns 0.293751mA
+ 3.446ns 0.292491mA
+ 3.448ns 0.291236mA
+ 3.45ns 0.289987mA
+ 3.452ns 0.288743mA
+ 3.454ns 0.287504mA
+ 3.456ns 0.286271mA
+ 3.458ns 0.285042mA
+ 3.46ns 0.28382mA
+ 3.462ns 0.282602mA
+ 3.464ns 0.28139mA
+ 3.466ns 0.280183mA
+ 3.468ns 0.278981mA
+ 3.47ns 0.277784mA
+ 3.472ns 0.276592mA
+ 3.474ns 0.275406mA
+ 3.476ns 0.274224mA
+ 3.478ns 0.273048mA
+ 3.48ns 0.271876mA
+ 3.482ns 0.27071mA
+ 3.484ns 0.269549mA
+ 3.486ns 0.268392mA
+ 3.488ns 0.267241mA
+ 3.49ns 0.266095mA
+ 3.492ns 0.264953mA
+ 3.494ns 0.263816mA
+ 3.496ns 0.262684mA
+ 3.498ns 0.261558mA
+ 3.5ns 0.260436mA
+ 3.502ns 0.259318mA
+ 3.504ns 0.258206mA
+ 3.506ns 0.257098mA
+ 3.508ns 0.255995mA
+ 3.51ns 0.254897mA
+ 3.512ns 0.253803mA
+ 3.514ns 0.252714mA
+ 3.516ns 0.25163mA
+ 3.518ns 0.250551mA
+ 3.52ns 0.249476mA
+ 3.522ns 0.248406mA
+ 3.524ns 0.24734mA
+ 3.526ns 0.246279mA
+ 3.528ns 0.245222mA
+ 3.53ns 0.24417mA
+ 3.532ns 0.243123mA
+ 3.534ns 0.24208mA
+ 3.536ns 0.241041mA
+ 3.538ns 0.240007mA
+ 3.54ns 0.238978mA
+ 3.542ns 0.237952mA
+ 3.544ns 0.236931mA
+ 3.546ns 0.235915mA
+ 3.548ns 0.234903mA
+ 3.55ns 0mA
+ 8.016ns 0mA
+ 8.018ns 0.00615717mA
+ 8.02ns 0.0139115mA
+ 8.022ns 0.0216621mA
+ 8.024ns 0.0294128mA
+ 8.026ns 0.0371634mA
+ 8.028ns 0.044914mA
+ 8.03ns 0.0526647mA
+ 8.032ns 0.0604153mA
+ 8.034ns 0.0681696mA
+ 8.036ns 0.0759203mA
+ 8.038ns 0.0836709mA
+ 8.04ns 0.0914215mA
+ 8.042ns 0.0991722mA
+ 8.044ns 0.106923mA
+ 8.046ns 0.114673mA
+ 8.048ns 0.122428mA
+ 8.05ns 0.130178mA
+ 8.052ns 0.137929mA
+ 8.054ns 0.14568mA
+ 8.056ns 0.15343mA
+ 8.058ns 0.161181mA
+ 8.06ns 0.168935mA
+ 8.062ns 0.176686mA
+ 8.064ns 0.184437mA
+ 8.066ns 0.192187mA
+ 8.068ns 0.199938mA
+ 8.07ns 0.207688mA
+ 8.072ns 0.215439mA
+ 8.074ns 0.223193mA
+ 8.076ns 0.230944mA
+ 8.078ns 0.238695mA
+ 8.08ns 0.246445mA
+ 8.082ns 0.254196mA
+ 8.084ns 0.261947mA
+ 8.086ns 0.269701mA
+ 8.088ns 0.277452mA
+ 8.09ns 0.285202mA
+ 8.092ns 0.292953mA
+ 8.094ns 0.300703mA
+ 8.096ns 0.308454mA
+ 8.098ns 0.316205mA
+ 8.1ns 0.323959mA
+ 8.102ns 0.33171mA
+ 8.104ns 0.33946mA
+ 8.106ns 0.347211mA
+ 8.108ns 0.354962mA
+ 8.11ns 0.362712mA
+ 8.112ns 0.370467mA
+ 8.114ns 0.378217mA
+ 8.116ns 0.385968mA
+ 8.118ns 0.393718mA
+ 8.12ns 0.401469mA
+ 8.122ns 0.40922mA
+ 8.124ns 0.41697mA
+ 8.126ns 0.424725mA
+ 8.128ns 0.432475mA
+ 8.13ns 0.440226mA
+ 8.132ns 0.447977mA
+ 8.134ns 0.455727mA
+ 8.136ns 0.463478mA
+ 8.138ns 0.471228mA
+ 8.14ns 0.478983mA
+ 8.142ns 0.486733mA
+ 8.144ns 0.494484mA
+ 8.146ns 0.502235mA
+ 8.148ns 0.509985mA
+ 8.15ns 0.517736mA
+ 8.152ns 0.52549mA
+ 8.154ns 0.533241mA
+ 8.156ns 0.540992mA
+ 8.158ns 0.543191mA
+ 8.16ns 0.540861mA
+ 8.162ns 0.538541mA
+ 8.164ns 0.536231mA
+ 8.166ns 0.53393mA
+ 8.168ns 0.53164mA
+ 8.17ns 0.52936mA
+ 8.172ns 0.52709mA
+ 8.174ns 0.524829mA
+ 8.176ns 0.522578mA
+ 8.178ns 0.520336mA
+ 8.18ns 0.518104mA
+ 8.182ns 0.515882mA
+ 8.184ns 0.513669mA
+ 8.186ns 0.511466mA
+ 8.188ns 0.509272mA
+ 8.19ns 0.507088mA
+ 8.192ns 0.504912mA
+ 8.194ns 0.502747mA
+ 8.196ns 0.50059mA
+ 8.198ns 0.498443mA
+ 8.2ns 0.496305mA
+ 8.202ns 0.494177mA
+ 8.204ns 0.492056mA
+ 8.206ns 0.489946mA
+ 8.208ns 0.487844mA
+ 8.21ns 0.485752mA
+ 8.212ns 0.483669mA
+ 8.214ns 0.481594mA
+ 8.216ns 0.479528mA
+ 8.218ns 0.477471mA
+ 8.22ns 0.475423mA
+ 8.222ns 0.473384mA
+ 8.224ns 0.471353mA
+ 8.226ns 0.469332mA
+ 8.228ns 0.467319mA
+ 8.23ns 0.465314mA
+ 8.232ns 0.463318mA
+ 8.234ns 0.46133mA
+ 8.236ns 0.459352mA
+ 8.238ns 0.457381mA
+ 8.24ns 0.45542mA
+ 8.242ns 0.453466mA
+ 8.244ns 0.45152mA
+ 8.246ns 0.449584mA
+ 8.248ns 0.447655mA
+ 8.25ns 0.445735mA
+ 8.252ns 0.443824mA
+ 8.254ns 0.44192mA
+ 8.256ns 0.440024mA
+ 8.258ns 0.438136mA
+ 8.26ns 0.436257mA
+ 8.262ns 0.434386mA
+ 8.264ns 0.432523mA
+ 8.266ns 0.430667mA
+ 8.268ns 0.42882mA
+ 8.27ns 0.42698mA
+ 8.272ns 0.425149mA
+ 8.274ns 0.423325mA
+ 8.276ns 0.421509mA
+ 8.278ns 0.419701mA
+ 8.28ns 0.417901mA
+ 8.282ns 0.416109mA
+ 8.284ns 0.414323mA
+ 8.286ns 0.412546mA
+ 8.288ns 0.410777mA
+ 8.29ns 0.409015mA
+ 8.292ns 0.40726mA
+ 8.294ns 0.405513mA
+ 8.296ns 0.403773mA
+ 8.298ns 0.402041mA
+ 8.3ns 0.400317mA
+ 8.302ns 0.3986mA
+ 8.304ns 0.39689mA
+ 8.306ns 0.395188mA
+ 8.308ns 0.393493mA
+ 8.31ns 0.391804mA
+ 8.312ns 0.390123mA
+ 8.314ns 0.38845mA
+ 8.316ns 0.386784mA
+ 8.318ns 0.385125mA
+ 8.32ns 0.383473mA
+ 8.322ns 0.381828mA
+ 8.324ns 0.38019mA
+ 8.326ns 0.378559mA
+ 8.328ns 0.376935mA
+ 8.33ns 0.375318mA
+ 8.332ns 0.373708mA
+ 8.334ns 0.372105mA
+ 8.336ns 0.370509mA
+ 8.338ns 0.368919mA
+ 8.34ns 0.367337mA
+ 8.342ns 0.365761mA
+ 8.344ns 0.364192mA
+ 8.346ns 0.36263mA
+ 8.348ns 0.361075mA
+ 8.35ns 0.359525mA
+ 8.352ns 0.357983mA
+ 8.354ns 0.356448mA
+ 8.356ns 0.354919mA
+ 8.358ns 0.353396mA
+ 8.36ns 0.35188mA
+ 8.362ns 0.35037mA
+ 8.364ns 0.348868mA
+ 8.366ns 0.347371mA
+ 8.368ns 0.345881mA
+ 8.37ns 0.344397mA
+ 8.372ns 0.34292mA
+ 8.374ns 0.341449mA
+ 8.376ns 0.339984mA
+ 8.378ns 0.338526mA
+ 8.38ns 0.337074mA
+ 8.382ns 0.335628mA
+ 8.384ns 0.334188mA
+ 8.386ns 0.332754mA
+ 8.388ns 0.331326mA
+ 8.39ns 0.329905mA
+ 8.392ns 0.32849mA
+ 8.394ns 0.327081mA
+ 8.396ns 0.325678mA
+ 8.398ns 0.324281mA
+ 8.4ns 0.32289mA
+ 8.402ns 0.321504mA
+ 8.404ns 0.320125mA
+ 8.406ns 0.318752mA
+ 8.408ns 0.317385mA
+ 8.41ns 0.316023mA
+ 8.412ns 0.314668mA
+ 8.414ns 0.313318mA
+ 8.416ns 0.311973mA
+ 8.418ns 0.310635mA
+ 8.42ns 0.309303mA
+ 8.422ns 0.307976mA
+ 8.424ns 0.306655mA
+ 8.426ns 0.305339mA
+ 8.428ns 0.304029mA
+ 8.43ns 0.302725mA
+ 8.432ns 0.301426mA
+ 8.434ns 0.300133mA
+ 8.436ns 0.298846mA
+ 8.438ns 0.297564mA
+ 8.44ns 0.296288mA
+ 8.442ns 0.295016mA
+ 8.444ns 0.293751mA
+ 8.446ns 0.292491mA
+ 8.448ns 0.291236mA
+ 8.45ns 0.289987mA
+ 8.452ns 0.288743mA
+ 8.454ns 0.287503mA
+ 8.456ns 0.28627mA
+ 8.458ns 0.285042mA
+ 8.46ns 0.283819mA
+ 8.462ns 0.282602mA
+ 8.464ns 0.28139mA
+ 8.466ns 0.280183mA
+ 8.468ns 0.27898mA
+ 8.47ns 0.277783mA
+ 8.472ns 0.276592mA
+ 8.474ns 0.275405mA
+ 8.476ns 0.274224mA
+ 8.478ns 0.273048mA
+ 8.48ns 0.271876mA
+ 8.482ns 0.27071mA
+ 8.484ns 0.269548mA
+ 8.486ns 0.268392mA
+ 8.488ns 0.267241mA
+ 8.49ns 0.266094mA
+ 8.492ns 0.264953mA
+ 8.494ns 0.263816mA
+ 8.496ns 0.262684mA
+ 8.498ns 0.261557mA
+ 8.5ns 0.260435mA
+ 8.502ns 0.259318mA
+ 8.504ns 0.258206mA
+ 8.506ns 0.257098mA
+ 8.508ns 0.255995mA
+ 8.51ns 0.254896mA
+ 8.512ns 0.253803mA
+ 8.514ns 0.252714mA
+ 8.516ns 0.25163mA
+ 8.518ns 0.250551mA
+ 8.52ns 0.249475mA
+ 8.522ns 0.248405mA
+ 8.524ns 0.24734mA
+ 8.526ns 0.246279mA
+ 8.528ns 0.245222mA
+ 8.53ns 0.24417mA
+ 8.532ns 0.243123mA
+ 8.534ns 0.242079mA
+ 8.536ns 0.241041mA
+ 8.538ns 0.240007mA
+ 8.54ns 0.238977mA
+ 8.542ns 0.237952mA
+ 8.544ns 0.236931mA
+ 8.546ns 0.235914mA
+ 8.548ns 0.234902mA
+ 8.55ns 0mA
I41 55 0 PWL 0 0
+ 5.15ns 0mA
+ 5.152ns 0.00897425mA
+ 5.154ns 0.0201456mA
+ 5.156ns 0.0313143mA
+ 5.158ns 0.042483mA
+ 5.16ns 0.0536517mA
+ 5.162ns 0.0648231mA
+ 5.164ns 0.0759918mA
+ 5.166ns 0.0780043mA
+ 5.168ns 0.0647628mA
+ 5.17ns 0.0537711mA
+ 5.172ns 0.0446445mA
+ 5.174ns 0.037065mA
+ 5.176ns 0.0307734mA
+ 5.178ns 0.0255496mA
+ 5.18ns 0.0212123mA
+ 5.182ns 0mA
I42 58 0 PWL 0 0
+ 2.654ns 0mA
+ 2.656ns 0.00774923mA
+ 2.658ns 0.0181851mA
+ 2.66ns 0.0286223mA
+ 2.662ns 0.0390582mA
+ 2.664ns 0.0494954mA
+ 2.666ns 0.0599325mA
+ 2.668ns 0.0703685mA
+ 2.67ns 0.0808056mA
+ 2.672ns 0.0912415mA
+ 2.674ns 0.101679mA
+ 2.676ns 0.112116mA
+ 2.678ns 0.122552mA
+ 2.68ns 0.132989mA
+ 2.682ns 0.143425mA
+ 2.684ns 0.14523mA
+ 2.686ns 0.131893mA
+ 2.688ns 0.119782mA
+ 2.69ns 0.108781mA
+ 2.692ns 0.0987908mA
+ 2.694ns 0.0897188mA
+ 2.696ns 0.0814786mA
+ 2.698ns 0.073996mA
+ 2.7ns 0.0671997mA
+ 2.702ns 0.0610274mA
+ 2.704ns 0.0554225mA
+ 2.706ns 0.0503318mA
+ 2.708ns 0.045709mA
+ 2.71ns 0.0415103mA
+ 2.712ns 0.0376971mA
+ 2.714ns 0mA
I43 59 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00309807mA
+ 5.156ns 0.0135203mA
+ 5.158ns 0.0239425mA
+ 5.16ns 0.0343647mA
+ 5.162ns 0.0447894mA
+ 5.164ns 0.0552115mA
+ 5.166ns 0.0656337mA
+ 5.168ns 0.0760584mA
+ 5.17ns 0.0864806mA
+ 5.172ns 0.0969028mA
+ 5.174ns 0.107328mA
+ 5.176ns 0.11775mA
+ 5.178ns 0.128172mA
+ 5.18ns 0.137351mA
+ 5.182ns 0.123701mA
+ 5.184ns 0.111411mA
+ 5.186ns 0.100341mA
+ 5.188ns 0.0903685mA
+ 5.19ns 0.081389mA
+ 5.192ns 0.0733017mA
+ 5.194ns 0.0660161mA
+ 5.196ns 0.0594559mA
+ 5.198ns 0.0535475mA
+ 5.2ns 0.048225mA
+ 5.202ns 0.0434324mA
+ 5.204ns 0.039116mA
+ 5.206ns 0.0352285mA
+ 5.208ns 0mA
I44 60 0 PWL 0 0
+ 3.004ns 0mA
+ 3.006ns 0.00411111mA
+ 3.008ns 0.0118046mA
+ 3.01ns 0.0194972mA
+ 3.012ns 0.0271908mA
+ 3.014ns 0.0348834mA
+ 3.016ns 0.0425769mA
+ 3.018ns 0.0502704mA
+ 3.02ns 0.057963mA
+ 3.022ns 0.0656566mA
+ 3.024ns 0.0733501mA
+ 3.026ns 0.0810427mA
+ 3.028ns 0.0887362mA
+ 3.03ns 0.0964288mA
+ 3.032ns 0.104122mA
+ 3.034ns 0.111816mA
+ 3.036ns 0.119508mA
+ 3.038ns 0.127202mA
+ 3.04ns 0.134895mA
+ 3.042ns 0.142588mA
+ 3.044ns 0.150282mA
+ 3.046ns 0.157974mA
+ 3.048ns 0.165668mA
+ 3.05ns 0.17336mA
+ 3.052ns 0.181054mA
+ 3.054ns 0.188747mA
+ 3.056ns 0.19644mA
+ 3.058ns 0.204134mA
+ 3.06ns 0.211826mA
+ 3.062ns 0.21952mA
+ 3.064ns 0.227213mA
+ 3.066ns 0.234906mA
+ 3.068ns 0.242599mA
+ 3.07ns 0.250292mA
+ 3.072ns 0.257985mA
+ 3.074ns 0.265679mA
+ 3.076ns 0.273372mA
+ 3.078ns 0.281065mA
+ 3.08ns 0.288759mA
+ 3.082ns 0.296451mA
+ 3.084ns 0.304145mA
+ 3.086ns 0.311837mA
+ 3.088ns 0.319531mA
+ 3.09ns 0.327224mA
+ 3.092ns 0.334917mA
+ 3.094ns 0.342611mA
+ 3.096ns 0.350303mA
+ 3.098ns 0.357997mA
+ 3.1ns 0.36569mA
+ 3.102ns 0.373383mA
+ 3.104ns 0.381076mA
+ 3.106ns 0.388769mA
+ 3.108ns 0.396463mA
+ 3.11ns 0.404156mA
+ 3.112ns 0.411849mA
+ 3.114ns 0.419542mA
+ 3.116ns 0.427235mA
+ 3.118ns 0.434928mA
+ 3.12ns 0.442622mA
+ 3.122ns 0.450314mA
+ 3.124ns 0.458008mA
+ 3.126ns 0.465701mA
+ 3.128ns 0.473394mA
+ 3.13ns 0.481088mA
+ 3.132ns 0.48878mA
+ 3.134ns 0.496474mA
+ 3.136ns 0.504167mA
+ 3.138ns 0.51186mA
+ 3.14ns 0.519553mA
+ 3.142ns 0.527246mA
+ 3.144ns 0.53494mA
+ 3.146ns 0.542633mA
+ 3.148ns 0.550326mA
+ 3.15ns 0.549933mA
+ 3.152ns 0.547529mA
+ 3.154ns 0.545136mA
+ 3.156ns 0.542753mA
+ 3.158ns 0.54038mA
+ 3.16ns 0.538018mA
+ 3.162ns 0.535667mA
+ 3.164ns 0.533325mA
+ 3.166ns 0.530994mA
+ 3.168ns 0.528673mA
+ 3.17ns 0.526362mA
+ 3.172ns 0.524061mA
+ 3.174ns 0.52177mA
+ 3.176ns 0.51949mA
+ 3.178ns 0.517219mA
+ 3.18ns 0.514958mA
+ 3.182ns 0.512707mA
+ 3.184ns 0.510466mA
+ 3.186ns 0.508235mA
+ 3.188ns 0.506013mA
+ 3.19ns 0.503801mA
+ 3.192ns 0.501599mA
+ 3.194ns 0.499406mA
+ 3.196ns 0.497223mA
+ 3.198ns 0.49505mA
+ 3.2ns 0.492886mA
+ 3.202ns 0.490731mA
+ 3.204ns 0.488586mA
+ 3.206ns 0.486451mA
+ 3.208ns 0.484324mA
+ 3.21ns 0.482207mA
+ 3.212ns 0.480099mA
+ 3.214ns 0.478001mA
+ 3.216ns 0.475911mA
+ 3.218ns 0.473831mA
+ 3.22ns 0.47176mA
+ 3.222ns 0.469697mA
+ 3.224ns 0.467644mA
+ 3.226ns 0.4656mA
+ 3.228ns 0.463565mA
+ 3.23ns 0.461539mA
+ 3.232ns 0.459521mA
+ 3.234ns 0.457512mA
+ 3.236ns 0.455512mA
+ 3.238ns 0.453521mA
+ 3.24ns 0.451539mA
+ 3.242ns 0.449565mA
+ 3.244ns 0.4476mA
+ 3.246ns 0.445643mA
+ 3.248ns 0.443695mA
+ 3.25ns 0.441756mA
+ 3.252ns 0.439824mA
+ 3.254ns 0.437902mA
+ 3.256ns 0.435988mA
+ 3.258ns 0.434082mA
+ 3.26ns 0.432184mA
+ 3.262ns 0.430295mA
+ 3.264ns 0.428414mA
+ 3.266ns 0.426541mA
+ 3.268ns 0.424677mA
+ 3.27ns 0.42282mA
+ 3.272ns 0.420972mA
+ 3.274ns 0.419132mA
+ 3.276ns 0.4173mA
+ 3.278ns 0.415475mA
+ 3.28ns 0.413659mA
+ 3.282ns 0.411851mA
+ 3.284ns 0.410051mA
+ 3.286ns 0.408258mA
+ 3.288ns 0.406473mA
+ 3.29ns 0.404697mA
+ 3.292ns 0.402928mA
+ 3.294ns 0.401166mA
+ 3.296ns 0.399413mA
+ 3.298ns 0.397666mA
+ 3.3ns 0.395928mA
+ 3.302ns 0.394197mA
+ 3.304ns 0.392474mA
+ 3.306ns 0.390759mA
+ 3.308ns 0.38905mA
+ 3.31ns 0.387349mA
+ 3.312ns 0.385656mA
+ 3.314ns 0.38397mA
+ 3.316ns 0.382292mA
+ 3.318ns 0.380621mA
+ 3.32ns 0.378957mA
+ 3.322ns 0.3773mA
+ 3.324ns 0.375651mA
+ 3.326ns 0.374009mA
+ 3.328ns 0.372374mA
+ 3.33ns 0.370746mA
+ 3.332ns 0.369125mA
+ 3.334ns 0.367512mA
+ 3.336ns 0.365905mA
+ 3.338ns 0.364305mA
+ 3.34ns 0.362713mA
+ 3.342ns 0.361127mA
+ 3.344ns 0.359549mA
+ 3.346ns 0.357977mA
+ 3.348ns 0.356412mA
+ 3.35ns 0.354854mA
+ 3.352ns 0.353303mA
+ 3.354ns 0.351758mA
+ 3.356ns 0.35022mA
+ 3.358ns 0.348689mA
+ 3.36ns 0.347165mA
+ 3.362ns 0.345647mA
+ 3.364ns 0.344136mA
+ 3.366ns 0.342632mA
+ 3.368ns 0.341134mA
+ 3.37ns 0.339643mA
+ 3.372ns 0.338158mA
+ 3.374ns 0.33668mA
+ 3.376ns 0.335208mA
+ 3.378ns 0.333742mA
+ 3.38ns 0.332283mA
+ 3.382ns 0.330831mA
+ 3.384ns 0.329385mA
+ 3.386ns 0.327944mA
+ 3.388ns 0.326511mA
+ 3.39ns 0.325083mA
+ 3.392ns 0.323662mA
+ 3.394ns 0.322247mA
+ 3.396ns 0.320839mA
+ 3.398ns 0.319436mA
+ 3.4ns 0.31804mA
+ 3.402ns 0.316649mA
+ 3.404ns 0.315265mA
+ 3.406ns 0.313887mA
+ 3.408ns 0.312515mA
+ 3.41ns 0.311148mA
+ 3.412ns 0.309788mA
+ 3.414ns 0.308434mA
+ 3.416ns 0.307085mA
+ 3.418ns 0.305743mA
+ 3.42ns 0.304406mA
+ 3.422ns 0.303075mA
+ 3.424ns 0.301751mA
+ 3.426ns 0.300431mA
+ 3.428ns 0.299118mA
+ 3.43ns 0.29781mA
+ 3.432ns 0.296508mA
+ 3.434ns 0.295212mA
+ 3.436ns 0.293921mA
+ 3.438ns 0.292637mA
+ 3.44ns 0.291357mA
+ 3.442ns 0.290083mA
+ 3.444ns 0.288815mA
+ 3.446ns 0.287553mA
+ 3.448ns 0.286296mA
+ 3.45ns 0.285044mA
+ 3.452ns 0.283798mA
+ 3.454ns 0.282557mA
+ 3.456ns 0.281322mA
+ 3.458ns 0.280092mA
+ 3.46ns 0.278867mA
+ 3.462ns 0.277648mA
+ 3.464ns 0.276434mA
+ 3.466ns 0.275226mA
+ 3.468ns 0.274023mA
+ 3.47ns 0.272825mA
+ 3.472ns 0.271632mA
+ 3.474ns 0.270444mA
+ 3.476ns 0.269262mA
+ 3.478ns 0.268085mA
+ 3.48ns 0.266913mA
+ 3.482ns 0.265746mA
+ 3.484ns 0.264584mA
+ 3.486ns 0.263427mA
+ 3.488ns 0.262276mA
+ 3.49ns 0.261129mA
+ 3.492ns 0.259987mA
+ 3.494ns 0.258851mA
+ 3.496ns 0.257719mA
+ 3.498ns 0.256592mA
+ 3.5ns 0.255471mA
+ 3.502ns 0.254354mA
+ 3.504ns 0.253242mA
+ 3.506ns 0.252135mA
+ 3.508ns 0.251032mA
+ 3.51ns 0.249935mA
+ 3.512ns 0.248842mA
+ 3.514ns 0.247754mA
+ 3.516ns 0.246671mA
+ 3.518ns 0.245593mA
+ 3.52ns 0.244519mA
+ 3.522ns 0.24345mA
+ 3.524ns 0.242385mA
+ 3.526ns 0.241326mA
+ 3.528ns 0.240271mA
+ 3.53ns 0.23922mA
+ 3.532ns 0.238174mA
+ 3.534ns 0.237133mA
+ 3.536ns 0.236096mA
+ 3.538ns 0mA
I45 61 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00854329mA
+ 2.656ns 0.0200516mA
+ 2.658ns 0.0315585mA
+ 2.66ns 0.0430668mA
+ 2.662ns 0.0545737mA
+ 2.664ns 0.066082mA
+ 2.666ns 0.0775903mA
+ 2.668ns 0.0890972mA
+ 2.67ns 0.100605mA
+ 2.672ns 0.102643mA
+ 2.674ns 0.0885569mA
+ 2.676ns 0.0764037mA
+ 2.678ns 0.0659191mA
+ 2.68ns 0.0568719mA
+ 2.682ns 0.0490671mA
+ 2.684ns 0.0423324mA
+ 2.686ns 0.0365218mA
+ 2.688ns 0.0315092mA
+ 2.69ns 0.027184mA
+ 2.692ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00854466mA
+ 7.656ns 0.0200516mA
+ 7.658ns 0.0315585mA
+ 7.66ns 0.0430654mA
+ 7.662ns 0.0545751mA
+ 7.664ns 0.066082mA
+ 7.666ns 0.0775889mA
+ 7.668ns 0.0890986mA
+ 7.67ns 0.100605mA
+ 7.672ns 0.102643mA
+ 7.674ns 0.0885554mA
+ 7.676ns 0.0764037mA
+ 7.678ns 0.0659191mA
+ 7.68ns 0.0568709mA
+ 7.682ns 0.0490662mA
+ 7.684ns 0.0423324mA
+ 7.686ns 0.0365225mA
+ 7.688ns 0.0315087mA
+ 7.69ns 0.027184mA
+ 7.692ns 0mA
I46 62 0 PWL 0 0
+ 0.376ns 0mA
+ 0.378ns 0.00224451mA
+ 0.38ns 0.00606887mA
+ 0.382ns 0.00989324mA
+ 0.384ns 0.0137176mA
+ 0.386ns 0.0175419mA
+ 0.388ns 0.0213663mA
+ 0.39ns 0.0251907mA
+ 0.392ns 0.029015mA
+ 0.394ns 0.0328394mA
+ 0.396ns 0.0366638mA
+ 0.398ns 0.0404881mA
+ 0.4ns 0.0443124mA
+ 0.402ns 0.0481368mA
+ 0.404ns 0.0519612mA
+ 0.406ns 0.0557855mA
+ 0.408ns 0.0596099mA
+ 0.41ns 0.0634343mA
+ 0.412ns 0.0672586mA
+ 0.414ns 0.071083mA
+ 0.416ns 0.0749073mA
+ 0.418ns 0.0787317mA
+ 0.42ns 0.0825561mA
+ 0.422ns 0.0863804mA
+ 0.424ns 0.0902048mA
+ 0.426ns 0.0940292mA
+ 0.428ns 0.0978535mA
+ 0.43ns 0.101678mA
+ 0.432ns 0.105502mA
+ 0.434ns 0.109327mA
+ 0.436ns 0.113151mA
+ 0.438ns 0.116975mA
+ 0.44ns 0.1208mA
+ 0.442ns 0.124624mA
+ 0.444ns 0.128448mA
+ 0.446ns 0.132273mA
+ 0.448ns 0.136097mA
+ 0.45ns 0.139921mA
+ 0.452ns 0.143746mA
+ 0.454ns 0.14757mA
+ 0.456ns 0.151395mA
+ 0.458ns 0.155219mA
+ 0.46ns 0.159043mA
+ 0.462ns 0.162868mA
+ 0.464ns 0.166692mA
+ 0.466ns 0.170516mA
+ 0.468ns 0.174341mA
+ 0.47ns 0.178165mA
+ 0.472ns 0.181989mA
+ 0.474ns 0.185814mA
+ 0.476ns 0.189638mA
+ 0.478ns 0.193462mA
+ 0.48ns 0.197287mA
+ 0.482ns 0.201111mA
+ 0.484ns 0.204936mA
+ 0.486ns 0.20876mA
+ 0.488ns 0.212584mA
+ 0.49ns 0.216409mA
+ 0.492ns 0.220233mA
+ 0.494ns 0.224057mA
+ 0.496ns 0.227882mA
+ 0.498ns 0.231706mA
+ 0.5ns 0.23553mA
+ 0.502ns 0.239355mA
+ 0.504ns 0.243179mA
+ 0.506ns 0.247004mA
+ 0.508ns 0.250828mA
+ 0.51ns 0.254652mA
+ 0.512ns 0.258477mA
+ 0.514ns 0.262301mA
+ 0.516ns 0.266125mA
+ 0.518ns 0.26995mA
+ 0.52ns 0.273774mA
+ 0.522ns 0.277598mA
+ 0.524ns 0.281423mA
+ 0.526ns 0.285247mA
+ 0.528ns 0.289071mA
+ 0.53ns 0.292896mA
+ 0.532ns 0.29672mA
+ 0.534ns 0.300545mA
+ 0.536ns 0.304369mA
+ 0.538ns 0.308193mA
+ 0.54ns 0.312018mA
+ 0.542ns 0.315842mA
+ 0.544ns 0.319666mA
+ 0.546ns 0.323491mA
+ 0.548ns 0.327315mA
+ 0.55ns 0.331139mA
+ 0.552ns 0.334964mA
+ 0.554ns 0.338788mA
+ 0.556ns 0.342613mA
+ 0.558ns 0.346437mA
+ 0.56ns 0.350261mA
+ 0.562ns 0.354086mA
+ 0.564ns 0.35791mA
+ 0.566ns 0.361734mA
+ 0.568ns 0.365559mA
+ 0.57ns 0.369383mA
+ 0.572ns 0.373207mA
+ 0.574ns 0.377032mA
+ 0.576ns 0.380856mA
+ 0.578ns 0.38468mA
+ 0.58ns 0.388505mA
+ 0.582ns 0.392329mA
+ 0.584ns 0.396154mA
+ 0.586ns 0.399978mA
+ 0.588ns 0.403802mA
+ 0.59ns 0.407627mA
+ 0.592ns 0.411451mA
+ 0.594ns 0.415275mA
+ 0.596ns 0.4191mA
+ 0.598ns 0.422924mA
+ 0.6ns 0.426748mA
+ 0.602ns 0.430573mA
+ 0.604ns 0.433065mA
+ 0.606ns 0.431562mA
+ 0.608ns 0.430064mA
+ 0.61ns 0.428571mA
+ 0.612ns 0.427084mA
+ 0.614ns 0.425602mA
+ 0.616ns 0.424125mA
+ 0.618ns 0.422653mA
+ 0.62ns 0.421186mA
+ 0.622ns 0.419725mA
+ 0.624ns 0.418268mA
+ 0.626ns 0.416817mA
+ 0.628ns 0.41537mA
+ 0.63ns 0.413929mA
+ 0.632ns 0.412492mA
+ 0.634ns 0.411061mA
+ 0.636ns 0.409634mA
+ 0.638ns 0.408212mA
+ 0.64ns 0.406796mA
+ 0.642ns 0.405384mA
+ 0.644ns 0.403977mA
+ 0.646ns 0.402575mA
+ 0.648ns 0.401178mA
+ 0.65ns 0.399786mA
+ 0.652ns 0.398398mA
+ 0.654ns 0.397016mA
+ 0.656ns 0.395638mA
+ 0.658ns 0.394265mA
+ 0.66ns 0.392897mA
+ 0.662ns 0.391533mA
+ 0.664ns 0.390174mA
+ 0.666ns 0.38882mA
+ 0.668ns 0.387471mA
+ 0.67ns 0.386126mA
+ 0.672ns 0.384786mA
+ 0.674ns 0.383451mA
+ 0.676ns 0.38212mA
+ 0.678ns 0.380794mA
+ 0.68ns 0.379472mA
+ 0.682ns 0.378155mA
+ 0.684ns 0.376843mA
+ 0.686ns 0.375535mA
+ 0.688ns 0.374232mA
+ 0.69ns 0.372933mA
+ 0.692ns 0.371639mA
+ 0.694ns 0.370349mA
+ 0.696ns 0.369064mA
+ 0.698ns 0.367783mA
+ 0.7ns 0.366506mA
+ 0.702ns 0.365235mA
+ 0.704ns 0.363967mA
+ 0.706ns 0.362704mA
+ 0.708ns 0.361445mA
+ 0.71ns 0.360191mA
+ 0.712ns 0.358941mA
+ 0.714ns 0.357695mA
+ 0.716ns 0.356454mA
+ 0.718ns 0.355216mA
+ 0.72ns 0.353984mA
+ 0.722ns 0.352755mA
+ 0.724ns 0.351531mA
+ 0.726ns 0.350311mA
+ 0.728ns 0.349095mA
+ 0.73ns 0.347884mA
+ 0.732ns 0.346676mA
+ 0.734ns 0.345473mA
+ 0.736ns 0.344274mA
+ 0.738ns 0.343079mA
+ 0.74ns 0.341889mA
+ 0.742ns 0.340702mA
+ 0.744ns 0.33952mA
+ 0.746ns 0.338341mA
+ 0.748ns 0.337167mA
+ 0.75ns 0.335997mA
+ 0.752ns 0.334831mA
+ 0.754ns 0.333669mA
+ 0.756ns 0.332511mA
+ 0.758ns 0.331357mA
+ 0.76ns 0.330207mA
+ 0.762ns 0.329061mA
+ 0.764ns 0.327919mA
+ 0.766ns 0.326781mA
+ 0.768ns 0.325646mA
+ 0.77ns 0.324516mA
+ 0.772ns 0.32339mA
+ 0.774ns 0.322268mA
+ 0.776ns 0.321149mA
+ 0.778ns 0.320035mA
+ 0.78ns 0.318924mA
+ 0.782ns 0.317817mA
+ 0.784ns 0.316714mA
+ 0.786ns 0.315615mA
+ 0.788ns 0.314519mA
+ 0.79ns 0.313428mA
+ 0.792ns 0.31234mA
+ 0.794ns 0.311256mA
+ 0.796ns 0.310176mA
+ 0.798ns 0.309099mA
+ 0.8ns 0.308026mA
+ 0.802ns 0.306957mA
+ 0.804ns 0.305892mA
+ 0.806ns 0.30483mA
+ 0.808ns 0.303772mA
+ 0.81ns 0.302718mA
+ 0.812ns 0.301668mA
+ 0.814ns 0.300621mA
+ 0.816ns 0.299577mA
+ 0.818ns 0.298537mA
+ 0.82ns 0.297501mA
+ 0.822ns 0.296469mA
+ 0.824ns 0.29544mA
+ 0.826ns 0.294414mA
+ 0.828ns 0.293393mA
+ 0.83ns 0.292374mA
+ 0.832ns 0.29136mA
+ 0.834ns 0.290348mA
+ 0.836ns 0.289341mA
+ 0.838ns 0.288336mA
+ 0.84ns 0.287336mA
+ 0.842ns 0.286338mA
+ 0.844ns 0.285345mA
+ 0.846ns 0.284354mA
+ 0.848ns 0.283367mA
+ 0.85ns 0.282384mA
+ 0.852ns 0.281404mA
+ 0.854ns 0.280427mA
+ 0.856ns 0.279454mA
+ 0.858ns 0.278484mA
+ 0.86ns 0.277517mA
+ 0.862ns 0.276554mA
+ 0.864ns 0.275594mA
+ 0.866ns 0.274638mA
+ 0.868ns 0.273685mA
+ 0.87ns 0.272735mA
+ 0.872ns 0.271788mA
+ 0.874ns 0.270845mA
+ 0.876ns 0.269905mA
+ 0.878ns 0.268968mA
+ 0.88ns 0.268035mA
+ 0.882ns 0.267104mA
+ 0.884ns 0.266177mA
+ 0.886ns 0.265253mA
+ 0.888ns 0.264333mA
+ 0.89ns 0.263415mA
+ 0.892ns 0.262501mA
+ 0.894ns 0.26159mA
+ 0.896ns 0.260682mA
+ 0.898ns 0.259777mA
+ 0.9ns 0.258876mA
+ 0.902ns 0.257977mA
+ 0.904ns 0.257082mA
+ 0.906ns 0.256189mA
+ 0.908ns 0.2553mA
+ 0.91ns 0.254414mA
+ 0.912ns 0.253531mA
+ 0.914ns 0.252651mA
+ 0.916ns 0.251774mA
+ 0.918ns 0.2509mA
+ 0.92ns 0.25003mA
+ 0.922ns 0.249162mA
+ 0.924ns 0.248297mA
+ 0.926ns 0.247435mA
+ 0.928ns 0.246576mA
+ 0.93ns 0.245721mA
+ 0.932ns 0.244868mA
+ 0.934ns 0.244018mA
+ 0.936ns 0.243171mA
+ 0.938ns 0.242327mA
+ 0.94ns 0.241486mA
+ 0.942ns 0.240648mA
+ 0.944ns 0.239812mA
+ 0.946ns 0.23898mA
+ 0.948ns 0.23815mA
+ 0.95ns 0.237324mA
+ 0.952ns 0.2365mA
+ 0.954ns 0.235679mA
+ 0.956ns 0.234861mA
+ 0.958ns 0.234046mA
+ 0.96ns 0.233234mA
+ 0.962ns 0.232424mA
+ 0.964ns 0.231618mA
+ 0.966ns 0.230814mA
+ 0.968ns 0.230012mA
+ 0.97ns 0.229214mA
+ 0.972ns 0.228419mA
+ 0.974ns 0.227626mA
+ 0.976ns 0.226836mA
+ 0.978ns 0.226048mA
+ 0.98ns 0.225264mA
+ 0.982ns 0.224482mA
+ 0.984ns 0.223703mA
+ 0.986ns 0.222926mA
+ 0.988ns 0.222153mA
+ 0.99ns 0.221381mA
+ 0.992ns 0.220613mA
+ 0.994ns 0.219847mA
+ 0.996ns 0.219084mA
+ 0.998ns 0.218324mA
+ 1ns 0.217566mA
+ 1.002ns 0.216811mA
+ 1.004ns 0.216058mA
+ 1.006ns 0.215308mA
+ 1.008ns 0.214561mA
+ 1.01ns 0.213816mA
+ 1.012ns 0.213074mA
+ 1.014ns 0.212335mA
+ 1.016ns 0.211598mA
+ 1.018ns 0.210863mA
+ 1.02ns 0.210131mA
+ 1.022ns 0.209402mA
+ 1.024ns 0.208675mA
+ 1.026ns 0.207951mA
+ 1.028ns 0.207229mA
+ 1.03ns 0.20651mA
+ 1.032ns 0.205793mA
+ 1.034ns 0.205079mA
+ 1.036ns 0.204367mA
+ 1.038ns 0.203657mA
+ 1.04ns 0.20295mA
+ 1.042ns 0.202246mA
+ 1.044ns 0.201544mA
+ 1.046ns 0.200844mA
+ 1.048ns 0.200147mA
+ 1.05ns 0.199453mA
+ 1.052ns 0.19876mA
+ 1.054ns 0.19807mA
+ 1.056ns 0.197383mA
+ 1.058ns 0.196698mA
+ 1.06ns 0.196015mA
+ 1.062ns 0.195335mA
+ 1.064ns 0.194657mA
+ 1.066ns 0.193981mA
+ 1.068ns 0.193308mA
+ 1.07ns 0.192637mA
+ 1.072ns 0.191968mA
+ 1.074ns 0.191302mA
+ 1.076ns 0.190638mA
+ 1.078ns 0.189976mA
+ 1.08ns 0.189317mA
+ 1.082ns 0.188659mA
+ 1.084ns 0.188005mA
+ 1.086ns 0.187352mA
+ 1.088ns 0.186702mA
+ 1.09ns 0.186054mA
+ 1.092ns 0.185408mA
+ 1.094ns 0.184764mA
+ 1.096ns 0.184123mA
+ 1.098ns 0.183484mA
+ 1.1ns 0.182847mA
+ 1.102ns 0.182212mA
+ 1.104ns 0.18158mA
+ 1.106ns 0.18095mA
+ 1.108ns 0.180321mA
+ 1.11ns 0.179696mA
+ 1.112ns 0.179072mA
+ 1.114ns 0.17845mA
+ 1.116ns 0mA
I47 64 0 PWL 0 0
+ 0.374ns 0mA
+ 0.376ns 0.00217446mA
+ 0.378ns 0.00603748mA
+ 0.38ns 0.00990051mA
+ 0.382ns 0.0137635mA
+ 0.384ns 0.0176265mA
+ 0.386ns 0.0214895mA
+ 0.388ns 0.0253526mA
+ 0.39ns 0.0292156mA
+ 0.392ns 0.0330786mA
+ 0.394ns 0.0369416mA
+ 0.396ns 0.0408047mA
+ 0.398ns 0.0446677mA
+ 0.4ns 0.0485306mA
+ 0.402ns 0.0523937mA
+ 0.404ns 0.0562567mA
+ 0.406ns 0.0601197mA
+ 0.408ns 0.0639828mA
+ 0.41ns 0.0678458mA
+ 0.412ns 0.0717088mA
+ 0.414ns 0.0755718mA
+ 0.416ns 0.0794348mA
+ 0.418ns 0.0832978mA
+ 0.42ns 0.0871608mA
+ 0.422ns 0.0910239mA
+ 0.424ns 0.0948869mA
+ 0.426ns 0.0987499mA
+ 0.428ns 0.102613mA
+ 0.43ns 0.106476mA
+ 0.432ns 0.110339mA
+ 0.434ns 0.114202mA
+ 0.436ns 0.118065mA
+ 0.438ns 0.121928mA
+ 0.44ns 0.125791mA
+ 0.442ns 0.129654mA
+ 0.444ns 0.133517mA
+ 0.446ns 0.13738mA
+ 0.448ns 0.141243mA
+ 0.45ns 0.145106mA
+ 0.452ns 0.148969mA
+ 0.454ns 0.152832mA
+ 0.456ns 0.156695mA
+ 0.458ns 0.160558mA
+ 0.46ns 0.164421mA
+ 0.462ns 0.168284mA
+ 0.464ns 0.172147mA
+ 0.466ns 0.17601mA
+ 0.468ns 0.179873mA
+ 0.47ns 0.183736mA
+ 0.472ns 0.187599mA
+ 0.474ns 0.191462mA
+ 0.476ns 0.195325mA
+ 0.478ns 0.199188mA
+ 0.48ns 0.203051mA
+ 0.482ns 0.206914mA
+ 0.484ns 0.210777mA
+ 0.486ns 0.21464mA
+ 0.488ns 0.218503mA
+ 0.49ns 0.222366mA
+ 0.492ns 0.226229mA
+ 0.494ns 0.230093mA
+ 0.496ns 0.233956mA
+ 0.498ns 0.237819mA
+ 0.5ns 0.241682mA
+ 0.502ns 0.245545mA
+ 0.504ns 0.249408mA
+ 0.506ns 0.253271mA
+ 0.508ns 0.257134mA
+ 0.51ns 0.260997mA
+ 0.512ns 0.26486mA
+ 0.514ns 0.268723mA
+ 0.516ns 0.272586mA
+ 0.518ns 0.276449mA
+ 0.52ns 0.280312mA
+ 0.522ns 0.284175mA
+ 0.524ns 0.288038mA
+ 0.526ns 0.291901mA
+ 0.528ns 0.295764mA
+ 0.53ns 0.299627mA
+ 0.532ns 0.30349mA
+ 0.534ns 0.307353mA
+ 0.536ns 0.311216mA
+ 0.538ns 0.315079mA
+ 0.54ns 0.318942mA
+ 0.542ns 0.322805mA
+ 0.544ns 0.326668mA
+ 0.546ns 0.330531mA
+ 0.548ns 0.334394mA
+ 0.55ns 0.338257mA
+ 0.552ns 0.34212mA
+ 0.554ns 0.345983mA
+ 0.556ns 0.349846mA
+ 0.558ns 0.353709mA
+ 0.56ns 0.357572mA
+ 0.562ns 0.361435mA
+ 0.564ns 0.365298mA
+ 0.566ns 0.369161mA
+ 0.568ns 0.373024mA
+ 0.57ns 0.376887mA
+ 0.572ns 0.38075mA
+ 0.574ns 0.384613mA
+ 0.576ns 0.388476mA
+ 0.578ns 0.392339mA
+ 0.58ns 0.396202mA
+ 0.582ns 0.400065mA
+ 0.584ns 0.403928mA
+ 0.586ns 0.407791mA
+ 0.588ns 0.411654mA
+ 0.59ns 0.415517mA
+ 0.592ns 0.41938mA
+ 0.594ns 0.423243mA
+ 0.596ns 0.427106mA
+ 0.598ns 0.430969mA
+ 0.6ns 0.432946mA
+ 0.602ns 0.431424mA
+ 0.604ns 0.429906mA
+ 0.606ns 0.428395mA
+ 0.608ns 0.426888mA
+ 0.61ns 0.425387mA
+ 0.612ns 0.423891mA
+ 0.614ns 0.4224mA
+ 0.616ns 0.420915mA
+ 0.618ns 0.419434mA
+ 0.62ns 0.417959mA
+ 0.622ns 0.41649mA
+ 0.624ns 0.415025mA
+ 0.626ns 0.413565mA
+ 0.628ns 0.412111mA
+ 0.63ns 0.410662mA
+ 0.632ns 0.409218mA
+ 0.634ns 0.407779mA
+ 0.636ns 0.406344mA
+ 0.638ns 0.404915mA
+ 0.64ns 0.403491mA
+ 0.642ns 0.402072mA
+ 0.644ns 0.400658mA
+ 0.646ns 0.399249mA
+ 0.648ns 0.397845mA
+ 0.65ns 0.396446mA
+ 0.652ns 0.395052mA
+ 0.654ns 0.393663mA
+ 0.656ns 0.392278mA
+ 0.658ns 0.390899mA
+ 0.66ns 0.389524mA
+ 0.662ns 0.388154mA
+ 0.664ns 0.386789mA
+ 0.666ns 0.385429mA
+ 0.668ns 0.384074mA
+ 0.67ns 0.382723mA
+ 0.672ns 0.381377mA
+ 0.674ns 0.380036mA
+ 0.676ns 0.378699mA
+ 0.678ns 0.377367mA
+ 0.68ns 0.37604mA
+ 0.682ns 0.374718mA
+ 0.684ns 0.3734mA
+ 0.686ns 0.372087mA
+ 0.688ns 0.370778mA
+ 0.69ns 0.369474mA
+ 0.692ns 0.368175mA
+ 0.694ns 0.36688mA
+ 0.696ns 0.36559mA
+ 0.698ns 0.364304mA
+ 0.7ns 0.363023mA
+ 0.702ns 0.361746mA
+ 0.704ns 0.360474mA
+ 0.706ns 0.359206mA
+ 0.708ns 0.357943mA
+ 0.71ns 0.356684mA
+ 0.712ns 0.35543mA
+ 0.714ns 0.35418mA
+ 0.716ns 0.352934mA
+ 0.718ns 0.351693mA
+ 0.72ns 0.350456mA
+ 0.722ns 0.349224mA
+ 0.724ns 0.347996mA
+ 0.726ns 0.346772mA
+ 0.728ns 0.345552mA
+ 0.73ns 0.344337mA
+ 0.732ns 0.343126mA
+ 0.734ns 0.341919mA
+ 0.736ns 0.340717mA
+ 0.738ns 0.339518mA
+ 0.74ns 0.338324mA
+ 0.742ns 0.337135mA
+ 0.744ns 0.335949mA
+ 0.746ns 0.334767mA
+ 0.748ns 0.33359mA
+ 0.75ns 0.332417mA
+ 0.752ns 0.331248mA
+ 0.754ns 0.330083mA
+ 0.756ns 0.328922mA
+ 0.758ns 0.327765mA
+ 0.76ns 0.326612mA
+ 0.762ns 0.325464mA
+ 0.764ns 0.324319mA
+ 0.766ns 0.323179mA
+ 0.768ns 0.322042mA
+ 0.77ns 0.320909mA
+ 0.772ns 0.319781mA
+ 0.774ns 0.318656mA
+ 0.776ns 0.317535mA
+ 0.778ns 0.316419mA
+ 0.78ns 0.315306mA
+ 0.782ns 0.314197mA
+ 0.784ns 0.313092mA
+ 0.786ns 0.311991mA
+ 0.788ns 0.310894mA
+ 0.79ns 0.3098mA
+ 0.792ns 0.308711mA
+ 0.794ns 0.307625mA
+ 0.796ns 0.306543mA
+ 0.798ns 0.305465mA
+ 0.8ns 0.304391mA
+ 0.802ns 0.30332mA
+ 0.804ns 0.302253mA
+ 0.806ns 0.30119mA
+ 0.808ns 0.300131mA
+ 0.81ns 0.299075mA
+ 0.812ns 0.298024mA
+ 0.814ns 0.296975mA
+ 0.816ns 0.295931mA
+ 0.818ns 0.29489mA
+ 0.82ns 0.293853mA
+ 0.822ns 0.29282mA
+ 0.824ns 0.29179mA
+ 0.826ns 0.290763mA
+ 0.828ns 0.289741mA
+ 0.83ns 0.288722mA
+ 0.832ns 0.287706mA
+ 0.834ns 0.286694mA
+ 0.836ns 0.285686mA
+ 0.838ns 0.284681mA
+ 0.84ns 0.28368mA
+ 0.842ns 0.282682mA
+ 0.844ns 0.281688mA
+ 0.846ns 0.280698mA
+ 0.848ns 0.27971mA
+ 0.85ns 0.278727mA
+ 0.852ns 0.277746mA
+ 0.854ns 0.276769mA
+ 0.856ns 0.275796mA
+ 0.858ns 0.274826mA
+ 0.86ns 0.273859mA
+ 0.862ns 0.272896mA
+ 0.864ns 0.271936mA
+ 0.866ns 0.27098mA
+ 0.868ns 0.270027mA
+ 0.87ns 0.269077mA
+ 0.872ns 0.268131mA
+ 0.874ns 0.267188mA
+ 0.876ns 0.266248mA
+ 0.878ns 0.265312mA
+ 0.88ns 0.264379mA
+ 0.882ns 0.263449mA
+ 0.884ns 0.262522mA
+ 0.886ns 0.261599mA
+ 0.888ns 0.260679mA
+ 0.89ns 0.259762mA
+ 0.892ns 0.258848mA
+ 0.894ns 0.257938mA
+ 0.896ns 0.257031mA
+ 0.898ns 0.256127mA
+ 0.9ns 0.255226mA
+ 0.902ns 0.254328mA
+ 0.904ns 0.253434mA
+ 0.906ns 0.252542mA
+ 0.908ns 0.251654mA
+ 0.91ns 0.250769mA
+ 0.912ns 0.249887mA
+ 0.914ns 0.249008mA
+ 0.916ns 0.248132mA
+ 0.918ns 0.24726mA
+ 0.92ns 0.24639mA
+ 0.922ns 0.245523mA
+ 0.924ns 0.24466mA
+ 0.926ns 0.243799mA
+ 0.928ns 0.242942mA
+ 0.93ns 0.242087mA
+ 0.932ns 0.241236mA
+ 0.934ns 0.240388mA
+ 0.936ns 0.239542mA
+ 0.938ns 0.2387mA
+ 0.94ns 0.23786mA
+ 0.942ns 0.237023mA
+ 0.944ns 0.23619mA
+ 0.946ns 0.235359mA
+ 0.948ns 0.234531mA
+ 0.95ns 0.233706mA
+ 0.952ns 0.232884mA
+ 0.954ns 0.232065mA
+ 0.956ns 0.231249mA
+ 0.958ns 0.230436mA
+ 0.96ns 0.229625mA
+ 0.962ns 0.228818mA
+ 0.964ns 0.228013mA
+ 0.966ns 0.227211mA
+ 0.968ns 0.226412mA
+ 0.97ns 0.225615mA
+ 0.972ns 0.224822mA
+ 0.974ns 0.224031mA
+ 0.976ns 0.223243mA
+ 0.978ns 0.222458mA
+ 0.98ns 0.221675mA
+ 0.982ns 0.220896mA
+ 0.984ns 0.220119mA
+ 0.986ns 0.219345mA
+ 0.988ns 0.218573mA
+ 0.99ns 0.217804mA
+ 0.992ns 0.217038mA
+ 0.994ns 0.216275mA
+ 0.996ns 0.215514mA
+ 0.998ns 0.214756mA
+ 1ns 0.214001mA
+ 1.002ns 0.213248mA
+ 1.004ns 0.212498mA
+ 1.006ns 0.211751mA
+ 1.008ns 0.211006mA
+ 1.01ns 0.210264mA
+ 1.012ns 0.209524mA
+ 1.014ns 0.208787mA
+ 1.016ns 0.208053mA
+ 1.018ns 0.207321mA
+ 1.02ns 0.206592mA
+ 1.022ns 0.205865mA
+ 1.024ns 0.205141mA
+ 1.026ns 0.204419mA
+ 1.028ns 0.2037mA
+ 1.03ns 0.202984mA
+ 1.032ns 0.20227mA
+ 1.034ns 0.201559mA
+ 1.036ns 0.20085mA
+ 1.038ns 0.200143mA
+ 1.04ns 0.199439mA
+ 1.042ns 0.198738mA
+ 1.044ns 0.198039mA
+ 1.046ns 0.197342mA
+ 1.048ns 0.196648mA
+ 1.05ns 0.195956mA
+ 1.052ns 0.195267mA
+ 1.054ns 0.19458mA
+ 1.056ns 0.193896mA
+ 1.058ns 0.193214mA
+ 1.06ns 0.192534mA
+ 1.062ns 0.191857mA
+ 1.064ns 0.191182mA
+ 1.066ns 0.19051mA
+ 1.068ns 0.18984mA
+ 1.07ns 0.189172mA
+ 1.072ns 0.188506mA
+ 1.074ns 0.187843mA
+ 1.076ns 0.187183mA
+ 1.078ns 0.186524mA
+ 1.08ns 0.185868mA
+ 1.082ns 0.185214mA
+ 1.084ns 0.184563mA
+ 1.086ns 0.183914mA
+ 1.088ns 0.183267mA
+ 1.09ns 0.182622mA
+ 1.092ns 0.18198mA
+ 1.094ns 0.18134mA
+ 1.096ns 0.180702mA
+ 1.098ns 0.180066mA
+ 1.1ns 0.179433mA
+ 1.102ns 0.178802mA
+ 1.104ns 0.178173mA
+ 1.106ns 0mA
I48 65 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.0100916mA
+ 5.156ns 0.0209329mA
+ 5.158ns 0.0317743mA
+ 5.16ns 0.0426157mA
+ 5.162ns 0.0534597mA
+ 5.164ns 0.0643011mA
+ 5.166ns 0.0751425mA
+ 5.168ns 0.0859865mA
+ 5.17ns 0.0968278mA
+ 5.172ns 0.107669mA
+ 5.174ns 0.0984465mA
+ 5.176ns 0.0858564mA
+ 5.178ns 0.074876mA
+ 5.18ns 0.0652996mA
+ 5.182ns 0.0569459mA
+ 5.184ns 0.0496623mA
+ 5.186ns 0.0433101mA
+ 5.188ns 0.0377689mA
+ 5.19ns 0.0329377mA
+ 5.192ns 0.0287243mA
+ 5.194ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.0100916mA
+ 7.656ns 0.0209329mA
+ 7.658ns 0.0317743mA
+ 7.66ns 0.0426157mA
+ 7.662ns 0.0534597mA
+ 7.664ns 0.0643011mA
+ 7.666ns 0.0751425mA
+ 7.668ns 0.0859865mA
+ 7.67ns 0.0968278mA
+ 7.672ns 0.107669mA
+ 7.674ns 0.0984465mA
+ 7.676ns 0.0858564mA
+ 7.678ns 0.074876mA
+ 7.68ns 0.0652975mA
+ 7.682ns 0.0569459mA
+ 7.684ns 0.0496623mA
+ 7.686ns 0.0433101mA
+ 7.688ns 0.0377689mA
+ 7.69ns 0.0329377mA
+ 7.692ns 0.0287243mA
+ 7.694ns 0mA
I49 68 0 PWL 0 0
+ 0.134ns 0mA
+ 0.136ns 0.000582489mA
+ 0.138ns 0.00505173mA
+ 0.14ns 0.00952094mA
+ 0.142ns 0.0139902mA
+ 0.144ns 0.0184594mA
+ 0.146ns 0.0229287mA
+ 0.148ns 0.0273979mA
+ 0.15ns 0.0318671mA
+ 0.152ns 0.0363364mA
+ 0.154ns 0.0408056mA
+ 0.156ns 0.0452748mA
+ 0.158ns 0.0497441mA
+ 0.16ns 0.0542133mA
+ 0.162ns 0.0586825mA
+ 0.164ns 0.0631518mA
+ 0.166ns 0.067621mA
+ 0.168ns 0.0720902mA
+ 0.17ns 0.0765595mA
+ 0.172ns 0.0810287mA
+ 0.174ns 0.0854979mA
+ 0.176ns 0.0899672mA
+ 0.178ns 0.0944364mA
+ 0.18ns 0.0989056mA
+ 0.182ns 0.103375mA
+ 0.184ns 0.107844mA
+ 0.186ns 0.109872mA
+ 0.188ns 0.106282mA
+ 0.19ns 0.10281mA
+ 0.192ns 0.0994511mA
+ 0.194ns 0.0962018mA
+ 0.196ns 0.0930587mA
+ 0.198ns 0.0900182mA
+ 0.2ns 0.0870771mA
+ 0.202ns 0.084232mA
+ 0.204ns 0.0814798mA
+ 0.206ns 0.0788176mA
+ 0.208ns 0.0762423mA
+ 0.21ns 0.0737512mA
+ 0.212ns 0.0713414mA
+ 0.214ns 0.0690103mA
+ 0.216ns 0.0667554mA
+ 0.218ns 0.0645742mA
+ 0.22ns 0.0624642mA
+ 0.222ns 0.0604231mA
+ 0.224ns 0.0584487mA
+ 0.226ns 0.0565389mA
+ 0.228ns 0.0546914mA
+ 0.23ns 0.0529042mA
+ 0.232ns 0.0511755mA
+ 0.234ns 0.0495032mA
+ 0.236ns 0.0478856mA
+ 0.238ns 0.0463208mA
+ 0.24ns 0.0448071mA
+ 0.242ns 0.0433429mA
+ 0.244ns 0.0419265mA
+ 0.246ns 0.0405564mA
+ 0.248ns 0.039231mA
+ 0.25ns 0.037949mA
+ 0.252ns 0mA
+ 5.134ns 0mA
+ 5.136ns 0.000582788mA
+ 5.138ns 0.0050517mA
+ 5.14ns 0.00952061mA
+ 5.142ns 0.0139906mA
+ 5.144ns 0.0184595mA
+ 5.146ns 0.0229284mA
+ 5.148ns 0.0273984mA
+ 5.15ns 0.0318673mA
+ 5.152ns 0.0363362mA
+ 5.154ns 0.0408062mA
+ 5.156ns 0.0452751mA
+ 5.158ns 0.049744mA
+ 5.16ns 0.0542129mA
+ 5.162ns 0.0586829mA
+ 5.164ns 0.0631518mA
+ 5.166ns 0.0676207mA
+ 5.168ns 0.0720907mA
+ 5.17ns 0.0765596mA
+ 5.172ns 0.0810285mA
+ 5.174ns 0.0854985mA
+ 5.176ns 0.0899674mA
+ 5.178ns 0.0944363mA
+ 5.18ns 0.0989052mA
+ 5.182ns 0.103375mA
+ 5.184ns 0.107844mA
+ 5.186ns 0.109872mA
+ 5.188ns 0.106282mA
+ 5.19ns 0.10281mA
+ 5.192ns 0.0994513mA
+ 5.194ns 0.0962015mA
+ 5.196ns 0.0930586mA
+ 5.198ns 0.0900183mA
+ 5.2ns 0.0870767mA
+ 5.202ns 0.0842318mA
+ 5.204ns 0.0814799mA
+ 5.206ns 0.0788178mA
+ 5.208ns 0.0762421mA
+ 5.21ns 0.0737512mA
+ 5.212ns 0.0713416mA
+ 5.214ns 0.0690101mA
+ 5.216ns 0.0667554mA
+ 5.218ns 0.0645743mA
+ 5.22ns 0.0624639mA
+ 5.222ns 0.060423mA
+ 5.224ns 0.0584488mA
+ 5.226ns 0.056539mA
+ 5.228ns 0.0546912mA
+ 5.23ns 0.0529042mA
+ 5.232ns 0.0511756mA
+ 5.234ns 0.0495031mA
+ 5.236ns 0.0478855mA
+ 5.238ns 0.0463209mA
+ 5.24ns 0.0448069mA
+ 5.242ns 0.0433428mA
+ 5.244ns 0.0419265mA
+ 5.246ns 0.0405562mA
+ 5.248ns 0.039231mA
+ 5.25ns 0.037949mA
+ 5.252ns 0mA
I50 69 0 PWL 0 0
+ 7.652ns 0mA
+ 7.654ns 0.00327205mA
+ 7.656ns 0.0130619mA
+ 7.658ns 0.0228519mA
+ 7.66ns 0.0326418mA
+ 7.662ns 0.042434mA
+ 7.664ns 0.0522239mA
+ 7.666ns 0.0620138mA
+ 7.668ns 0.071806mA
+ 7.67ns 0.0815959mA
+ 7.672ns 0.0913858mA
+ 7.674ns 0.101178mA
+ 7.676ns 0.110968mA
+ 7.678ns 0.120758mA
+ 7.68ns 0.13055mA
+ 7.682ns 0.14034mA
+ 7.684ns 0.13296mA
+ 7.686ns 0.120904mA
+ 7.688ns 0.109939mA
+ 7.69ns 0.0999696mA
+ 7.692ns 0.0909044mA
+ 7.694ns 0.0826591mA
+ 7.696ns 0.0751632mA
+ 7.698ns 0.068347mA
+ 7.7ns 0.0621473mA
+ 7.702ns 0.0565112mA
+ 7.704ns 0.051386mA
+ 7.706ns 0.0467256mA
+ 7.708ns 0.0424868mA
+ 7.71ns 0.0386334mA
+ 7.712ns 0mA
I51 70 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00461793mA
+ 2.656ns 0.0151221mA
+ 2.658ns 0.025625mA
+ 2.66ns 0.0361291mA
+ 2.662ns 0.046632mA
+ 2.664ns 0.0571362mA
+ 2.666ns 0.0676403mA
+ 2.668ns 0.0781432mA
+ 2.67ns 0.0886474mA
+ 2.672ns 0.0991503mA
+ 2.674ns 0.109654mA
+ 2.676ns 0.120159mA
+ 2.678ns 0.130662mA
+ 2.68ns 0.123996mA
+ 2.682ns 0.111212mA
+ 2.684ns 0.0997439mA
+ 2.686ns 0.0894583mA
+ 2.688ns 0.0802342mA
+ 2.69ns 0.0719601mA
+ 2.692ns 0.0645391mA
+ 2.694ns 0.0578839mA
+ 2.696ns 0.0519142mA
+ 2.698ns 0.0465607mA
+ 2.7ns 0.0417585mA
+ 2.702ns 0.0374515mA
+ 2.704ns 0.0335891mA
+ 2.706ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00461918mA
+ 7.656ns 0.0151221mA
+ 7.658ns 0.025625mA
+ 7.66ns 0.0361279mA
+ 7.662ns 0.0466333mA
+ 7.664ns 0.0571362mA
+ 7.666ns 0.0676391mA
+ 7.668ns 0.0781445mA
+ 7.67ns 0.0886474mA
+ 7.672ns 0.0991503mA
+ 7.674ns 0.109656mA
+ 7.676ns 0.120159mA
+ 7.678ns 0.130662mA
+ 7.68ns 0.123994mA
+ 7.682ns 0.11121mA
+ 7.684ns 0.0997439mA
+ 7.686ns 0.0894595mA
+ 7.688ns 0.0802332mA
+ 7.69ns 0.0719601mA
+ 7.692ns 0.0645399mA
+ 7.694ns 0.0578832mA
+ 7.696ns 0.0519142mA
+ 7.698ns 0.0465607mA
+ 7.7ns 0.041758mA
+ 7.702ns 0.0374515mA
+ 7.704ns 0.0335891mA
+ 7.706ns 0mA
I52 71 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.0006084mA
+ 2.654ns 0.0110303mA
+ 2.656ns 0.0214522mA
+ 2.658ns 0.0318728mA
+ 2.66ns 0.0422947mA
+ 2.662ns 0.0527153mA
+ 2.664ns 0.0631372mA
+ 2.666ns 0.0735591mA
+ 2.668ns 0.0839797mA
+ 2.67ns 0.0944016mA
+ 2.672ns 0.104822mA
+ 2.674ns 0.105443mA
+ 2.676ns 0.0925818mA
+ 2.678ns 0.0812904mA
+ 2.68ns 0.0713747mA
+ 2.682ns 0.0626692mA
+ 2.684ns 0.0550244mA
+ 2.686ns 0.048312mA
+ 2.688ns 0.0424189mA
+ 2.69ns 0.0372439mA
+ 2.692ns 0.0327002mA
+ 2.694ns 0.028711mA
+ 2.696ns 0mA
I53 72 0 PWL 0 0
+ 0.138ns 0mA
+ 0.14ns 0.00438585mA
+ 0.142ns 0.00888106mA
+ 0.144ns 0.0133763mA
+ 0.146ns 0.0178715mA
+ 0.148ns 0.0223666mA
+ 0.15ns 0.0268618mA
+ 0.152ns 0.031357mA
+ 0.154ns 0.0358523mA
+ 0.156ns 0.0403474mA
+ 0.158ns 0.0448426mA
+ 0.16ns 0.0493378mA
+ 0.162ns 0.053833mA
+ 0.164ns 0.0583282mA
+ 0.166ns 0.0628234mA
+ 0.168ns 0.0673186mA
+ 0.17ns 0.0718138mA
+ 0.172ns 0.076309mA
+ 0.174ns 0.0808042mA
+ 0.176ns 0.0852994mA
+ 0.178ns 0.0897946mA
+ 0.18ns 0.0942898mA
+ 0.182ns 0.098785mA
+ 0.184ns 0.10328mA
+ 0.186ns 0.107775mA
+ 0.188ns 0.112271mA
+ 0.19ns 0.116766mA
+ 0.192ns 0.114612mA
+ 0.194ns 0.111373mA
+ 0.196ns 0.108225mA
+ 0.198ns 0.105166mA
+ 0.2ns 0.102193mA
+ 0.202ns 0.0993047mA
+ 0.204ns 0.0964978mA
+ 0.206ns 0.0937701mA
+ 0.208ns 0.0911196mA
+ 0.21ns 0.088544mA
+ 0.212ns 0.0860411mA
+ 0.214ns 0.083609mA
+ 0.216ns 0.0812456mA
+ 0.218ns 0.078949mA
+ 0.22ns 0.0767173mA
+ 0.222ns 0.0745487mA
+ 0.224ns 0.0724413mA
+ 0.226ns 0.0703936mA
+ 0.228ns 0.0684036mA
+ 0.23ns 0.06647mA
+ 0.232ns 0.064591mA
+ 0.234ns 0.062765mA
+ 0.236ns 0.0609907mA
+ 0.238ns 0.0592666mA
+ 0.24ns 0.0575911mA
+ 0.242ns 0.055963mA
+ 0.244ns 0.054381mA
+ 0.246ns 0.0528436mA
+ 0.248ns 0.0513497mA
+ 0.25ns 0.049898mA
+ 0.252ns 0.0484874mA
+ 0.254ns 0.0471166mA
+ 0.256ns 0.0457846mA
+ 0.258ns 0.0444902mA
+ 0.26ns 0.0432324mA
+ 0.262ns 0.0420101mA
+ 0.264ns 0.0408224mA
+ 0.266ns 0mA
I54 73 0 PWL 0 0
+ 2.638ns 0mA
+ 2.64ns 0.00404895mA
+ 2.642ns 0.00883058mA
+ 2.644ns 0.0136128mA
+ 2.646ns 0.018395mA
+ 2.648ns 0.0231766mA
+ 2.65ns 0.0279588mA
+ 2.652ns 0.0327404mA
+ 2.654ns 0.0375226mA
+ 2.656ns 0.0423048mA
+ 2.658ns 0.0470865mA
+ 2.66ns 0.0518687mA
+ 2.662ns 0.0566503mA
+ 2.664ns 0.0614325mA
+ 2.666ns 0.0662147mA
+ 2.668ns 0.0709963mA
+ 2.67ns 0.0757785mA
+ 2.672ns 0.0805601mA
+ 2.674ns 0.0853423mA
+ 2.676ns 0.0901245mA
+ 2.678ns 0.0949062mA
+ 2.68ns 0.0996884mA
+ 2.682ns 0.10447mA
+ 2.684ns 0.107098mA
+ 2.686ns 0.10335mA
+ 2.688ns 0.0997335mA
+ 2.69ns 0.0962432mA
+ 2.692ns 0.092875mA
+ 2.694ns 0.0896251mA
+ 2.696ns 0.0864885mA
+ 2.698ns 0.0834619mA
+ 2.7ns 0.080541mA
+ 2.702ns 0.0777222mA
+ 2.704ns 0.0750024mA
+ 2.706ns 0.0723774mA
+ 2.708ns 0.0698446mA
+ 2.71ns 0.0674001mA
+ 2.712ns 0.0650411mA
+ 2.714ns 0.0627649mA
+ 2.716ns 0.0605682mA
+ 2.718ns 0.0584485mA
+ 2.72ns 0.0564028mA
+ 2.722ns 0.0544286mA
+ 2.724ns 0.0525238mA
+ 2.726ns 0.0506854mA
+ 2.728ns 0.0489115mA
+ 2.73ns 0.0471995mA
+ 2.732ns 0.0455474mA
+ 2.734ns 0.0439533mA
+ 2.736ns 0.0424148mA
+ 2.738ns 0.0409303mA
+ 2.74ns 0.0394976mA
+ 2.742ns 0.038115mA
+ 2.744ns 0.036781mA
+ 2.746ns 0mA
+ 5.138ns 0mA
+ 5.14ns 0.00404838mA
+ 5.142ns 0.00883115mA
+ 5.144ns 0.0136128mA
+ 5.146ns 0.0183944mA
+ 5.148ns 0.0231772mA
+ 5.15ns 0.0279588mA
+ 5.152ns 0.0327404mA
+ 5.154ns 0.0375232mA
+ 5.156ns 0.0423048mA
+ 5.158ns 0.0470865mA
+ 5.16ns 0.0518681mA
+ 5.162ns 0.0566509mA
+ 5.164ns 0.0614325mA
+ 5.166ns 0.0662141mA
+ 5.168ns 0.0709969mA
+ 5.17ns 0.0757785mA
+ 5.172ns 0.0805601mA
+ 5.174ns 0.0853429mA
+ 5.176ns 0.0901245mA
+ 5.178ns 0.0949062mA
+ 5.18ns 0.0996878mA
+ 5.182ns 0.104471mA
+ 5.184ns 0.107098mA
+ 5.186ns 0.10335mA
+ 5.188ns 0.0997331mA
+ 5.19ns 0.0962432mA
+ 5.192ns 0.0928754mA
+ 5.194ns 0.0896247mA
+ 5.196ns 0.0864885mA
+ 5.198ns 0.0834619mA
+ 5.2ns 0.0805406mA
+ 5.202ns 0.0777222mA
+ 5.204ns 0.0750024mA
+ 5.206ns 0.0723777mA
+ 5.208ns 0.0698443mA
+ 5.21ns 0.0674001mA
+ 5.212ns 0.0650414mA
+ 5.214ns 0.0627647mA
+ 5.216ns 0.0605682mA
+ 5.218ns 0.0584485mA
+ 5.22ns 0.0564025mA
+ 5.222ns 0.0544286mA
+ 5.224ns 0.0525238mA
+ 5.226ns 0.0506856mA
+ 5.228ns 0.0489113mA
+ 5.23ns 0.0471995mA
+ 5.232ns 0.0455476mA
+ 5.234ns 0.0439531mA
+ 5.236ns 0.0424148mA
+ 5.238ns 0.0409303mA
+ 5.24ns 0.0394974mA
+ 5.242ns 0.038115mA
+ 5.244ns 0.036781mA
+ 5.246ns 0mA
I55 75 0 PWL 0 0
+ 0.23ns 0mA
+ 0.232ns 0.00158899mA
+ 0.234ns 0.00621349mA
+ 0.236ns 0.010838mA
+ 0.238ns 0.0154625mA
+ 0.24ns 0.020087mA
+ 0.242ns 0.0247115mA
+ 0.244ns 0.029336mA
+ 0.246ns 0.0339604mA
+ 0.248ns 0.0385849mA
+ 0.25ns 0.0432094mA
+ 0.252ns 0.0478339mA
+ 0.254ns 0.0524584mA
+ 0.256ns 0.0570829mA
+ 0.258ns 0.0617073mA
+ 0.26ns 0.0556181mA
+ 0.262ns 0.0501296mA
+ 0.264ns 0.0451827mA
+ 0.266ns 0.0407238mA
+ 0.268ns 0.0367048mA
+ 0.27ns 0.0330824mA
+ 0.272ns 0.0298174mA
+ 0.274ns 0.0268746mA
+ 0.276ns 0.0242221mA
+ 0.278ns 0.0218314mA
+ 0.28ns 0.0196766mA
+ 0.282ns 0.0177344mA
+ 0.284ns 0.0159839mA
+ 0.286ns 0mA
I56 78 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00502259mA
+ 5.156ns 0.0154318mA
+ 5.158ns 0.0258409mA
+ 5.16ns 0.0362501mA
+ 5.162ns 0.0466618mA
+ 5.164ns 0.057071mA
+ 5.166ns 0.0674801mA
+ 5.168ns 0.0778918mA
+ 5.17ns 0.088301mA
+ 5.172ns 0.0987101mA
+ 5.174ns 0.109122mA
+ 5.176ns 0.119531mA
+ 5.178ns 0.12994mA
+ 5.18ns 0.126915mA
+ 5.182ns 0.114012mA
+ 5.184ns 0.102423mA
+ 5.186ns 0.0920112mA
+ 5.188ns 0.0826557mA
+ 5.19ns 0.0742532mA
+ 5.192ns 0.0667046mA
+ 5.194ns 0.0599218mA
+ 5.196ns 0.0538299mA
+ 5.198ns 0.0483571mA
+ 5.2ns 0.0434396mA
+ 5.202ns 0.039023mA
+ 5.204ns 0.0350553mA
+ 5.206ns 0mA
I57 79 0 PWL 0 0
+ 5.916ns 0mA
+ 5.918ns 0.00404714mA
+ 5.92ns 0.00851254mA
+ 5.922ns 0.0129779mA
+ 5.924ns 0.0174444mA
+ 5.926ns 0.0219098mA
+ 5.928ns 0.0263752mA
+ 5.93ns 0.0308416mA
+ 5.932ns 0.035307mA
+ 5.934ns 0.0397724mA
+ 5.936ns 0.0442378mA
+ 5.938ns 0.0487043mA
+ 5.94ns 0.0531697mA
+ 5.942ns 0.0576351mA
+ 5.944ns 0.0621015mA
+ 5.946ns 0.0665669mA
+ 5.948ns 0.0637081mA
+ 5.95ns 0.058156mA
+ 5.952ns 0.0530887mA
+ 5.954ns 0.0484628mA
+ 5.956ns 0.044239mA
+ 5.958ns 0.0403841mA
+ 5.96ns 0.036865mA
+ 5.962ns 0.0336525mA
+ 5.964ns 0.0307193mA
+ 5.966ns 0.0280422mA
+ 5.968ns 0.0255984mA
+ 5.97ns 0.023367mA
+ 5.972ns 0.0213306mA
+ 5.974ns 0.0194715mA
+ 5.976ns 0.0177741mA
+ 5.978ns 0mA
I58 81 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00465708mA
+ 2.656ns 0.0154564mA
+ 2.658ns 0.0262544mA
+ 2.66ns 0.0370537mA
+ 2.662ns 0.0478517mA
+ 2.664ns 0.058651mA
+ 2.666ns 0.0694503mA
+ 2.668ns 0.0802484mA
+ 2.67ns 0.0910477mA
+ 2.672ns 0.101846mA
+ 2.674ns 0.112645mA
+ 2.676ns 0.123444mA
+ 2.678ns 0.126586mA
+ 2.68ns 0.112916mA
+ 2.682ns 0.100722mA
+ 2.684ns 0.0898444mA
+ 2.686ns 0.0801409mA
+ 2.688ns 0.0714862mA
+ 2.69ns 0.063765mA
+ 2.692ns 0.0568777mA
+ 2.694ns 0.0507347mA
+ 2.696ns 0.0452545mA
+ 2.698ns 0.0403666mA
+ 2.7ns 0.0360061mA
+ 2.702ns 0mA
I59 82 0 PWL 0 0
+ 5.516ns 0mA
+ 5.518ns 0.0011011mA
+ 5.52ns 0.0086515mA
+ 5.522ns 0.0162019mA
+ 5.524ns 0.0237541mA
+ 5.526ns 0.0313045mA
+ 5.528ns 0.0388549mA
+ 5.53ns 0.0464071mA
+ 5.532ns 0.0539575mA
+ 5.534ns 0.0615079mA
+ 5.536ns 0.0690601mA
+ 5.538ns 0.0766105mA
+ 5.54ns 0.0841609mA
+ 5.542ns 0.0917131mA
+ 5.544ns 0.0992635mA
+ 5.546ns 0.106814mA
+ 5.548ns 0.114364mA
+ 5.55ns 0.121917mA
+ 5.552ns 0.129467mA
+ 5.554ns 0.137017mA
+ 5.556ns 0.14457mA
+ 5.558ns 0.15212mA
+ 5.56ns 0.15967mA
+ 5.562ns 0.167223mA
+ 5.564ns 0.174773mA
+ 5.566ns 0.182323mA
+ 5.568ns 0.189874mA
+ 5.57ns 0.197426mA
+ 5.572ns 0.204976mA
+ 5.574ns 0.212527mA
+ 5.576ns 0.220079mA
+ 5.578ns 0.227629mA
+ 5.58ns 0.23518mA
+ 5.582ns 0.242732mA
+ 5.584ns 0.250282mA
+ 5.586ns 0.257833mA
+ 5.588ns 0.265385mA
+ 5.59ns 0.272935mA
+ 5.592ns 0.280486mA
+ 5.594ns 0.288036mA
+ 5.596ns 0.295588mA
+ 5.598ns 0.303139mA
+ 5.6ns 0.310689mA
+ 5.602ns 0.318241mA
+ 5.604ns 0.325792mA
+ 5.606ns 0.333342mA
+ 5.608ns 0.340894mA
+ 5.61ns 0.348445mA
+ 5.612ns 0.355995mA
+ 5.614ns 0.363546mA
+ 5.616ns 0.371098mA
+ 5.618ns 0.378648mA
+ 5.62ns 0.386199mA
+ 5.622ns 0.393751mA
+ 5.624ns 0.401301mA
+ 5.626ns 0.408852mA
+ 5.628ns 0.416404mA
+ 5.63ns 0.423954mA
+ 5.632ns 0.431505mA
+ 5.634ns 0.439057mA
+ 5.636ns 0.446607mA
+ 5.638ns 0.454158mA
+ 5.64ns 0.461708mA
+ 5.642ns 0.46926mA
+ 5.644ns 0.476811mA
+ 5.646ns 0.484361mA
+ 5.648ns 0.491913mA
+ 5.65ns 0.499464mA
+ 5.652ns 0.507014mA
+ 5.654ns 0.514566mA
+ 5.656ns 0.522117mA
+ 5.658ns 0.529667mA
+ 5.66ns 0.537217mA
+ 5.662ns 0.544767mA
+ 5.664ns 0.542412mA
+ 5.666ns 0.540067mA
+ 5.668ns 0.537731mA
+ 5.67ns 0.535406mA
+ 5.672ns 0.533091mA
+ 5.674ns 0.530785mA
+ 5.676ns 0.52849mA
+ 5.678ns 0.526205mA
+ 5.68ns 0.52393mA
+ 5.682ns 0.521664mA
+ 5.684ns 0.519409mA
+ 5.686ns 0.517163mA
+ 5.688ns 0.514926mA
+ 5.69ns 0.5127mA
+ 5.692ns 0.510483mA
+ 5.694ns 0.508275mA
+ 5.696ns 0.506078mA
+ 5.698ns 0.50389mA
+ 5.7ns 0.50171mA
+ 5.702ns 0.499541mA
+ 5.704ns 0.497381mA
+ 5.706ns 0.49523mA
+ 5.708ns 0.493089mA
+ 5.71ns 0.490957mA
+ 5.712ns 0.488834mA
+ 5.714ns 0.48672mA
+ 5.716ns 0.484615mA
+ 5.718ns 0.48252mA
+ 5.72ns 0.480433mA
+ 5.722ns 0.478356mA
+ 5.724ns 0.476287mA
+ 5.726ns 0.474227mA
+ 5.728ns 0.472177mA
+ 5.73ns 0.470135mA
+ 5.732ns 0.468102mA
+ 5.734ns 0.466078mA
+ 5.736ns 0.464063mA
+ 5.738ns 0.462056mA
+ 5.74ns 0.460058mA
+ 5.742ns 0.458069mA
+ 5.744ns 0.456088mA
+ 5.746ns 0.454115mA
+ 5.748ns 0.452152mA
+ 5.75ns 0.450197mA
+ 5.752ns 0.44825mA
+ 5.754ns 0.446311mA
+ 5.756ns 0.444382mA
+ 5.758ns 0.44246mA
+ 5.76ns 0.440547mA
+ 5.762ns 0.438642mA
+ 5.764ns 0.436745mA
+ 5.766ns 0.434856mA
+ 5.768ns 0.432976mA
+ 5.77ns 0.431104mA
+ 5.772ns 0.429239mA
+ 5.774ns 0.427383mA
+ 5.776ns 0.425535mA
+ 5.778ns 0.423695mA
+ 5.78ns 0.421863mA
+ 5.782ns 0.420038mA
+ 5.784ns 0.418222mA
+ 5.786ns 0.416413mA
+ 5.788ns 0.414613mA
+ 5.79ns 0.41282mA
+ 5.792ns 0.411035mA
+ 5.794ns 0.409257mA
+ 5.796ns 0.407488mA
+ 5.798ns 0.405726mA
+ 5.8ns 0.403971mA
+ 5.802ns 0.402224mA
+ 5.804ns 0.400485mA
+ 5.806ns 0.398753mA
+ 5.808ns 0.397029mA
+ 5.81ns 0.395312mA
+ 5.812ns 0.393602mA
+ 5.814ns 0.3919mA
+ 5.816ns 0.390205mA
+ 5.818ns 0.388518mA
+ 5.82ns 0.386838mA
+ 5.822ns 0.385165mA
+ 5.824ns 0.3835mA
+ 5.826ns 0.381841mA
+ 5.828ns 0.38019mA
+ 5.83ns 0.378546mA
+ 5.832ns 0.376909mA
+ 5.834ns 0.375279mA
+ 5.836ns 0.373656mA
+ 5.838ns 0.37204mA
+ 5.84ns 0.370431mA
+ 5.842ns 0.368829mA
+ 5.844ns 0.367234mA
+ 5.846ns 0.365646mA
+ 5.848ns 0.364065mA
+ 5.85ns 0.362491mA
+ 5.852ns 0.360923mA
+ 5.854ns 0.359362mA
+ 5.856ns 0.357808mA
+ 5.858ns 0.356261mA
+ 5.86ns 0.35472mA
+ 5.862ns 0.353186mA
+ 5.864ns 0.351659mA
+ 5.866ns 0.350138mA
+ 5.868ns 0.348624mA
+ 5.87ns 0.347117mA
+ 5.872ns 0.345615mA
+ 5.874ns 0.344121mA
+ 5.876ns 0.342633mA
+ 5.878ns 0.341151mA
+ 5.88ns 0.339675mA
+ 5.882ns 0.338207mA
+ 5.884ns 0.336744mA
+ 5.886ns 0.335288mA
+ 5.888ns 0.333838mA
+ 5.89ns 0.332394mA
+ 5.892ns 0.330956mA
+ 5.894ns 0.329525mA
+ 5.896ns 0.3281mA
+ 5.898ns 0.326681mA
+ 5.9ns 0.325269mA
+ 5.902ns 0.323862mA
+ 5.904ns 0.322461mA
+ 5.906ns 0.321067mA
+ 5.908ns 0.319678mA
+ 5.91ns 0.318296mA
+ 5.912ns 0.316919mA
+ 5.914ns 0.315549mA
+ 5.916ns 0.314184mA
+ 5.918ns 0.312825mA
+ 5.92ns 0.311473mA
+ 5.922ns 0.310126mA
+ 5.924ns 0.308784mA
+ 5.926ns 0.307449mA
+ 5.928ns 0.30612mA
+ 5.93ns 0.304796mA
+ 5.932ns 0.303477mA
+ 5.934ns 0.302165mA
+ 5.936ns 0.300858mA
+ 5.938ns 0.299557mA
+ 5.94ns 0.298262mA
+ 5.942ns 0.296972mA
+ 5.944ns 0.295687mA
+ 5.946ns 0.294409mA
+ 5.948ns 0.293136mA
+ 5.95ns 0.291868mA
+ 5.952ns 0.290606mA
+ 5.954ns 0.289349mA
+ 5.956ns 0.288097mA
+ 5.958ns 0.286851mA
+ 5.96ns 0.285611mA
+ 5.962ns 0.284376mA
+ 5.964ns 0.283146mA
+ 5.966ns 0.281921mA
+ 5.968ns 0.280702mA
+ 5.97ns 0.279488mA
+ 5.972ns 0.27828mA
+ 5.974ns 0.277076mA
+ 5.976ns 0.275878mA
+ 5.978ns 0.274685mA
+ 5.98ns 0.273497mA
+ 5.982ns 0.272314mA
+ 5.984ns 0.271136mA
+ 5.986ns 0.269964mA
+ 5.988ns 0.268796mA
+ 5.99ns 0.267634mA
+ 5.992ns 0.266476mA
+ 5.994ns 0.265324mA
+ 5.996ns 0.264176mA
+ 5.998ns 0.263034mA
+ 6ns 0.261896mA
+ 6.002ns 0.260764mA
+ 6.004ns 0.259636mA
+ 6.006ns 0.258513mA
+ 6.008ns 0.257395mA
+ 6.01ns 0.256282mA
+ 6.012ns 0.255173mA
+ 6.014ns 0.25407mA
+ 6.016ns 0.252971mA
+ 6.018ns 0.251877mA
+ 6.02ns 0.250788mA
+ 6.022ns 0.249703mA
+ 6.024ns 0.248623mA
+ 6.026ns 0.247548mA
+ 6.028ns 0.246477mA
+ 6.03ns 0.245411mA
+ 6.032ns 0.24435mA
+ 6.034ns 0.243293mA
+ 6.036ns 0.242241mA
+ 6.038ns 0.241193mA
+ 6.04ns 0.24015mA
+ 6.042ns 0.239111mA
+ 6.044ns 0.238077mA
+ 6.046ns 0.237048mA
+ 6.048ns 0.236022mA
+ 6.05ns 0.235002mA
+ 6.052ns 0.233985mA
+ 6.054ns 0.232973mA
+ 6.056ns 0mA
I60 83 0 PWL 0 0
+ 3.006ns 0mA
+ 3.008ns 0.00631317mA
+ 3.01ns 0.0136499mA
+ 3.012ns 0.0209875mA
+ 3.014ns 0.0283243mA
+ 3.016ns 0.0356619mA
+ 3.018ns 0.0429996mA
+ 3.02ns 0.0503363mA
+ 3.022ns 0.0576739mA
+ 3.024ns 0.0650116mA
+ 3.026ns 0.0723483mA
+ 3.028ns 0.0796859mA
+ 3.03ns 0.0870227mA
+ 3.032ns 0.0943603mA
+ 3.034ns 0.101698mA
+ 3.036ns 0.109035mA
+ 3.038ns 0.116372mA
+ 3.04ns 0.123709mA
+ 3.042ns 0.131047mA
+ 3.044ns 0.138384mA
+ 3.046ns 0.145721mA
+ 3.048ns 0.153059mA
+ 3.05ns 0.160395mA
+ 3.052ns 0.167733mA
+ 3.054ns 0.175071mA
+ 3.056ns 0.182407mA
+ 3.058ns 0.189745mA
+ 3.06ns 0.197082mA
+ 3.062ns 0.204419mA
+ 3.064ns 0.211757mA
+ 3.066ns 0.219094mA
+ 3.068ns 0.226431mA
+ 3.07ns 0.233768mA
+ 3.072ns 0.241106mA
+ 3.074ns 0.248443mA
+ 3.076ns 0.25578mA
+ 3.078ns 0.263118mA
+ 3.08ns 0.270455mA
+ 3.082ns 0.277792mA
+ 3.084ns 0.28513mA
+ 3.086ns 0.292467mA
+ 3.088ns 0.299804mA
+ 3.09ns 0.307142mA
+ 3.092ns 0.314479mA
+ 3.094ns 0.321816mA
+ 3.096ns 0.329153mA
+ 3.098ns 0.336491mA
+ 3.1ns 0.343828mA
+ 3.102ns 0.351165mA
+ 3.104ns 0.358503mA
+ 3.106ns 0.365839mA
+ 3.108ns 0.373177mA
+ 3.11ns 0.380515mA
+ 3.112ns 0.387851mA
+ 3.114ns 0.395189mA
+ 3.116ns 0.402526mA
+ 3.118ns 0.409863mA
+ 3.12ns 0.417201mA
+ 3.122ns 0.424538mA
+ 3.124ns 0.431875mA
+ 3.126ns 0.439213mA
+ 3.128ns 0.44655mA
+ 3.13ns 0.453887mA
+ 3.132ns 0.461224mA
+ 3.134ns 0.468562mA
+ 3.136ns 0.475899mA
+ 3.138ns 0.483236mA
+ 3.14ns 0.490574mA
+ 3.142ns 0.497911mA
+ 3.144ns 0.505248mA
+ 3.146ns 0.512586mA
+ 3.148ns 0.519923mA
+ 3.15ns 0.52726mA
+ 3.152ns 0.534597mA
+ 3.154ns 0.541935mA
+ 3.156ns 0.543943mA
+ 3.158ns 0.541601mA
+ 3.16ns 0.539268mA
+ 3.162ns 0.536946mA
+ 3.164ns 0.534634mA
+ 3.166ns 0.532332mA
+ 3.168ns 0.530039mA
+ 3.17ns 0.527757mA
+ 3.172ns 0.525484mA
+ 3.174ns 0.523222mA
+ 3.176ns 0.520968mA
+ 3.178ns 0.518725mA
+ 3.18ns 0.516491mA
+ 3.182ns 0.514267mA
+ 3.184ns 0.512053mA
+ 3.186ns 0.509848mA
+ 3.188ns 0.507652mA
+ 3.19ns 0.505466mA
+ 3.192ns 0.503289mA
+ 3.194ns 0.501122mA
+ 3.196ns 0.498964mA
+ 3.198ns 0.496816mA
+ 3.2ns 0.494676mA
+ 3.202ns 0.492546mA
+ 3.204ns 0.490425mA
+ 3.206ns 0.488313mA
+ 3.208ns 0.48621mA
+ 3.21ns 0.484117mA
+ 3.212ns 0.482032mA
+ 3.214ns 0.479956mA
+ 3.216ns 0.477889mA
+ 3.218ns 0.475831mA
+ 3.22ns 0.473782mA
+ 3.222ns 0.471742mA
+ 3.224ns 0.469711mA
+ 3.226ns 0.467688mA
+ 3.228ns 0.465674mA
+ 3.23ns 0.463669mA
+ 3.232ns 0.461672mA
+ 3.234ns 0.459684mA
+ 3.236ns 0.457704mA
+ 3.238ns 0.455733mA
+ 3.24ns 0.453771mA
+ 3.242ns 0.451817mA
+ 3.244ns 0.449871mA
+ 3.246ns 0.447934mA
+ 3.248ns 0.446005mA
+ 3.25ns 0.444084mA
+ 3.252ns 0.442172mA
+ 3.254ns 0.440268mA
+ 3.256ns 0.438372mA
+ 3.258ns 0.436484mA
+ 3.26ns 0.434604mA
+ 3.262ns 0.432732mA
+ 3.264ns 0.430869mA
+ 3.266ns 0.429014mA
+ 3.268ns 0.427166mA
+ 3.27ns 0.425327mA
+ 3.272ns 0.423495mA
+ 3.274ns 0.421671mA
+ 3.276ns 0.419855mA
+ 3.278ns 0.418047mA
+ 3.28ns 0.416247mA
+ 3.282ns 0.414454mA
+ 3.284ns 0.412669mA
+ 3.286ns 0.410892mA
+ 3.288ns 0.409123mA
+ 3.29ns 0.407361mA
+ 3.292ns 0.405607mA
+ 3.294ns 0.40386mA
+ 3.296ns 0.402121mA
+ 3.298ns 0.400389mA
+ 3.3ns 0.398665mA
+ 3.302ns 0.396948mA
+ 3.304ns 0.395239mA
+ 3.306ns 0.393537mA
+ 3.308ns 0.391842mA
+ 3.31ns 0.390154mA
+ 3.312ns 0.388474mA
+ 3.314ns 0.386801mA
+ 3.316ns 0.385135mA
+ 3.318ns 0.383477mA
+ 3.32ns 0.381825mA
+ 3.322ns 0.380181mA
+ 3.324ns 0.378544mA
+ 3.326ns 0.376914mA
+ 3.328ns 0.37529mA
+ 3.33ns 0.373674mA
+ 3.332ns 0.372065mA
+ 3.334ns 0.370463mA
+ 3.336ns 0.368867mA
+ 3.338ns 0.367279mA
+ 3.34ns 0.365697mA
+ 3.342ns 0.364122mA
+ 3.344ns 0.362554mA
+ 3.346ns 0.360993mA
+ 3.348ns 0.359438mA
+ 3.35ns 0.35789mA
+ 3.352ns 0.356349mA
+ 3.354ns 0.354814mA
+ 3.356ns 0.353286mA
+ 3.358ns 0.351765mA
+ 3.36ns 0.35025mA
+ 3.362ns 0.348741mA
+ 3.364ns 0.347239mA
+ 3.366ns 0.345744mA
+ 3.368ns 0.344255mA
+ 3.37ns 0.342772mA
+ 3.372ns 0.341296mA
+ 3.374ns 0.339826mA
+ 3.376ns 0.338363mA
+ 3.378ns 0.336906mA
+ 3.38ns 0.335455mA
+ 3.382ns 0.33401mA
+ 3.384ns 0.332572mA
+ 3.386ns 0.331139mA
+ 3.388ns 0.329713mA
+ 3.39ns 0.328293mA
+ 3.392ns 0.32688mA
+ 3.394ns 0.325472mA
+ 3.396ns 0.32407mA
+ 3.398ns 0.322674mA
+ 3.4ns 0.321285mA
+ 3.402ns 0.319901mA
+ 3.404ns 0.318523mA
+ 3.406ns 0.317151mA
+ 3.408ns 0.315786mA
+ 3.41ns 0.314426mA
+ 3.412ns 0.313071mA
+ 3.414ns 0.311723mA
+ 3.416ns 0.310381mA
+ 3.418ns 0.309044mA
+ 3.42ns 0.307713mA
+ 3.422ns 0.306388mA
+ 3.424ns 0.305068mA
+ 3.426ns 0.303754mA
+ 3.428ns 0.302446mA
+ 3.43ns 0.301144mA
+ 3.432ns 0.299847mA
+ 3.434ns 0.298555mA
+ 3.436ns 0.297269mA
+ 3.438ns 0.295989mA
+ 3.44ns 0.294714mA
+ 3.442ns 0.293445mA
+ 3.444ns 0.292181mA
+ 3.446ns 0.290923mA
+ 3.448ns 0.28967mA
+ 3.45ns 0.288423mA
+ 3.452ns 0.28718mA
+ 3.454ns 0.285944mA
+ 3.456ns 0.284712mA
+ 3.458ns 0.283486mA
+ 3.46ns 0.282265mA
+ 3.462ns 0.281049mA
+ 3.464ns 0.279839mA
+ 3.466ns 0.278634mA
+ 3.468ns 0.277433mA
+ 3.47ns 0.276239mA
+ 3.472ns 0.275049mA
+ 3.474ns 0.273864mA
+ 3.476ns 0.272685mA
+ 3.478ns 0.27151mA
+ 3.48ns 0.270341mA
+ 3.482ns 0.269177mA
+ 3.484ns 0.268018mA
+ 3.486ns 0.266863mA
+ 3.488ns 0.265714mA
+ 3.49ns 0.264569mA
+ 3.492ns 0.26343mA
+ 3.494ns 0.262295mA
+ 3.496ns 0.261166mA
+ 3.498ns 0.260041mA
+ 3.5ns 0.258921mA
+ 3.502ns 0.257806mA
+ 3.504ns 0.256695mA
+ 3.506ns 0.25559mA
+ 3.508ns 0.254489mA
+ 3.51ns 0.253393mA
+ 3.512ns 0.252302mA
+ 3.514ns 0.251215mA
+ 3.516ns 0.250133mA
+ 3.518ns 0.249056mA
+ 3.52ns 0.247983mA
+ 3.522ns 0.246915mA
+ 3.524ns 0.245851mA
+ 3.526ns 0.244793mA
+ 3.528ns 0.243738mA
+ 3.53ns 0.242689mA
+ 3.532ns 0.241643mA
+ 3.534ns 0.240602mA
+ 3.536ns 0.239566mA
+ 3.538ns 0.238534mA
+ 3.54ns 0.237507mA
+ 3.542ns 0.236484mA
+ 3.544ns 0.235466mA
+ 3.546ns 0.234451mA
+ 3.548ns 0.233442mA
+ 3.55ns 0.232436mA
+ 3.552ns 0mA
I61 84 0 PWL 0 0
+ 2.876ns 0mA
+ 2.878ns 0.000344217mA
+ 2.88ns 0.00425568mA
+ 2.882ns 0.00816667mA
+ 2.884ns 0.0120781mA
+ 2.886ns 0.0159896mA
+ 2.888ns 0.0199006mA
+ 2.89ns 0.023812mA
+ 2.892ns 0.027723mA
+ 2.894ns 0.0316345mA
+ 2.896ns 0.035546mA
+ 2.898ns 0.039457mA
+ 2.9ns 0.0433684mA
+ 2.902ns 0.0472794mA
+ 2.904ns 0.0511909mA
+ 2.906ns 0.0551023mA
+ 2.908ns 0.0590133mA
+ 2.91ns 0.0629248mA
+ 2.912ns 0.0668358mA
+ 2.914ns 0.0707472mA
+ 2.916ns 0.0746587mA
+ 2.918ns 0.0785697mA
+ 2.92ns 0.0824812mA
+ 2.922ns 0.0863922mA
+ 2.924ns 0.0903036mA
+ 2.926ns 0.0942151mA
+ 2.928ns 0.0981261mA
+ 2.93ns 0.102038mA
+ 2.932ns 0.105949mA
+ 2.934ns 0.10986mA
+ 2.936ns 0.113771mA
+ 2.938ns 0.117682mA
+ 2.94ns 0.121594mA
+ 2.942ns 0.125505mA
+ 2.944ns 0.129416mA
+ 2.946ns 0.133328mA
+ 2.948ns 0.137239mA
+ 2.95ns 0.14115mA
+ 2.952ns 0.145062mA
+ 2.954ns 0.148973mA
+ 2.956ns 0.152884mA
+ 2.958ns 0.156795mA
+ 2.96ns 0.160707mA
+ 2.962ns 0.164618mA
+ 2.964ns 0.168529mA
+ 2.966ns 0.172441mA
+ 2.968ns 0.176352mA
+ 2.97ns 0.180263mA
+ 2.972ns 0.184174mA
+ 2.974ns 0.188085mA
+ 2.976ns 0.191997mA
+ 2.978ns 0.195908mA
+ 2.98ns 0.199819mA
+ 2.982ns 0.203731mA
+ 2.984ns 0.207642mA
+ 2.986ns 0.211553mA
+ 2.988ns 0.215465mA
+ 2.99ns 0.219376mA
+ 2.992ns 0.223287mA
+ 2.994ns 0.227198mA
+ 2.996ns 0.23111mA
+ 2.998ns 0.235021mA
+ 3ns 0.238932mA
+ 3.002ns 0.242844mA
+ 3.004ns 0.246755mA
+ 3.006ns 0.250666mA
+ 3.008ns 0.254578mA
+ 3.01ns 0.258489mA
+ 3.012ns 0.2624mA
+ 3.014ns 0.266311mA
+ 3.016ns 0.270222mA
+ 3.018ns 0.274134mA
+ 3.02ns 0.278045mA
+ 3.022ns 0.281956mA
+ 3.024ns 0.285868mA
+ 3.026ns 0.289779mA
+ 3.028ns 0.29369mA
+ 3.03ns 0.297601mA
+ 3.032ns 0.301513mA
+ 3.034ns 0.305424mA
+ 3.036ns 0.309335mA
+ 3.038ns 0.313247mA
+ 3.04ns 0.317158mA
+ 3.042ns 0.321069mA
+ 3.044ns 0.324981mA
+ 3.046ns 0.328892mA
+ 3.048ns 0.332803mA
+ 3.05ns 0.336714mA
+ 3.052ns 0.340625mA
+ 3.054ns 0.344537mA
+ 3.056ns 0.348448mA
+ 3.058ns 0.352359mA
+ 3.06ns 0.35627mA
+ 3.062ns 0.360182mA
+ 3.064ns 0.364093mA
+ 3.066ns 0.368004mA
+ 3.068ns 0.371916mA
+ 3.07ns 0.375827mA
+ 3.072ns 0.379738mA
+ 3.074ns 0.38365mA
+ 3.076ns 0.387561mA
+ 3.078ns 0.391472mA
+ 3.08ns 0.395384mA
+ 3.082ns 0.399295mA
+ 3.084ns 0.403206mA
+ 3.086ns 0.407117mA
+ 3.088ns 0.411029mA
+ 3.09ns 0.41494mA
+ 3.092ns 0.418851mA
+ 3.094ns 0.422762mA
+ 3.096ns 0.426673mA
+ 3.098ns 0.430585mA
+ 3.1ns 0.434496mA
+ 3.102ns 0.434324mA
+ 3.104ns 0.432797mA
+ 3.106ns 0.431274mA
+ 3.108ns 0.429757mA
+ 3.11ns 0.428246mA
+ 3.112ns 0.426739mA
+ 3.114ns 0.425238mA
+ 3.116ns 0.423743mA
+ 3.118ns 0.422252mA
+ 3.12ns 0.420767mA
+ 3.122ns 0.419287mA
+ 3.124ns 0.417812mA
+ 3.126ns 0.416343mA
+ 3.128ns 0.414878mA
+ 3.13ns 0.413419mA
+ 3.132ns 0.411965mA
+ 3.134ns 0.410516mA
+ 3.136ns 0.409072mA
+ 3.138ns 0.407633mA
+ 3.14ns 0.406199mA
+ 3.142ns 0.40477mA
+ 3.144ns 0.403347mA
+ 3.146ns 0.401928mA
+ 3.148ns 0.400514mA
+ 3.15ns 0.399105mA
+ 3.152ns 0.397702mA
+ 3.154ns 0.396303mA
+ 3.156ns 0.394909mA
+ 3.158ns 0.39352mA
+ 3.16ns 0.392136mA
+ 3.162ns 0.390756mA
+ 3.164ns 0.389382mA
+ 3.166ns 0.388012mA
+ 3.168ns 0.386647mA
+ 3.17ns 0.385287mA
+ 3.172ns 0.383932mA
+ 3.174ns 0.382582mA
+ 3.176ns 0.381236mA
+ 3.178ns 0.379895mA
+ 3.18ns 0.378559mA
+ 3.182ns 0.377227mA
+ 3.184ns 0.3759mA
+ 3.186ns 0.374578mA
+ 3.188ns 0.373261mA
+ 3.19ns 0.371948mA
+ 3.192ns 0.370639mA
+ 3.194ns 0.369336mA
+ 3.196ns 0.368036mA
+ 3.198ns 0.366742mA
+ 3.2ns 0.365452mA
+ 3.202ns 0.364166mA
+ 3.204ns 0.362886mA
+ 3.206ns 0.361609mA
+ 3.208ns 0.360337mA
+ 3.21ns 0.35907mA
+ 3.212ns 0.357807mA
+ 3.214ns 0.356548mA
+ 3.216ns 0.355294mA
+ 3.218ns 0.354044mA
+ 3.22ns 0.352799mA
+ 3.222ns 0.351558mA
+ 3.224ns 0.350321mA
+ 3.226ns 0.349089mA
+ 3.228ns 0.347861mA
+ 3.23ns 0.346637mA
+ 3.232ns 0.345418mA
+ 3.234ns 0.344203mA
+ 3.236ns 0.342992mA
+ 3.238ns 0.341786mA
+ 3.24ns 0.340584mA
+ 3.242ns 0.339386mA
+ 3.244ns 0.338192mA
+ 3.246ns 0.337002mA
+ 3.248ns 0.335817mA
+ 3.25ns 0.334635mA
+ 3.252ns 0.333458mA
+ 3.254ns 0.332285mA
+ 3.256ns 0.331117mA
+ 3.258ns 0.329952mA
+ 3.26ns 0.328791mA
+ 3.262ns 0.327635mA
+ 3.264ns 0.326482mA
+ 3.266ns 0.325334mA
+ 3.268ns 0.324189mA
+ 3.27ns 0.323049mA
+ 3.272ns 0.321913mA
+ 3.274ns 0.32078mA
+ 3.276ns 0.319652mA
+ 3.278ns 0.318527mA
+ 3.28ns 0.317407mA
+ 3.282ns 0.316291mA
+ 3.284ns 0.315178mA
+ 3.286ns 0.314069mA
+ 3.288ns 0.312964mA
+ 3.29ns 0.311864mA
+ 3.292ns 0.310767mA
+ 3.294ns 0.309673mA
+ 3.296ns 0.308584mA
+ 3.298ns 0.307499mA
+ 3.3ns 0.306417mA
+ 3.302ns 0.305339mA
+ 3.304ns 0.304265mA
+ 3.306ns 0.303195mA
+ 3.308ns 0.302128mA
+ 3.31ns 0.301065mA
+ 3.312ns 0.300006mA
+ 3.314ns 0.298951mA
+ 3.316ns 0.2979mA
+ 3.318ns 0.296852mA
+ 3.32ns 0.295807mA
+ 3.322ns 0.294767mA
+ 3.324ns 0.29373mA
+ 3.326ns 0.292697mA
+ 3.328ns 0.291667mA
+ 3.33ns 0.290641mA
+ 3.332ns 0.289619mA
+ 3.334ns 0.2886mA
+ 3.336ns 0.287585mA
+ 3.338ns 0.286573mA
+ 3.34ns 0.285565mA
+ 3.342ns 0.284561mA
+ 3.344ns 0.283559mA
+ 3.346ns 0.282562mA
+ 3.348ns 0.281568mA
+ 3.35ns 0.280578mA
+ 3.352ns 0.279591mA
+ 3.354ns 0.278607mA
+ 3.356ns 0.277627mA
+ 3.358ns 0.27665mA
+ 3.36ns 0.275677mA
+ 3.362ns 0.274707mA
+ 3.364ns 0.273741mA
+ 3.366ns 0.272778mA
+ 3.368ns 0.271819mA
+ 3.37ns 0.270862mA
+ 3.372ns 0.26991mA
+ 3.374ns 0.26896mA
+ 3.376ns 0.268014mA
+ 3.378ns 0.267071mA
+ 3.38ns 0.266132mA
+ 3.382ns 0.265196mA
+ 3.384ns 0.264263mA
+ 3.386ns 0.263333mA
+ 3.388ns 0.262407mA
+ 3.39ns 0.261484mA
+ 3.392ns 0.260564mA
+ 3.394ns 0.259647mA
+ 3.396ns 0.258734mA
+ 3.398ns 0.257824mA
+ 3.4ns 0.256917mA
+ 3.402ns 0.256013mA
+ 3.404ns 0.255112mA
+ 3.406ns 0.254215mA
+ 3.408ns 0.253321mA
+ 3.41ns 0.252429mA
+ 3.412ns 0.251541mA
+ 3.414ns 0.250657mA
+ 3.416ns 0.249775mA
+ 3.418ns 0.248896mA
+ 3.42ns 0.248021mA
+ 3.422ns 0.247148mA
+ 3.424ns 0.246279mA
+ 3.426ns 0.245412mA
+ 3.428ns 0.244549mA
+ 3.43ns 0.243689mA
+ 3.432ns 0.242831mA
+ 3.434ns 0.241977mA
+ 3.436ns 0.241126mA
+ 3.438ns 0.240278mA
+ 3.44ns 0.239432mA
+ 3.442ns 0.23859mA
+ 3.444ns 0.237751mA
+ 3.446ns 0.236914mA
+ 3.448ns 0.236081mA
+ 3.45ns 0.235251mA
+ 3.452ns 0.234423mA
+ 3.454ns 0.233598mA
+ 3.456ns 0.232777mA
+ 3.458ns 0.231958mA
+ 3.46ns 0.231142mA
+ 3.462ns 0.230329mA
+ 3.464ns 0.229518mA
+ 3.466ns 0.228711mA
+ 3.468ns 0.227906mA
+ 3.47ns 0.227105mA
+ 3.472ns 0.226306mA
+ 3.474ns 0.22551mA
+ 3.476ns 0.224716mA
+ 3.478ns 0.223926mA
+ 3.48ns 0.223138mA
+ 3.482ns 0.222353mA
+ 3.484ns 0.221571mA
+ 3.486ns 0.220791mA
+ 3.488ns 0.220014mA
+ 3.49ns 0.219241mA
+ 3.492ns 0.218469mA
+ 3.494ns 0.217701mA
+ 3.496ns 0.216935mA
+ 3.498ns 0.216172mA
+ 3.5ns 0.215411mA
+ 3.502ns 0.214653mA
+ 3.504ns 0.213898mA
+ 3.506ns 0.213146mA
+ 3.508ns 0.212396mA
+ 3.51ns 0.211649mA
+ 3.512ns 0.210904mA
+ 3.514ns 0.210162mA
+ 3.516ns 0.209423mA
+ 3.518ns 0.208686mA
+ 3.52ns 0.207952mA
+ 3.522ns 0.20722mA
+ 3.524ns 0.206491mA
+ 3.526ns 0.205765mA
+ 3.528ns 0.205041mA
+ 3.53ns 0.20432mA
+ 3.532ns 0.203601mA
+ 3.534ns 0.202885mA
+ 3.536ns 0.202171mA
+ 3.538ns 0.20146mA
+ 3.54ns 0.200751mA
+ 3.542ns 0.200045mA
+ 3.544ns 0.199341mA
+ 3.546ns 0.19864mA
+ 3.548ns 0.197941mA
+ 3.55ns 0.197245mA
+ 3.552ns 0.196551mA
+ 3.554ns 0.195859mA
+ 3.556ns 0.19517mA
+ 3.558ns 0.194484mA
+ 3.56ns 0.193799mA
+ 3.562ns 0.193118mA
+ 3.564ns 0.192438mA
+ 3.566ns 0.191761mA
+ 3.568ns 0.191087mA
+ 3.57ns 0.190414mA
+ 3.572ns 0.189744mA
+ 3.574ns 0.189077mA
+ 3.576ns 0.188412mA
+ 3.578ns 0.187749mA
+ 3.58ns 0.187088mA
+ 3.582ns 0.18643mA
+ 3.584ns 0.185774mA
+ 3.586ns 0.185121mA
+ 3.588ns 0.184469mA
+ 3.59ns 0.18382mA
+ 3.592ns 0.183174mA
+ 3.594ns 0.182529mA
+ 3.596ns 0.181887mA
+ 3.598ns 0.181247mA
+ 3.6ns 0.18061mA
+ 3.602ns 0.179974mA
+ 3.604ns 0.179341mA
+ 3.606ns 0mA
I62 85 0 PWL 0 0
+ 0.266ns 0mA
+ 0.268ns 0.000326663mA
+ 0.27ns 0.00347773mA
+ 0.272ns 0.0066288mA
+ 0.274ns 0.00977987mA
+ 0.276ns 0.0129309mA
+ 0.278ns 0.016082mA
+ 0.28ns 0.019233mA
+ 0.282ns 0.0223841mA
+ 0.284ns 0.0255352mA
+ 0.286ns 0.0286862mA
+ 0.288ns 0.0318373mA
+ 0.29ns 0.0349884mA
+ 0.292ns 0.0381395mA
+ 0.294ns 0.0412905mA
+ 0.296ns 0.0444416mA
+ 0.298ns 0.0475926mA
+ 0.3ns 0.0507437mA
+ 0.302ns 0.0538948mA
+ 0.304ns 0.0570458mA
+ 0.306ns 0.0601969mA
+ 0.308ns 0.063348mA
+ 0.31ns 0.066499mA
+ 0.312ns 0.0696501mA
+ 0.314ns 0.0728011mA
+ 0.316ns 0.0759522mA
+ 0.318ns 0.0791033mA
+ 0.32ns 0.0822544mA
+ 0.322ns 0.0854054mA
+ 0.324ns 0.0885564mA
+ 0.326ns 0.0917075mA
+ 0.328ns 0.0948586mA
+ 0.33ns 0.0980097mA
+ 0.332ns 0.101161mA
+ 0.334ns 0.104312mA
+ 0.336ns 0.107463mA
+ 0.338ns 0.110614mA
+ 0.34ns 0.113765mA
+ 0.342ns 0.116916mA
+ 0.344ns 0.120067mA
+ 0.346ns 0.123218mA
+ 0.348ns 0.126369mA
+ 0.35ns 0.12952mA
+ 0.352ns 0.132671mA
+ 0.354ns 0.135822mA
+ 0.356ns 0.138973mA
+ 0.358ns 0.142125mA
+ 0.36ns 0.145276mA
+ 0.362ns 0.148427mA
+ 0.364ns 0.151578mA
+ 0.366ns 0.154729mA
+ 0.368ns 0.15788mA
+ 0.37ns 0.161031mA
+ 0.372ns 0.164182mA
+ 0.374ns 0.167333mA
+ 0.376ns 0.168625mA
+ 0.378ns 0.167649mA
+ 0.38ns 0.166678mA
+ 0.382ns 0.165713mA
+ 0.384ns 0.164753mA
+ 0.386ns 0.1638mA
+ 0.388ns 0.162851mA
+ 0.39ns 0.161908mA
+ 0.392ns 0.160971mA
+ 0.394ns 0.160039mA
+ 0.396ns 0.159112mA
+ 0.398ns 0.158191mA
+ 0.4ns 0.157275mA
+ 0.402ns 0.156364mA
+ 0.404ns 0.155459mA
+ 0.406ns 0.154559mA
+ 0.408ns 0.153664mA
+ 0.41ns 0.152774mA
+ 0.412ns 0.15189mA
+ 0.414ns 0.15101mA
+ 0.416ns 0.150136mA
+ 0.418ns 0.149267mA
+ 0.42ns 0.148402mA
+ 0.422ns 0.147543mA
+ 0.424ns 0.146689mA
+ 0.426ns 0.145839mA
+ 0.428ns 0.144995mA
+ 0.43ns 0.144156mA
+ 0.432ns 0.143321mA
+ 0.434ns 0.142491mA
+ 0.436ns 0.141666mA
+ 0.438ns 0.140846mA
+ 0.44ns 0.14003mA
+ 0.442ns 0.139219mA
+ 0.444ns 0.138413mA
+ 0.446ns 0.137612mA
+ 0.448ns 0.136815mA
+ 0.45ns 0.136023mA
+ 0.452ns 0.135235mA
+ 0.454ns 0.134452mA
+ 0.456ns 0.133674mA
+ 0.458ns 0.1329mA
+ 0.46ns 0.13213mA
+ 0.462ns 0.131365mA
+ 0.464ns 0.130605mA
+ 0.466ns 0.129848mA
+ 0.468ns 0.129096mA
+ 0.47ns 0.128349mA
+ 0.472ns 0.127606mA
+ 0.474ns 0.126867mA
+ 0.476ns 0.126132mA
+ 0.478ns 0.125402mA
+ 0.48ns 0.124676mA
+ 0.482ns 0.123954mA
+ 0.484ns 0.123236mA
+ 0.486ns 0.122523mA
+ 0.488ns 0.121813mA
+ 0.49ns 0.121108mA
+ 0.492ns 0.120407mA
+ 0.494ns 0.119709mA
+ 0.496ns 0.119016mA
+ 0.498ns 0.118327mA
+ 0.5ns 0.117642mA
+ 0.502ns 0.116961mA
+ 0.504ns 0.116283mA
+ 0.506ns 0.11561mA
+ 0.508ns 0.114941mA
+ 0.51ns 0.114275mA
+ 0.512ns 0.113613mA
+ 0.514ns 0.112956mA
+ 0.516ns 0.112301mA
+ 0.518ns 0.111651mA
+ 0.52ns 0.111005mA
+ 0.522ns 0.110362mA
+ 0.524ns 0.109723mA
+ 0.526ns 0.109088mA
+ 0.528ns 0.108456mA
+ 0.53ns 0.107828mA
+ 0.532ns 0.107203mA
+ 0.534ns 0.106583mA
+ 0.536ns 0.105966mA
+ 0.538ns 0.105352mA
+ 0.54ns 0.104742mA
+ 0.542ns 0.104135mA
+ 0.544ns 0.103532mA
+ 0.546ns 0.102933mA
+ 0.548ns 0.102337mA
+ 0.55ns 0.101744mA
+ 0.552ns 0.101155mA
+ 0.554ns 0.100569mA
+ 0.556ns 0.0999869mA
+ 0.558ns 0.099408mA
+ 0.56ns 0.0988323mA
+ 0.562ns 0.09826mA
+ 0.564ns 0.0976911mA
+ 0.566ns 0.0971253mA
+ 0.568ns 0.0965629mA
+ 0.57ns 0.0960038mA
+ 0.572ns 0.0954478mA
+ 0.574ns 0.0948951mA
+ 0.576ns 0.0943456mA
+ 0.578ns 0.0937993mA
+ 0.58ns 0.0932561mA
+ 0.582ns 0.0927161mA
+ 0.584ns 0.0921792mA
+ 0.586ns 0.0916454mA
+ 0.588ns 0.0911147mA
+ 0.59ns 0.0905871mA
+ 0.592ns 0.0900626mA
+ 0.594ns 0.089541mA
+ 0.596ns 0.0890225mA
+ 0.598ns 0.088507mA
+ 0.6ns 0.0879945mA
+ 0.602ns 0.0874849mA
+ 0.604ns 0.0869783mA
+ 0.606ns 0.0864746mA
+ 0.608ns 0.0859739mA
+ 0.61ns 0.085476mA
+ 0.612ns 0.084981mA
+ 0.614ns 0.0844889mA
+ 0.616ns 0.0839996mA
+ 0.618ns 0.0835132mA
+ 0.62ns 0.0830296mA
+ 0.622ns 0.0825488mA
+ 0.624ns 0.0820708mA
+ 0.626ns 0.0815955mA
+ 0.628ns 0.081123mA
+ 0.63ns 0.0806532mA
+ 0.632ns 0.0801862mA
+ 0.634ns 0.0797218mA
+ 0.636ns 0.0792601mA
+ 0.638ns 0.0788011mA
+ 0.64ns 0.0783448mA
+ 0.642ns 0.0778911mA
+ 0.644ns 0.07744mA
+ 0.646ns 0.0769916mA
+ 0.648ns 0.0765457mA
+ 0.65ns 0.0761025mA
+ 0.652ns 0.0756618mA
+ 0.654ns 0.0752236mA
+ 0.656ns 0.074788mA
+ 0.658ns 0.0743549mA
+ 0.66ns 0.0739243mA
+ 0.662ns 0.0734962mA
+ 0.664ns 0.0730706mA
+ 0.666ns 0.0726474mA
+ 0.668ns 0mA
+ 7.766ns 0mA
+ 7.768ns 0.000327367mA
+ 7.77ns 0.0034782mA
+ 7.772ns 0.00662979mA
+ 7.774ns 0.00978063mA
+ 7.776ns 0.0129315mA
+ 7.778ns 0.0160823mA
+ 7.78ns 0.0192339mA
+ 7.782ns 0.0223847mA
+ 7.784ns 0.0255356mA
+ 7.786ns 0.0286871mA
+ 7.788ns 0.031838mA
+ 7.79ns 0.0349888mA
+ 7.792ns 0.0381404mA
+ 7.794ns 0.0412912mA
+ 7.796ns 0.0444421mA
+ 7.798ns 0.0475929mA
+ 7.8ns 0.0507445mA
+ 7.802ns 0.0538953mA
+ 7.804ns 0.0570462mA
+ 7.806ns 0.0601978mA
+ 7.808ns 0.0633486mA
+ 7.81ns 0.0664994mA
+ 7.812ns 0.069651mA
+ 7.814ns 0.0728019mA
+ 7.816ns 0.0759527mA
+ 7.818ns 0.0791043mA
+ 7.82ns 0.0822551mA
+ 7.822ns 0.0854059mA
+ 7.824ns 0.0885568mA
+ 7.826ns 0.0917084mA
+ 7.828ns 0.0948592mA
+ 7.83ns 0.09801mA
+ 7.832ns 0.101162mA
+ 7.834ns 0.104312mA
+ 7.836ns 0.107463mA
+ 7.838ns 0.110615mA
+ 7.84ns 0.113766mA
+ 7.842ns 0.116917mA
+ 7.844ns 0.120067mA
+ 7.846ns 0.123219mA
+ 7.848ns 0.12637mA
+ 7.85ns 0.129521mA
+ 7.852ns 0.132672mA
+ 7.854ns 0.135823mA
+ 7.856ns 0.138974mA
+ 7.858ns 0.142125mA
+ 7.86ns 0.145276mA
+ 7.862ns 0.148427mA
+ 7.864ns 0.151579mA
+ 7.866ns 0.15473mA
+ 7.868ns 0.15788mA
+ 7.87ns 0.161031mA
+ 7.872ns 0.164183mA
+ 7.874ns 0.167334mA
+ 7.876ns 0.168625mA
+ 7.878ns 0.167648mA
+ 7.88ns 0.166678mA
+ 7.882ns 0.165713mA
+ 7.884ns 0.164753mA
+ 7.886ns 0.163799mA
+ 7.888ns 0.162851mA
+ 7.89ns 0.161908mA
+ 7.892ns 0.160971mA
+ 7.894ns 0.160039mA
+ 7.896ns 0.159112mA
+ 7.898ns 0.158191mA
+ 7.9ns 0.157275mA
+ 7.902ns 0.156364mA
+ 7.904ns 0.155459mA
+ 7.906ns 0.154559mA
+ 7.908ns 0.153664mA
+ 7.91ns 0.152774mA
+ 7.912ns 0.15189mA
+ 7.914ns 0.15101mA
+ 7.916ns 0.150136mA
+ 7.918ns 0.149266mA
+ 7.92ns 0.148402mA
+ 7.922ns 0.147543mA
+ 7.924ns 0.146689mA
+ 7.926ns 0.145839mA
+ 7.928ns 0.144995mA
+ 7.93ns 0.144155mA
+ 7.932ns 0.143321mA
+ 7.934ns 0.142491mA
+ 7.936ns 0.141666mA
+ 7.938ns 0.140845mA
+ 7.94ns 0.14003mA
+ 7.942ns 0.139219mA
+ 7.944ns 0.138413mA
+ 7.946ns 0.137612mA
+ 7.948ns 0.136815mA
+ 7.95ns 0.136023mA
+ 7.952ns 0.135235mA
+ 7.954ns 0.134452mA
+ 7.956ns 0.133673mA
+ 7.958ns 0.1329mA
+ 7.96ns 0.13213mA
+ 7.962ns 0.131365mA
+ 7.964ns 0.130604mA
+ 7.966ns 0.129848mA
+ 7.968ns 0.129096mA
+ 7.97ns 0.128349mA
+ 7.972ns 0.127606mA
+ 7.974ns 0.126867mA
+ 7.976ns 0.126132mA
+ 7.978ns 0.125402mA
+ 7.98ns 0.124676mA
+ 7.982ns 0.123954mA
+ 7.984ns 0.123236mA
+ 7.986ns 0.122522mA
+ 7.988ns 0.121813mA
+ 7.99ns 0.121108mA
+ 7.992ns 0.120406mA
+ 7.994ns 0.119709mA
+ 7.996ns 0.119016mA
+ 7.998ns 0.118327mA
+ 8ns 0.117642mA
+ 8.002ns 0.116961mA
+ 8.004ns 0.116283mA
+ 8.006ns 0.11561mA
+ 8.008ns 0.11494mA
+ 8.01ns 0.114275mA
+ 8.012ns 0.113613mA
+ 8.014ns 0.112955mA
+ 8.016ns 0.112301mA
+ 8.018ns 0.111651mA
+ 8.02ns 0.111004mA
+ 8.022ns 0.110362mA
+ 8.024ns 0.109723mA
+ 8.026ns 0.109087mA
+ 8.028ns 0.108456mA
+ 8.03ns 0.107828mA
+ 8.032ns 0.107203mA
+ 8.034ns 0.106582mA
+ 8.036ns 0.105965mA
+ 8.038ns 0.105352mA
+ 8.04ns 0.104742mA
+ 8.042ns 0.104135mA
+ 8.044ns 0.103532mA
+ 8.046ns 0.102933mA
+ 8.048ns 0.102337mA
+ 8.05ns 0.101744mA
+ 8.052ns 0.101155mA
+ 8.054ns 0.100569mA
+ 8.056ns 0.0999869mA
+ 8.058ns 0.099408mA
+ 8.06ns 0.0988321mA
+ 8.062ns 0.0982599mA
+ 8.064ns 0.0976909mA
+ 8.066ns 0.0971253mA
+ 8.068ns 0.0965629mA
+ 8.07ns 0.0960038mA
+ 8.072ns 0.0954479mA
+ 8.074ns 0.094895mA
+ 8.076ns 0.0943455mA
+ 8.078ns 0.0937992mA
+ 8.08ns 0.0932561mA
+ 8.082ns 0.0927161mA
+ 8.084ns 0.0921792mA
+ 8.086ns 0.0916452mA
+ 8.088ns 0.0911146mA
+ 8.09ns 0.090587mA
+ 8.092ns 0.0900625mA
+ 8.094ns 0.089541mA
+ 8.096ns 0.0890225mA
+ 8.098ns 0.088507mA
+ 8.1ns 0.0879943mA
+ 8.102ns 0.0874848mA
+ 8.104ns 0.0869782mA
+ 8.106ns 0.0864746mA
+ 8.108ns 0.0859738mA
+ 8.11ns 0.085476mA
+ 8.112ns 0.0849808mA
+ 8.114ns 0.0844888mA
+ 8.116ns 0.0839995mA
+ 8.118ns 0.0835131mA
+ 8.12ns 0.0830296mA
+ 8.122ns 0.0825488mA
+ 8.124ns 0.0820708mA
+ 8.126ns 0.0815953mA
+ 8.128ns 0.0811229mA
+ 8.13ns 0.0806531mA
+ 8.132ns 0.0801861mA
+ 8.134ns 0.0797218mA
+ 8.136ns 0.0792601mA
+ 8.138ns 0.0788012mA
+ 8.14ns 0.0783447mA
+ 8.142ns 0.077891mA
+ 8.144ns 0.07744mA
+ 8.146ns 0.0769916mA
+ 8.148ns 0.0765457mA
+ 8.15ns 0.0761025mA
+ 8.152ns 0.0756616mA
+ 8.154ns 0.0752235mA
+ 8.156ns 0.0747879mA
+ 8.158ns 0.0743548mA
+ 8.16ns 0.0739243mA
+ 8.162ns 0.0734962mA
+ 8.164ns 0.0730706mA
+ 8.166ns 0.0726473mA
+ 8.168ns 0mA
I63 87 0 PWL 0 0
+ 0.15ns 0mA
+ 0.152ns 0.00982416mA
+ 0.154ns 0.0208752mA
+ 0.156ns 0.0319262mA
+ 0.158ns 0.0429773mA
+ 0.16ns 0.0540284mA
+ 0.162ns 0.0650794mA
+ 0.164ns 0.0761305mA
+ 0.166ns 0.0718638mA
+ 0.168ns 0.0594165mA
+ 0.17ns 0.0491248mA
+ 0.172ns 0.0406153mA
+ 0.174ns 0.0335796mA
+ 0.176ns 0.0277624mA
+ 0.178ns 0.0229528mA
+ 0.18ns 0mA
I64 88 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00692443mA
+ 2.656ns 0.0182981mA
+ 2.658ns 0.0296704mA
+ 2.66ns 0.041044mA
+ 2.662ns 0.0524163mA
+ 2.664ns 0.06379mA
+ 2.666ns 0.0751636mA
+ 2.668ns 0.0865359mA
+ 2.67ns 0.0979096mA
+ 2.672ns 0.109282mA
+ 2.674ns 0.113933mA
+ 2.676ns 0.0996609mA
+ 2.678ns 0.0871776mA
+ 2.68ns 0.0762563mA
+ 2.682ns 0.066704mA
+ 2.684ns 0.0583471mA
+ 2.686ns 0.0510369mA
+ 2.688ns 0.0446432mA
+ 2.69ns 0.0390496mA
+ 2.692ns 0.0341567mA
+ 2.694ns 0.0298773mA
+ 2.696ns 0mA
I65 90 0 PWL 0 0
+ 2.686ns 0mA
+ 2.688ns 0.0037652mA
+ 2.69ns 0.0176518mA
+ 2.692ns 0.0315383mA
+ 2.694ns 0.0454232mA
+ 2.696ns 0.0593098mA
+ 2.698ns 0.0731947mA
+ 2.7ns 0.0870812mA
+ 2.702ns 0.100968mA
+ 2.704ns 0.114853mA
+ 2.706ns 0.128735mA
+ 2.708ns 0.110857mA
+ 2.71ns 0.0954587mA
+ 2.712ns 0.0821991mA
+ 2.714ns 0.0707822mA
+ 2.716ns 0.0609496mA
+ 2.718ns 0.0524835mA
+ 2.72ns 0.0451924mA
+ 2.722ns 0.0389139mA
+ 2.724ns 0.0335081mA
+ 2.726ns 0mA
I66 97 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00464848mA
+ 0.156ns 0.0147173mA
+ 0.158ns 0.0247862mA
+ 0.16ns 0.0348551mA
+ 0.162ns 0.0449239mA
+ 0.164ns 0.0549928mA
+ 0.166ns 0.0650617mA
+ 0.168ns 0.0751306mA
+ 0.17ns 0.0851994mA
+ 0.172ns 0.0952683mA
+ 0.174ns 0.105337mA
+ 0.176ns 0.115406mA
+ 0.178ns 0.125475mA
+ 0.18ns 0.135544mA
+ 0.182ns 0.126832mA
+ 0.184ns 0.114593mA
+ 0.186ns 0.103535mA
+ 0.188ns 0.0935433mA
+ 0.19ns 0.084516mA
+ 0.192ns 0.0763596mA
+ 0.194ns 0.0689902mA
+ 0.196ns 0.0623319mA
+ 0.198ns 0.056316mA
+ 0.2ns 0.0508806mA
+ 0.202ns 0.0459697mA
+ 0.204ns 0.0415327mA
+ 0.206ns 0.0375238mA
+ 0.208ns 0mA
+ 5.152ns 0mA
+ 5.154ns 0.00465036mA
+ 5.156ns 0.0147185mA
+ 5.158ns 0.0247866mA
+ 5.16ns 0.0348548mA
+ 5.162ns 0.0449253mA
+ 5.164ns 0.0549935mA
+ 5.166ns 0.0650616mA
+ 5.168ns 0.0751322mA
+ 5.17ns 0.0852003mA
+ 5.172ns 0.0952684mA
+ 5.174ns 0.105339mA
+ 5.176ns 0.115407mA
+ 5.178ns 0.125475mA
+ 5.18ns 0.135543mA
+ 5.182ns 0.12683mA
+ 5.184ns 0.114592mA
+ 5.186ns 0.103535mA
+ 5.188ns 0.0935419mA
+ 5.19ns 0.0845153mA
+ 5.192ns 0.0763596mA
+ 5.194ns 0.068989mA
+ 5.196ns 0.0623313mA
+ 5.198ns 0.0563159mA
+ 5.2ns 0.0508796mA
+ 5.202ns 0.0459692mA
+ 5.204ns 0.0415325mA
+ 5.206ns 0.037524mA
+ 5.208ns 0mA
I67 99 0 PWL 0 0
+ 0.436ns 0mA
+ 0.438ns 0.00176986mA
+ 0.44ns 0.00658779mA
+ 0.442ns 0.0114057mA
+ 0.444ns 0.0162236mA
+ 0.446ns 0.0210415mA
+ 0.448ns 0.0258594mA
+ 0.45ns 0.0306773mA
+ 0.452ns 0.0354952mA
+ 0.454ns 0.0403132mA
+ 0.456ns 0.0451311mA
+ 0.458ns 0.049949mA
+ 0.46ns 0.0547669mA
+ 0.462ns 0.0561698mA
+ 0.464ns 0.0500737mA
+ 0.466ns 0.0446391mA
+ 0.468ns 0.0397942mA
+ 0.47ns 0.035475mA
+ 0.472ns 0.0316245mA
+ 0.474ns 0.0281919mA
+ 0.476ns 0.0251318mA
+ 0.478ns 0.0224038mA
+ 0.48ns 0.0199718mA
+ 0.482ns 0.0178037mA
+ 0.484ns 0.015871mA
+ 0.486ns 0mA
+ 5.912ns 0mA
+ 5.914ns 0.00201145mA
+ 5.916ns 0.00682901mA
+ 5.918ns 0.0116477mA
+ 5.92ns 0.0164653mA
+ 5.922ns 0.0212828mA
+ 5.924ns 0.0261016mA
+ 5.926ns 0.0309191mA
+ 5.928ns 0.0357367mA
+ 5.93ns 0.0405554mA
+ 5.932ns 0.045373mA
+ 5.934ns 0.0501905mA
+ 5.936ns 0.0550081mA
+ 5.938ns 0.0558466mA
+ 5.94ns 0.049786mA
+ 5.942ns 0.044383mA
+ 5.944ns 0.0395651mA
+ 5.946ns 0.0352711mA
+ 5.948ns 0.031443mA
+ 5.95ns 0.0280295mA
+ 5.952ns 0.0249873mA
+ 5.954ns 0.0222751mA
+ 5.956ns 0.0198567mA
+ 5.958ns 0.0177013mA
+ 5.96ns 0.0157798mA
+ 5.962ns 0mA
I68 102 0 PWL 0 0
+ 0.39ns 0mA
+ 0.392ns 0.00215644mA
+ 0.394ns 0.00614664mA
+ 0.396ns 0.0101368mA
+ 0.398ns 0.014127mA
+ 0.4ns 0.0181172mA
+ 0.402ns 0.0221074mA
+ 0.404ns 0.0260976mA
+ 0.406ns 0.0300878mA
+ 0.408ns 0.034078mA
+ 0.41ns 0.0380682mA
+ 0.412ns 0.0420584mA
+ 0.414ns 0.0460486mA
+ 0.416ns 0.0500388mA
+ 0.418ns 0.054029mA
+ 0.42ns 0.0580192mA
+ 0.422ns 0.0620094mA
+ 0.424ns 0.0659996mA
+ 0.426ns 0.0699898mA
+ 0.428ns 0.07398mA
+ 0.43ns 0.0779701mA
+ 0.432ns 0.0819603mA
+ 0.434ns 0.0859505mA
+ 0.436ns 0.0899407mA
+ 0.438ns 0.0939309mA
+ 0.44ns 0.0979211mA
+ 0.442ns 0.101911mA
+ 0.444ns 0.105902mA
+ 0.446ns 0.109892mA
+ 0.448ns 0.113882mA
+ 0.45ns 0.117872mA
+ 0.452ns 0.121862mA
+ 0.454ns 0.125852mA
+ 0.456ns 0.129843mA
+ 0.458ns 0.133833mA
+ 0.46ns 0.137823mA
+ 0.462ns 0.141813mA
+ 0.464ns 0.145803mA
+ 0.466ns 0.149794mA
+ 0.468ns 0.153784mA
+ 0.47ns 0.157774mA
+ 0.472ns 0.161764mA
+ 0.474ns 0.165754mA
+ 0.476ns 0.169745mA
+ 0.478ns 0.173735mA
+ 0.48ns 0.177725mA
+ 0.482ns 0.181715mA
+ 0.484ns 0.185705mA
+ 0.486ns 0.189696mA
+ 0.488ns 0.193686mA
+ 0.49ns 0.197676mA
+ 0.492ns 0.201666mA
+ 0.494ns 0.205656mA
+ 0.496ns 0.209647mA
+ 0.498ns 0.213637mA
+ 0.5ns 0.217627mA
+ 0.502ns 0.221617mA
+ 0.504ns 0.225607mA
+ 0.506ns 0.229598mA
+ 0.508ns 0.233588mA
+ 0.51ns 0.237578mA
+ 0.512ns 0.241568mA
+ 0.514ns 0.245558mA
+ 0.516ns 0.249549mA
+ 0.518ns 0.253539mA
+ 0.52ns 0.257529mA
+ 0.522ns 0.261519mA
+ 0.524ns 0.265509mA
+ 0.526ns 0.269499mA
+ 0.528ns 0.27349mA
+ 0.53ns 0.27748mA
+ 0.532ns 0.28147mA
+ 0.534ns 0.28546mA
+ 0.536ns 0.28945mA
+ 0.538ns 0.293441mA
+ 0.54ns 0.297431mA
+ 0.542ns 0.301421mA
+ 0.544ns 0.305411mA
+ 0.546ns 0.309401mA
+ 0.548ns 0.313392mA
+ 0.55ns 0.317382mA
+ 0.552ns 0.321372mA
+ 0.554ns 0.325362mA
+ 0.556ns 0.329352mA
+ 0.558ns 0.333343mA
+ 0.56ns 0.337333mA
+ 0.562ns 0.341323mA
+ 0.564ns 0.345313mA
+ 0.566ns 0.349303mA
+ 0.568ns 0.353294mA
+ 0.57ns 0.357284mA
+ 0.572ns 0.361274mA
+ 0.574ns 0.365264mA
+ 0.576ns 0.369254mA
+ 0.578ns 0.373244mA
+ 0.58ns 0.377235mA
+ 0.582ns 0.381225mA
+ 0.584ns 0.385215mA
+ 0.586ns 0.389205mA
+ 0.588ns 0.393195mA
+ 0.59ns 0.397186mA
+ 0.592ns 0.401176mA
+ 0.594ns 0.405166mA
+ 0.596ns 0.409156mA
+ 0.598ns 0.413147mA
+ 0.6ns 0.417137mA
+ 0.602ns 0.421127mA
+ 0.604ns 0.425117mA
+ 0.606ns 0.429107mA
+ 0.608ns 0.432277mA
+ 0.61ns 0.430804mA
+ 0.612ns 0.429335mA
+ 0.614ns 0.427871mA
+ 0.616ns 0.426413mA
+ 0.618ns 0.424959mA
+ 0.62ns 0.423511mA
+ 0.622ns 0.422067mA
+ 0.624ns 0.420628mA
+ 0.626ns 0.419194mA
+ 0.628ns 0.417765mA
+ 0.63ns 0.416341mA
+ 0.632ns 0.414921mA
+ 0.634ns 0.413507mA
+ 0.636ns 0.412097mA
+ 0.638ns 0.410693mA
+ 0.64ns 0.409292mA
+ 0.642ns 0.407897mA
+ 0.644ns 0.406507mA
+ 0.646ns 0.405121mA
+ 0.648ns 0.40374mA
+ 0.65ns 0.402363mA
+ 0.652ns 0.400992mA
+ 0.654ns 0.399625mA
+ 0.656ns 0.398262mA
+ 0.658ns 0.396905mA
+ 0.66ns 0.395552mA
+ 0.662ns 0.394203mA
+ 0.664ns 0.392859mA
+ 0.666ns 0.39152mA
+ 0.668ns 0.390185mA
+ 0.67ns 0.388855mA
+ 0.672ns 0.387529mA
+ 0.674ns 0.386208mA
+ 0.676ns 0.384892mA
+ 0.678ns 0.38358mA
+ 0.68ns 0.382272mA
+ 0.682ns 0.380969mA
+ 0.684ns 0.37967mA
+ 0.686ns 0.378376mA
+ 0.688ns 0.377086mA
+ 0.69ns 0.3758mA
+ 0.692ns 0.374519mA
+ 0.694ns 0.373242mA
+ 0.696ns 0.37197mA
+ 0.698ns 0.370702mA
+ 0.7ns 0.369438mA
+ 0.702ns 0.368178mA
+ 0.704ns 0.366923mA
+ 0.706ns 0.365672mA
+ 0.708ns 0.364426mA
+ 0.71ns 0.363183mA
+ 0.712ns 0.361945mA
+ 0.714ns 0.360711mA
+ 0.716ns 0.359482mA
+ 0.718ns 0.358256mA
+ 0.72ns 0.357035mA
+ 0.722ns 0.355818mA
+ 0.724ns 0.354605mA
+ 0.726ns 0.353396mA
+ 0.728ns 0.352191mA
+ 0.73ns 0.35099mA
+ 0.732ns 0.349794mA
+ 0.734ns 0.348601mA
+ 0.736ns 0.347413mA
+ 0.738ns 0.346228mA
+ 0.74ns 0.345048mA
+ 0.742ns 0.343872mA
+ 0.744ns 0.342699mA
+ 0.746ns 0.341531mA
+ 0.748ns 0.340367mA
+ 0.75ns 0.339206mA
+ 0.752ns 0.33805mA
+ 0.754ns 0.336897mA
+ 0.756ns 0.335749mA
+ 0.758ns 0.334604mA
+ 0.76ns 0.333463mA
+ 0.762ns 0.332327mA
+ 0.764ns 0.331194mA
+ 0.766ns 0.330064mA
+ 0.768ns 0.328939mA
+ 0.77ns 0.327818mA
+ 0.772ns 0.3267mA
+ 0.774ns 0.325586mA
+ 0.776ns 0.324476mA
+ 0.778ns 0.32337mA
+ 0.78ns 0.322268mA
+ 0.782ns 0.321169mA
+ 0.784ns 0.320074mA
+ 0.786ns 0.318983mA
+ 0.788ns 0.317895mA
+ 0.79ns 0.316812mA
+ 0.792ns 0.315731mA
+ 0.794ns 0.314655mA
+ 0.796ns 0.313582mA
+ 0.798ns 0.312513mA
+ 0.8ns 0.311448mA
+ 0.802ns 0.310386mA
+ 0.804ns 0.309328mA
+ 0.806ns 0.308273mA
+ 0.808ns 0.307222mA
+ 0.81ns 0.306175mA
+ 0.812ns 0.305131mA
+ 0.814ns 0.304091mA
+ 0.816ns 0.303054mA
+ 0.818ns 0.302021mA
+ 0.82ns 0.300991mA
+ 0.822ns 0.299965mA
+ 0.824ns 0.298942mA
+ 0.826ns 0.297923mA
+ 0.828ns 0.296907mA
+ 0.83ns 0.295895mA
+ 0.832ns 0.294886mA
+ 0.834ns 0.293881mA
+ 0.836ns 0.292879mA
+ 0.838ns 0.29188mA
+ 0.84ns 0.290885mA
+ 0.842ns 0.289894mA
+ 0.844ns 0.288905mA
+ 0.846ns 0.28792mA
+ 0.848ns 0.286939mA
+ 0.85ns 0.28596mA
+ 0.852ns 0.284985mA
+ 0.854ns 0.284014mA
+ 0.856ns 0.283046mA
+ 0.858ns 0.282081mA
+ 0.86ns 0.281119mA
+ 0.862ns 0.28016mA
+ 0.864ns 0.279205mA
+ 0.866ns 0.278253mA
+ 0.868ns 0.277305mA
+ 0.87ns 0.276359mA
+ 0.872ns 0.275417mA
+ 0.874ns 0.274478mA
+ 0.876ns 0.273542mA
+ 0.878ns 0.27261mA
+ 0.88ns 0.27168mA
+ 0.882ns 0.270754mA
+ 0.884ns 0.269831mA
+ 0.886ns 0.268911mA
+ 0.888ns 0.267994mA
+ 0.89ns 0.26708mA
+ 0.892ns 0.26617mA
+ 0.894ns 0.265262mA
+ 0.896ns 0.264358mA
+ 0.898ns 0.263457mA
+ 0.9ns 0.262558mA
+ 0.902ns 0.261663mA
+ 0.904ns 0.260771mA
+ 0.906ns 0.259882mA
+ 0.908ns 0.258996mA
+ 0.91ns 0.258113mA
+ 0.912ns 0.257233mA
+ 0.914ns 0.256356mA
+ 0.916ns 0.255482mA
+ 0.918ns 0.254611mA
+ 0.92ns 0.253743mA
+ 0.922ns 0.252878mA
+ 0.924ns 0.252015mA
+ 0.926ns 0.251156mA
+ 0.928ns 0.2503mA
+ 0.93ns 0.249447mA
+ 0.932ns 0.248596mA
+ 0.934ns 0.247749mA
+ 0.936ns 0.246904mA
+ 0.938ns 0.246062mA
+ 0.94ns 0.245223mA
+ 0.942ns 0.244387mA
+ 0.944ns 0.243554mA
+ 0.946ns 0.242723mA
+ 0.948ns 0.241896mA
+ 0.95ns 0.241071mA
+ 0.952ns 0.240249mA
+ 0.954ns 0.23943mA
+ 0.956ns 0.238614mA
+ 0.958ns 0.2378mA
+ 0.96ns 0.236989mA
+ 0.962ns 0.236181mA
+ 0.964ns 0.235376mA
+ 0.966ns 0.234574mA
+ 0.968ns 0.233774mA
+ 0.97ns 0.232977mA
+ 0.972ns 0.232182mA
+ 0.974ns 0.231391mA
+ 0.976ns 0.230602mA
+ 0.978ns 0.229816mA
+ 0.98ns 0.229032mA
+ 0.982ns 0.228251mA
+ 0.984ns 0.227473mA
+ 0.986ns 0.226697mA
+ 0.988ns 0.225924mA
+ 0.99ns 0.225154mA
+ 0.992ns 0.224386mA
+ 0.994ns 0.223621mA
+ 0.996ns 0.222859mA
+ 0.998ns 0.222099mA
+ 1ns 0.221342mA
+ 1.002ns 0.220587mA
+ 1.004ns 0.219835mA
+ 1.006ns 0.219085mA
+ 1.008ns 0.218339mA
+ 1.01ns 0.217594mA
+ 1.012ns 0.216852mA
+ 1.014ns 0.216113mA
+ 1.016ns 0.215376mA
+ 1.018ns 0.214642mA
+ 1.02ns 0.21391mA
+ 1.022ns 0.21318mA
+ 1.024ns 0.212454mA
+ 1.026ns 0.211729mA
+ 1.028ns 0.211007mA
+ 1.03ns 0.210288mA
+ 1.032ns 0.209571mA
+ 1.034ns 0.208856mA
+ 1.036ns 0.208144mA
+ 1.038ns 0.207434mA
+ 1.04ns 0.206727mA
+ 1.042ns 0.206022mA
+ 1.044ns 0.20532mA
+ 1.046ns 0.20462mA
+ 1.048ns 0.203922mA
+ 1.05ns 0.203227mA
+ 1.052ns 0.202534mA
+ 1.054ns 0.201843mA
+ 1.056ns 0.201155mA
+ 1.058ns 0.200469mA
+ 1.06ns 0.199786mA
+ 1.062ns 0.199105mA
+ 1.064ns 0.198426mA
+ 1.066ns 0.197749mA
+ 1.068ns 0.197075mA
+ 1.07ns 0.196403mA
+ 1.072ns 0.195733mA
+ 1.074ns 0.195066mA
+ 1.076ns 0.194401mA
+ 1.078ns 0.193738mA
+ 1.08ns 0.193077mA
+ 1.082ns 0.192419mA
+ 1.084ns 0.191763mA
+ 1.086ns 0.191109mA
+ 1.088ns 0.190457mA
+ 1.09ns 0.189808mA
+ 1.092ns 0.189161mA
+ 1.094ns 0.188516mA
+ 1.096ns 0.187873mA
+ 1.098ns 0.187233mA
+ 1.1ns 0.186594mA
+ 1.102ns 0.185958mA
+ 1.104ns 0.185324mA
+ 1.106ns 0.184692mA
+ 1.108ns 0.184062mA
+ 1.11ns 0.183435mA
+ 1.112ns 0.182809mA
+ 1.114ns 0.182186mA
+ 1.116ns 0.181565mA
+ 1.118ns 0.180946mA
+ 1.12ns 0.180329mA
+ 1.122ns 0.179714mA
+ 1.124ns 0mA
+ 7.998ns 0mA
+ 8ns 0.217628mA
+ 8.002ns 0.221618mA
+ 8.004ns 0.225608mA
+ 8.006ns 0.229598mA
+ 8.008ns 0.23359mA
+ 8.01ns 0.23758mA
+ 8.012ns 0.241569mA
+ 8.014ns 0.245559mA
+ 8.016ns 0.249549mA
+ 8.018ns 0.253539mA
+ 8.02ns 0.257531mA
+ 8.022ns 0.261521mA
+ 8.024ns 0.265511mA
+ 8.026ns 0.269501mA
+ 8.028ns 0.273491mA
+ 8.03ns 0.27748mA
+ 8.032ns 0.28147mA
+ 8.034ns 0.285462mA
+ 8.036ns 0.289452mA
+ 8.038ns 0.293442mA
+ 8.04ns 0.297432mA
+ 8.042ns 0.301422mA
+ 8.044ns 0.305412mA
+ 8.046ns 0.309402mA
+ 8.048ns 0.313393mA
+ 8.05ns 0.317383mA
+ 8.052ns 0.321373mA
+ 8.054ns 0.325363mA
+ 8.056ns 0.329353mA
+ 8.058ns 0.333343mA
+ 8.06ns 0.337335mA
+ 8.062ns 0.341325mA
+ 8.064ns 0.345315mA
+ 8.066ns 0.349304mA
+ 8.068ns 0.353294mA
+ 8.07ns 0.357284mA
+ 8.072ns 0.361274mA
+ 8.074ns 0.365266mA
+ 8.076ns 0.369256mA
+ 8.078ns 0.373246mA
+ 8.08ns 0.377236mA
+ 8.082ns 0.381226mA
+ 8.084ns 0.385216mA
+ 8.086ns 0.389207mA
+ 8.088ns 0.393197mA
+ 8.09ns 0.397187mA
+ 8.092ns 0.401177mA
+ 8.094ns 0.405167mA
+ 8.096ns 0.409157mA
+ 8.098ns 0.413147mA
+ 8.1ns 0.417139mA
+ 8.102ns 0.421128mA
+ 8.104ns 0.425118mA
+ 8.106ns 0.429108mA
+ 8.108ns 0.432277mA
+ 8.11ns 0.430804mA
+ 8.112ns 0.429334mA
+ 8.114ns 0.427871mA
+ 8.116ns 0.426412mA
+ 8.118ns 0.424959mA
+ 8.12ns 0.42351mA
+ 8.122ns 0.422067mA
+ 8.124ns 0.420628mA
+ 8.126ns 0.419193mA
+ 8.128ns 0.417764mA
+ 8.13ns 0.41634mA
+ 8.132ns 0.414921mA
+ 8.134ns 0.413507mA
+ 8.136ns 0.412097mA
+ 8.138ns 0.410692mA
+ 8.14ns 0.409292mA
+ 8.142ns 0.407897mA
+ 8.144ns 0.406506mA
+ 8.146ns 0.40512mA
+ 8.148ns 0.403739mA
+ 8.15ns 0.402363mA
+ 8.152ns 0.400991mA
+ 8.154ns 0.399624mA
+ 8.156ns 0.398262mA
+ 8.158ns 0.396904mA
+ 8.16ns 0.395551mA
+ 8.162ns 0.394203mA
+ 8.164ns 0.392859mA
+ 8.166ns 0.391519mA
+ 8.168ns 0.390185mA
+ 8.17ns 0.388855mA
+ 8.172ns 0.387529mA
+ 8.174ns 0.386208mA
+ 8.176ns 0.384892mA
+ 8.178ns 0.383579mA
+ 8.18ns 0.382271mA
+ 8.182ns 0.380968mA
+ 8.184ns 0.37967mA
+ 8.186ns 0.378375mA
+ 8.188ns 0.377085mA
+ 8.19ns 0.3758mA
+ 8.192ns 0.374518mA
+ 8.194ns 0.373242mA
+ 8.196ns 0.371969mA
+ 8.198ns 0.370701mA
+ 8.2ns 0.369438mA
+ 8.202ns 0.368178mA
+ 8.204ns 0.366923mA
+ 8.206ns 0.365672mA
+ 8.208ns 0.364425mA
+ 8.21ns 0.363183mA
+ 8.212ns 0.361945mA
+ 8.214ns 0.360711mA
+ 8.216ns 0.359482mA
+ 8.218ns 0.358255mA
+ 8.22ns 0.357034mA
+ 8.222ns 0.355817mA
+ 8.224ns 0.354604mA
+ 8.226ns 0.353395mA
+ 8.228ns 0.352191mA
+ 8.23ns 0.35099mA
+ 8.232ns 0.349793mA
+ 8.234ns 0.348601mA
+ 8.236ns 0.347412mA
+ 8.238ns 0.346228mA
+ 8.24ns 0.345048mA
+ 8.242ns 0.343871mA
+ 8.244ns 0.342699mA
+ 8.246ns 0.34153mA
+ 8.248ns 0.340366mA
+ 8.25ns 0.339206mA
+ 8.252ns 0.33805mA
+ 8.254ns 0.336897mA
+ 8.256ns 0.335749mA
+ 8.258ns 0.334604mA
+ 8.26ns 0.333463mA
+ 8.262ns 0.332326mA
+ 8.264ns 0.331193mA
+ 8.266ns 0.330064mA
+ 8.268ns 0.328939mA
+ 8.27ns 0.327817mA
+ 8.272ns 0.3267mA
+ 8.274ns 0.325586mA
+ 8.276ns 0.324476mA
+ 8.278ns 0.32337mA
+ 8.28ns 0.322268mA
+ 8.282ns 0.321169mA
+ 8.284ns 0.320074mA
+ 8.286ns 0.318982mA
+ 8.288ns 0.317895mA
+ 8.29ns 0.316811mA
+ 8.292ns 0.315731mA
+ 8.294ns 0.314655mA
+ 8.296ns 0.313582mA
+ 8.298ns 0.312513mA
+ 8.3ns 0.311447mA
+ 8.302ns 0.310386mA
+ 8.304ns 0.309328mA
+ 8.306ns 0.308273mA
+ 8.308ns 0.307222mA
+ 8.31ns 0.306174mA
+ 8.312ns 0.305131mA
+ 8.314ns 0.30409mA
+ 8.316ns 0.303054mA
+ 8.318ns 0.302021mA
+ 8.32ns 0.300991mA
+ 8.322ns 0.299965mA
+ 8.324ns 0.298942mA
+ 8.326ns 0.297923mA
+ 8.328ns 0.296907mA
+ 8.33ns 0.295895mA
+ 8.332ns 0.294886mA
+ 8.334ns 0.293881mA
+ 8.336ns 0.292879mA
+ 8.338ns 0.29188mA
+ 8.34ns 0.290885mA
+ 8.342ns 0.289893mA
+ 8.344ns 0.288905mA
+ 8.346ns 0.28792mA
+ 8.348ns 0.286939mA
+ 8.35ns 0.28596mA
+ 8.352ns 0.284985mA
+ 8.354ns 0.284014mA
+ 8.356ns 0.283045mA
+ 8.358ns 0.28208mA
+ 8.36ns 0.281119mA
+ 8.362ns 0.28016mA
+ 8.364ns 0.279205mA
+ 8.366ns 0.278253mA
+ 8.368ns 0.277304mA
+ 8.37ns 0.276359mA
+ 8.372ns 0.275417mA
+ 8.374ns 0.274478mA
+ 8.376ns 0.273542mA
+ 8.378ns 0.272609mA
+ 8.38ns 0.27168mA
+ 8.382ns 0.270754mA
+ 8.384ns 0.269831mA
+ 8.386ns 0.268911mA
+ 8.388ns 0.267994mA
+ 8.39ns 0.26708mA
+ 8.392ns 0.266169mA
+ 8.394ns 0.265262mA
+ 8.396ns 0.264358mA
+ 8.398ns 0.263456mA
+ 8.4ns 0.262558mA
+ 8.402ns 0.261663mA
+ 8.404ns 0.260771mA
+ 8.406ns 0.259882mA
+ 8.408ns 0.258996mA
+ 8.41ns 0.258113mA
+ 8.412ns 0.257233mA
+ 8.414ns 0.256356mA
+ 8.416ns 0.255481mA
+ 8.418ns 0.254611mA
+ 8.42ns 0.253742mA
+ 8.422ns 0.252877mA
+ 8.424ns 0.252015mA
+ 8.426ns 0.251156mA
+ 8.428ns 0.2503mA
+ 8.43ns 0.249446mA
+ 8.432ns 0.248596mA
+ 8.434ns 0.247748mA
+ 8.436ns 0.246904mA
+ 8.438ns 0.246062mA
+ 8.44ns 0.245223mA
+ 8.442ns 0.244387mA
+ 8.444ns 0.243553mA
+ 8.446ns 0.242723mA
+ 8.448ns 0.241896mA
+ 8.45ns 0.241071mA
+ 8.452ns 0.240249mA
+ 8.454ns 0.23943mA
+ 8.456ns 0.238613mA
+ 8.458ns 0.2378mA
+ 8.46ns 0.236989mA
+ 8.462ns 0.236181mA
+ 8.464ns 0.235376mA
+ 8.466ns 0.234573mA
+ 8.468ns 0.233773mA
+ 8.47ns 0.232976mA
+ 8.472ns 0.232182mA
+ 8.474ns 0.231391mA
+ 8.476ns 0.230602mA
+ 8.478ns 0.229815mA
+ 8.48ns 0.229032mA
+ 8.482ns 0.228251mA
+ 8.484ns 0.227473mA
+ 8.486ns 0.226697mA
+ 8.488ns 0.225924mA
+ 8.49ns 0.225154mA
+ 8.492ns 0.224386mA
+ 8.494ns 0.223621mA
+ 8.496ns 0.222859mA
+ 8.498ns 0.222099mA
+ 8.5ns 0.221342mA
+ 8.502ns 0.220587mA
+ 8.504ns 0.219835mA
+ 8.506ns 0.219085mA
+ 8.508ns 0.218338mA
+ 8.51ns 0.217594mA
+ 8.512ns 0.216852mA
+ 8.514ns 0.216113mA
+ 8.516ns 0.215376mA
+ 8.518ns 0.214642mA
+ 8.52ns 0.213909mA
+ 8.522ns 0.21318mA
+ 8.524ns 0.212453mA
+ 8.526ns 0.211729mA
+ 8.528ns 0.211007mA
+ 8.53ns 0.210288mA
+ 8.532ns 0.209571mA
+ 8.534ns 0.208856mA
+ 8.536ns 0.208144mA
+ 8.538ns 0.207434mA
+ 8.54ns 0.206727mA
+ 8.542ns 0.206022mA
+ 8.544ns 0.20532mA
+ 8.546ns 0.204619mA
+ 8.548ns 0.203922mA
+ 8.55ns 0.203227mA
+ 8.552ns 0.202534mA
+ 8.554ns 0.201843mA
+ 8.556ns 0.201155mA
+ 8.558ns 0.200469mA
+ 8.56ns 0.199785mA
+ 8.562ns 0.199104mA
+ 8.564ns 0.198425mA
+ 8.566ns 0.197749mA
+ 8.568ns 0.197075mA
+ 8.57ns 0.196403mA
+ 8.572ns 0.195733mA
+ 8.574ns 0.195066mA
+ 8.576ns 0.194401mA
+ 8.578ns 0.193738mA
+ 8.58ns 0.193077mA
+ 8.582ns 0.192419mA
+ 8.584ns 0.191763mA
+ 8.586ns 0.191109mA
+ 8.588ns 0.190457mA
+ 8.59ns 0.189808mA
+ 8.592ns 0.189161mA
+ 8.594ns 0.188516mA
+ 8.596ns 0.187873mA
+ 8.598ns 0.187232mA
+ 8.6ns 0.186594mA
+ 8.602ns 0.185958mA
+ 8.604ns 0.185324mA
+ 8.606ns 0.184692mA
+ 8.608ns 0.184062mA
+ 8.61ns 0.183435mA
+ 8.612ns 0.182809mA
+ 8.614ns 0.182186mA
+ 8.616ns 0.181564mA
+ 8.618ns 0.180945mA
+ 8.62ns 0.180328mA
+ 8.622ns 0.179714mA
+ 8.624ns 0mA
I69 103 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00345267mA
+ 2.656ns 0.01308mA
+ 2.658ns 0.0227063mA
+ 2.66ns 0.0323336mA
+ 2.662ns 0.0419598mA
+ 2.664ns 0.0515872mA
+ 2.666ns 0.0612146mA
+ 2.668ns 0.0708408mA
+ 2.67ns 0.0804682mA
+ 2.672ns 0.0900944mA
+ 2.674ns 0.0997217mA
+ 2.676ns 0.109349mA
+ 2.678ns 0.118975mA
+ 2.68ns 0.128603mA
+ 2.682ns 0.138229mA
+ 2.684ns 0.138763mA
+ 2.686ns 0.126481mA
+ 2.688ns 0.115286mA
+ 2.69ns 0.105081mA
+ 2.692ns 0.0957788mA
+ 2.694ns 0.0873011mA
+ 2.696ns 0.0795726mA
+ 2.698ns 0.072529mA
+ 2.7ns 0.066108mA
+ 2.702ns 0.0602554mA
+ 2.704ns 0.0549213mA
+ 2.706ns 0.0500588mA
+ 2.708ns 0.0456273mA
+ 2.71ns 0.0415874mA
+ 2.712ns 0.0379052mA
+ 2.714ns 0mA
I70 104 0 PWL 0 0
+ 0.23ns 0mA
+ 0.232ns 0.000143766mA
+ 0.234ns 0.00463343mA
+ 0.236ns 0.0091231mA
+ 0.238ns 0.0136127mA
+ 0.24ns 0.0181024mA
+ 0.242ns 0.0225921mA
+ 0.244ns 0.0270817mA
+ 0.246ns 0.0315714mA
+ 0.248ns 0.036061mA
+ 0.25ns 0.0405507mA
+ 0.252ns 0.0450403mA
+ 0.254ns 0.04953mA
+ 0.256ns 0.0540197mA
+ 0.258ns 0.0585093mA
+ 0.26ns 0.062999mA
+ 0.262ns 0.06642mA
+ 0.264ns 0.0605311mA
+ 0.266ns 0.0551642mA
+ 0.268ns 0.050273mA
+ 0.27ns 0.0458154mA
+ 0.272ns 0.0417529mA
+ 0.274ns 0.0380506mA
+ 0.276ns 0.0346765mA
+ 0.278ns 0.0316015mA
+ 0.28ns 0.0287992mA
+ 0.282ns 0.0262453mA
+ 0.284ns 0.0239178mA
+ 0.286ns 0.0217967mA
+ 0.288ns 0.0198637mA
+ 0.29ns 0.018102mA
+ 0.292ns 0mA
I71 106 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00489826mA
+ 2.656ns 0.0156103mA
+ 2.658ns 0.026321mA
+ 2.66ns 0.037033mA
+ 2.662ns 0.0477437mA
+ 2.664ns 0.0584557mA
+ 2.666ns 0.0691677mA
+ 2.668ns 0.0798784mA
+ 2.67ns 0.0905904mA
+ 2.672ns 0.101301mA
+ 2.674ns 0.112013mA
+ 2.676ns 0.122725mA
+ 2.678ns 0.129621mA
+ 2.68ns 0.115812mA
+ 2.682ns 0.103475mA
+ 2.684ns 0.092451mA
+ 2.686ns 0.082601mA
+ 2.688ns 0.0738013mA
+ 2.69ns 0.0659379mA
+ 2.692ns 0.0589121mA
+ 2.694ns 0.0526355mA
+ 2.696ns 0.0470269mA
+ 2.698ns 0.0420163mA
+ 2.7ns 0.0375389mA
+ 2.702ns 0.0335386mA
+ 2.704ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00489954mA
+ 7.656ns 0.0156103mA
+ 7.658ns 0.026321mA
+ 7.66ns 0.0370317mA
+ 7.662ns 0.047745mA
+ 7.664ns 0.0584557mA
+ 7.666ns 0.0691664mA
+ 7.668ns 0.0798797mA
+ 7.67ns 0.0905904mA
+ 7.672ns 0.101301mA
+ 7.674ns 0.112014mA
+ 7.676ns 0.122725mA
+ 7.678ns 0.129621mA
+ 7.68ns 0.115811mA
+ 7.682ns 0.103474mA
+ 7.684ns 0.092451mA
+ 7.686ns 0.0826021mA
+ 7.688ns 0.0738003mA
+ 7.69ns 0.0659379mA
+ 7.692ns 0.0589129mA
+ 7.694ns 0.0526348mA
+ 7.696ns 0.0470269mA
+ 7.698ns 0.0420163mA
+ 7.7ns 0.0375384mA
+ 7.702ns 0.0335386mA
+ 7.704ns 0mA
I72 108 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.0105469mA
+ 0.156ns 0.0214778mA
+ 0.158ns 0.0324088mA
+ 0.16ns 0.0433399mA
+ 0.162ns 0.0542708mA
+ 0.164ns 0.0652018mA
+ 0.166ns 0.0761329mA
+ 0.168ns 0.0870639mA
+ 0.17ns 0.0979949mA
+ 0.172ns 0.102471mA
+ 0.174ns 0.0888439mA
+ 0.176ns 0.0770284mA
+ 0.178ns 0.0667839mA
+ 0.18ns 0.0579016mA
+ 0.182ns 0.0502004mA
+ 0.184ns 0.0435232mA
+ 0.186ns 0.0377341mA
+ 0.188ns 0.0327148mA
+ 0.19ns 0.028363mA
+ 0.192ns 0mA
I73 109 0 PWL 0 0
+ 2.876ns 0mA
+ 2.878ns 0.00105683mA
+ 2.88ns 0.00497451mA
+ 2.882ns 0.00889173mA
+ 2.884ns 0.0128094mA
+ 2.886ns 0.0167271mA
+ 2.888ns 0.0206443mA
+ 2.89ns 0.024562mA
+ 2.892ns 0.0284792mA
+ 2.894ns 0.0323969mA
+ 2.896ns 0.0363146mA
+ 2.898ns 0.0402318mA
+ 2.9ns 0.0441495mA
+ 2.902ns 0.0480667mA
+ 2.904ns 0.0519844mA
+ 2.906ns 0.0559021mA
+ 2.908ns 0.0598193mA
+ 2.91ns 0.063737mA
+ 2.912ns 0.0676542mA
+ 2.914ns 0.0715719mA
+ 2.916ns 0.0754896mA
+ 2.918ns 0.0794068mA
+ 2.92ns 0.0833244mA
+ 2.922ns 0.0872417mA
+ 2.924ns 0.0911594mA
+ 2.926ns 0.095077mA
+ 2.928ns 0.0989942mA
+ 2.93ns 0.102912mA
+ 2.932ns 0.10683mA
+ 2.934ns 0.110747mA
+ 2.936ns 0.114665mA
+ 2.938ns 0.118582mA
+ 2.94ns 0.122499mA
+ 2.942ns 0.126417mA
+ 2.944ns 0.130334mA
+ 2.946ns 0.134252mA
+ 2.948ns 0.138169mA
+ 2.95ns 0.142087mA
+ 2.952ns 0.146005mA
+ 2.954ns 0.149922mA
+ 2.956ns 0.153839mA
+ 2.958ns 0.157757mA
+ 2.96ns 0.161674mA
+ 2.962ns 0.165592mA
+ 2.964ns 0.169509mA
+ 2.966ns 0.173427mA
+ 2.968ns 0.177344mA
+ 2.97ns 0.181262mA
+ 2.972ns 0.18518mA
+ 2.974ns 0.189097mA
+ 2.976ns 0.193014mA
+ 2.978ns 0.196932mA
+ 2.98ns 0.200849mA
+ 2.982ns 0.204767mA
+ 2.984ns 0.208684mA
+ 2.986ns 0.212602mA
+ 2.988ns 0.21652mA
+ 2.99ns 0.220437mA
+ 2.992ns 0.224355mA
+ 2.994ns 0.228272mA
+ 2.996ns 0.232189mA
+ 2.998ns 0.236107mA
+ 3ns 0.240024mA
+ 3.002ns 0.243942mA
+ 3.004ns 0.247859mA
+ 3.006ns 0.251777mA
+ 3.008ns 0.255695mA
+ 3.01ns 0.259612mA
+ 3.012ns 0.263529mA
+ 3.014ns 0.267447mA
+ 3.016ns 0.271364mA
+ 3.018ns 0.275282mA
+ 3.02ns 0.279199mA
+ 3.022ns 0.283117mA
+ 3.024ns 0.287035mA
+ 3.026ns 0.290952mA
+ 3.028ns 0.29487mA
+ 3.03ns 0.298787mA
+ 3.032ns 0.302704mA
+ 3.034ns 0.306622mA
+ 3.036ns 0.310539mA
+ 3.038ns 0.314457mA
+ 3.04ns 0.318374mA
+ 3.042ns 0.322292mA
+ 3.044ns 0.32621mA
+ 3.046ns 0.330127mA
+ 3.048ns 0.334045mA
+ 3.05ns 0.337962mA
+ 3.052ns 0.341879mA
+ 3.054ns 0.345797mA
+ 3.056ns 0.349714mA
+ 3.058ns 0.353632mA
+ 3.06ns 0.357549mA
+ 3.062ns 0.361467mA
+ 3.064ns 0.365385mA
+ 3.066ns 0.369302mA
+ 3.068ns 0.373219mA
+ 3.07ns 0.377137mA
+ 3.072ns 0.381054mA
+ 3.074ns 0.384972mA
+ 3.076ns 0.388889mA
+ 3.078ns 0.392807mA
+ 3.08ns 0.396725mA
+ 3.082ns 0.400642mA
+ 3.084ns 0.40456mA
+ 3.086ns 0.408477mA
+ 3.088ns 0.412394mA
+ 3.09ns 0.416312mA
+ 3.092ns 0.420229mA
+ 3.094ns 0.424147mA
+ 3.096ns 0.428064mA
+ 3.098ns 0.431982mA
+ 3.1ns 0.435353mA
+ 3.102ns 0.43382mA
+ 3.104ns 0.432291mA
+ 3.106ns 0.430768mA
+ 3.108ns 0.42925mA
+ 3.11ns 0.427737mA
+ 3.112ns 0.42623mA
+ 3.114ns 0.424728mA
+ 3.116ns 0.423232mA
+ 3.118ns 0.421741mA
+ 3.12ns 0.420255mA
+ 3.122ns 0.418774mA
+ 3.124ns 0.417298mA
+ 3.126ns 0.415828mA
+ 3.128ns 0.414363mA
+ 3.13ns 0.412903mA
+ 3.132ns 0.411448mA
+ 3.134ns 0.409998mA
+ 3.136ns 0.408553mA
+ 3.138ns 0.407114mA
+ 3.14ns 0.405679mA
+ 3.142ns 0.40425mA
+ 3.144ns 0.402825mA
+ 3.146ns 0.401406mA
+ 3.148ns 0.399992mA
+ 3.15ns 0.398582mA
+ 3.152ns 0.397178mA
+ 3.154ns 0.395778mA
+ 3.156ns 0.394384mA
+ 3.158ns 0.392994mA
+ 3.16ns 0.391609mA
+ 3.162ns 0.390229mA
+ 3.164ns 0.388854mA
+ 3.166ns 0.387484mA
+ 3.168ns 0.386119mA
+ 3.17ns 0.384758mA
+ 3.172ns 0.383402mA
+ 3.174ns 0.382051mA
+ 3.176ns 0.380705mA
+ 3.178ns 0.379364mA
+ 3.18ns 0.378027mA
+ 3.182ns 0.376695mA
+ 3.184ns 0.375368mA
+ 3.186ns 0.374045mA
+ 3.188ns 0.372727mA
+ 3.19ns 0.371414mA
+ 3.192ns 0.370105mA
+ 3.194ns 0.368801mA
+ 3.196ns 0.367501mA
+ 3.198ns 0.366206mA
+ 3.2ns 0.364916mA
+ 3.202ns 0.36363mA
+ 3.204ns 0.362349mA
+ 3.206ns 0.361072mA
+ 3.208ns 0.3598mA
+ 3.21ns 0.358532mA
+ 3.212ns 0.357268mA
+ 3.214ns 0.35601mA
+ 3.216ns 0.354755mA
+ 3.218ns 0.353505mA
+ 3.22ns 0.352259mA
+ 3.222ns 0.351018mA
+ 3.224ns 0.349781mA
+ 3.226ns 0.348549mA
+ 3.228ns 0.34732mA
+ 3.23ns 0.346097mA
+ 3.232ns 0.344877mA
+ 3.234ns 0.343662mA
+ 3.236ns 0.342451mA
+ 3.238ns 0.341244mA
+ 3.24ns 0.340042mA
+ 3.242ns 0.338843mA
+ 3.244ns 0.337649mA
+ 3.246ns 0.33646mA
+ 3.248ns 0.335274mA
+ 3.25ns 0.334093mA
+ 3.252ns 0.332915mA
+ 3.254ns 0.331742mA
+ 3.256ns 0.330573mA
+ 3.258ns 0.329408mA
+ 3.26ns 0.328248mA
+ 3.262ns 0.327091mA
+ 3.264ns 0.325938mA
+ 3.266ns 0.32479mA
+ 3.268ns 0.323645mA
+ 3.27ns 0.322505mA
+ 3.272ns 0.321368mA
+ 3.274ns 0.320236mA
+ 3.276ns 0.319108mA
+ 3.278ns 0.317983mA
+ 3.28ns 0.316863mA
+ 3.282ns 0.315746mA
+ 3.284ns 0.314633mA
+ 3.286ns 0.313525mA
+ 3.288ns 0.31242mA
+ 3.29ns 0.311319mA
+ 3.292ns 0.310222mA
+ 3.294ns 0.309129mA
+ 3.296ns 0.308039mA
+ 3.298ns 0.306954mA
+ 3.3ns 0.305872mA
+ 3.302ns 0.304794mA
+ 3.304ns 0.30372mA
+ 3.306ns 0.30265mA
+ 3.308ns 0.301584mA
+ 3.31ns 0.300521mA
+ 3.312ns 0.299462mA
+ 3.314ns 0.298407mA
+ 3.316ns 0.297355mA
+ 3.318ns 0.296307mA
+ 3.32ns 0.295263mA
+ 3.322ns 0.294223mA
+ 3.324ns 0.293186mA
+ 3.326ns 0.292153mA
+ 3.328ns 0.291123mA
+ 3.33ns 0.290097mA
+ 3.332ns 0.289075mA
+ 3.334ns 0.288056mA
+ 3.336ns 0.287041mA
+ 3.338ns 0.28603mA
+ 3.34ns 0.285022mA
+ 3.342ns 0.284017mA
+ 3.344ns 0.283017mA
+ 3.346ns 0.282019mA
+ 3.348ns 0.281025mA
+ 3.35ns 0.280035mA
+ 3.352ns 0.279048mA
+ 3.354ns 0.278065mA
+ 3.356ns 0.277085mA
+ 3.358ns 0.276109mA
+ 3.36ns 0.275136mA
+ 3.362ns 0.274166mA
+ 3.364ns 0.2732mA
+ 3.366ns 0.272237mA
+ 3.368ns 0.271278mA
+ 3.37ns 0.270322mA
+ 3.372ns 0.269369mA
+ 3.374ns 0.26842mA
+ 3.376ns 0.267474mA
+ 3.378ns 0.266532mA
+ 3.38ns 0.265592mA
+ 3.382ns 0.264656mA
+ 3.384ns 0.263724mA
+ 3.386ns 0.262794mA
+ 3.388ns 0.261868mA
+ 3.39ns 0.260945mA
+ 3.392ns 0.260026mA
+ 3.394ns 0.25911mA
+ 3.396ns 0.258196mA
+ 3.398ns 0.257287mA
+ 3.4ns 0.25638mA
+ 3.402ns 0.255477mA
+ 3.404ns 0.254576mA
+ 3.406ns 0.253679mA
+ 3.408ns 0.252785mA
+ 3.41ns 0.251894mA
+ 3.412ns 0.251007mA
+ 3.414ns 0.250122mA
+ 3.416ns 0.249241mA
+ 3.418ns 0.248362mA
+ 3.42ns 0.247487mA
+ 3.422ns 0.246615mA
+ 3.424ns 0.245746mA
+ 3.426ns 0.24488mA
+ 3.428ns 0.244017mA
+ 3.43ns 0.243157mA
+ 3.432ns 0.2423mA
+ 3.434ns 0.241446mA
+ 3.436ns 0.240595mA
+ 3.438ns 0.239747mA
+ 3.44ns 0.238903mA
+ 3.442ns 0.238061mA
+ 3.444ns 0.237222mA
+ 3.446ns 0.236386mA
+ 3.448ns 0.235553mA
+ 3.45ns 0.234723mA
+ 3.452ns 0.233895mA
+ 3.454ns 0.233071mA
+ 3.456ns 0.23225mA
+ 3.458ns 0.231431mA
+ 3.46ns 0.230616mA
+ 3.462ns 0.229803mA
+ 3.464ns 0.228993mA
+ 3.466ns 0.228186mA
+ 3.468ns 0.227382mA
+ 3.47ns 0.226581mA
+ 3.472ns 0.225782mA
+ 3.474ns 0.224987mA
+ 3.476ns 0.224194mA
+ 3.478ns 0.223404mA
+ 3.48ns 0.222616mA
+ 3.482ns 0.221832mA
+ 3.484ns 0.22105mA
+ 3.486ns 0.220271mA
+ 3.488ns 0.219495mA
+ 3.49ns 0.218721mA
+ 3.492ns 0.21795mA
+ 3.494ns 0.217182mA
+ 3.496ns 0.216417mA
+ 3.498ns 0.215654mA
+ 3.5ns 0.214894mA
+ 3.502ns 0.214137mA
+ 3.504ns 0.213382mA
+ 3.506ns 0.21263mA
+ 3.508ns 0.211881mA
+ 3.51ns 0.211134mA
+ 3.512ns 0.21039mA
+ 3.514ns 0.209649mA
+ 3.516ns 0.20891mA
+ 3.518ns 0.208174mA
+ 3.52ns 0.20744mA
+ 3.522ns 0.206709mA
+ 3.524ns 0.20598mA
+ 3.526ns 0.205255mA
+ 3.528ns 0.204531mA
+ 3.53ns 0.20381mA
+ 3.532ns 0.203092mA
+ 3.534ns 0.202376mA
+ 3.536ns 0.201663mA
+ 3.538ns 0.200953mA
+ 3.54ns 0.200244mA
+ 3.542ns 0.199539mA
+ 3.544ns 0.198835mA
+ 3.546ns 0.198135mA
+ 3.548ns 0.197436mA
+ 3.55ns 0.196741mA
+ 3.552ns 0.196047mA
+ 3.554ns 0.195356mA
+ 3.556ns 0.194668mA
+ 3.558ns 0.193982mA
+ 3.56ns 0.193298mA
+ 3.562ns 0.192617mA
+ 3.564ns 0.191938mA
+ 3.566ns 0.191262mA
+ 3.568ns 0.190588mA
+ 3.57ns 0.189916mA
+ 3.572ns 0.189247mA
+ 3.574ns 0.18858mA
+ 3.576ns 0.187915mA
+ 3.578ns 0.187253mA
+ 3.58ns 0.186593mA
+ 3.582ns 0.185935mA
+ 3.584ns 0.18528mA
+ 3.586ns 0.184627mA
+ 3.588ns 0.183976mA
+ 3.59ns 0.183328mA
+ 3.592ns 0.182682mA
+ 3.594ns 0.182038mA
+ 3.596ns 0.181396mA
+ 3.598ns 0.180757mA
+ 3.6ns 0.18012mA
+ 3.602ns 0.179485mA
+ 3.604ns 0mA
I74 110 0 PWL 0 0
+ 3.128ns 0mA
+ 3.13ns 0.000877836mA
+ 3.132ns 0.00223959mA
+ 3.134ns 0.00360152mA
+ 3.136ns 0.00496344mA
+ 3.138ns 0.0063252mA
+ 3.14ns 0.00768712mA
+ 3.142ns 0.00904888mA
+ 3.144ns 0.0104108mA
+ 3.146ns 0.0117727mA
+ 3.148ns 0.0131345mA
+ 3.15ns 0.0144964mA
+ 3.152ns 0.0158582mA
+ 3.154ns 0.0160995mA
+ 3.156ns 0.0157442mA
+ 3.158ns 0.0153967mA
+ 3.16ns 0.0150569mA
+ 3.162ns 0.0147246mA
+ 3.164ns 0.0143996mA
+ 3.166ns 0.0140817mA
+ 3.168ns 0.013771mA
+ 3.17ns 0.013467mA
+ 3.172ns 0.0131697mA
+ 3.174ns 0.0128791mA
+ 3.176ns 0.0125948mA
+ 3.178ns 0.0123168mA
+ 3.18ns 0.0120449mA
+ 3.182ns 0.0117791mA
+ 3.184ns 0.0115191mA
+ 3.186ns 0.0112648mA
+ 3.188ns 0.0110162mA
+ 3.19ns 0.010773mA
+ 3.192ns 0.0105352mA
+ 3.194ns 0.0103027mA
+ 3.196ns 0.0100753mA
+ 3.198ns 0.00985288mA
+ 3.2ns 0.00963538mA
+ 3.202ns 0.00942269mA
+ 3.204ns 0.00921471mA
+ 3.206ns 0.00901129mA
+ 3.208ns 0.00881239mA
+ 3.21ns 0.00861785mA
+ 3.212ns 0.00842761mA
+ 3.214ns 0.00824159mA
+ 3.216ns 0.00805965mA
+ 3.218ns 0.00788173mA
+ 3.22ns 0.00770776mA
+ 3.222ns 0.0075376mA
+ 3.224ns 0.00737122mA
+ 3.226ns 0.00720849mA
+ 3.228ns 0mA
I75 121 0 PWL 0 0
+ 5.632ns 0mA
+ 5.634ns 0.000753242mA
+ 5.636ns 0.00178581mA
+ 5.638ns 0.00281838mA
+ 5.64ns 0.00385095mA
+ 5.642ns 0.00488376mA
+ 5.644ns 0.00591633mA
+ 5.646ns 0.0069489mA
+ 5.648ns 0.00798172mA
+ 5.65ns 0.00901429mA
+ 5.652ns 0.0100469mA
+ 5.654ns 0.0110797mA
+ 5.656ns 0.0116542mA
+ 5.658ns 0.0113832mA
+ 5.66ns 0.0111186mA
+ 5.662ns 0.01086mA
+ 5.664ns 0.0106075mA
+ 5.666ns 0.0103609mA
+ 5.668ns 0.01012mA
+ 5.67ns 0.00988467mA
+ 5.672ns 0.00965485mA
+ 5.674ns 0.00943032mA
+ 5.676ns 0.00921107mA
+ 5.678ns 0.00899691mA
+ 5.68ns 0.00878768mA
+ 5.682ns 0.00858336mA
+ 5.684ns 0.00838379mA
+ 5.686ns 0.00818886mA
+ 5.688ns 0.00799842mA
+ 5.69ns 0.00781245mA
+ 5.692ns 0.0076308mA
+ 5.694ns 0.00745333mA
+ 5.696ns 0.00728003mA
+ 5.698ns 0.00711076mA
+ 5.7ns 0.00694538mA
+ 5.702ns 0.00678389mA
+ 5.704ns 0.00662615mA
+ 5.706ns 0.00647208mA
+ 5.708ns 0.00632156mA
+ 5.71ns 0.00617456mA
+ 5.712ns 0.00603099mA
+ 5.714ns 0.00589072mA
+ 5.716ns 0.00575375mA
+ 5.718ns 0.00561996mA
+ 5.72ns 0.00548924mA
+ 5.722ns 0.0053616mA
+ 5.724ns 0.00523693mA
+ 5.726ns 0mA
I76 122 0 PWL 0 0
+ 5.726ns 0mA
+ 5.728ns 0.028464mA
+ 5.73ns 0.0491169mA
+ 5.732ns 0.0459921mA
+ 5.734ns 0.0430653mA
+ 5.736ns 0.0403254mA
+ 5.738ns 0.0377597mA
+ 5.74ns 0.0353567mA
+ 5.742ns 0.0331071mA
+ 5.744ns 0.0310006mA
+ 5.746ns 0.0290276mA
+ 5.748ns 0.0271806mA
+ 5.75ns 0mA
I77 123 0 PWL 0 0
+ 0.256ns 0mA
+ 0.258ns 0.00383459mA
+ 0.26ns 0.0101536mA
+ 0.262ns 0.0164726mA
+ 0.264ns 0.0227915mA
+ 0.266ns 0.0291105mA
+ 0.268ns 0.0354296mA
+ 0.27ns 0.0417486mA
+ 0.272ns 0.0480676mA
+ 0.274ns 0.0543866mA
+ 0.276ns 0.0547771mA
+ 0.278ns 0.0471198mA
+ 0.28ns 0.0405329mA
+ 0.282ns 0.0348664mA
+ 0.284ns 0.029992mA
+ 0.286ns 0.0257988mA
+ 0.288ns 0.0221918mA
+ 0.29ns 0.019089mA
+ 0.292ns 0.0164199mA
+ 0.294ns 0mA
+ 3.176ns 0mA
+ 3.178ns 0.0032025mA
+ 3.18ns 0.00952179mA
+ 3.182ns 0.0158411mA
+ 3.184ns 0.0221596mA
+ 3.186ns 0.0284789mA
+ 3.188ns 0.0347975mA
+ 3.19ns 0.0411167mA
+ 3.192ns 0.047436mA
+ 3.194ns 0.0537546mA
+ 3.196ns 0.0556079mA
+ 3.198ns 0.0478351mA
+ 3.2ns 0.0411478mA
+ 3.202ns 0.0353951mA
+ 3.204ns 0.0304471mA
+ 3.206ns 0.0261902mA
+ 3.208ns 0.0225287mA
+ 3.21ns 0.0193787mA
+ 3.212ns 0.016669mA
+ 3.214ns 0mA
I78 129 0 PWL 0 0
+ 5.134ns 0mA
+ 5.136ns 0.00203645mA
+ 5.138ns 0.00666113mA
+ 5.14ns 0.0112858mA
+ 5.142ns 0.0159116mA
+ 5.144ns 0.0205363mA
+ 5.146ns 0.025161mA
+ 5.148ns 0.0297867mA
+ 5.15ns 0.0344114mA
+ 5.152ns 0.0390361mA
+ 5.154ns 0.0436619mA
+ 5.156ns 0.0482866mA
+ 5.158ns 0.0529112mA
+ 5.16ns 0.0575359mA
+ 5.162ns 0.0621617mA
+ 5.164ns 0.0667864mA
+ 5.166ns 0.0714111mA
+ 5.168ns 0.0760368mA
+ 5.17ns 0.0806615mA
+ 5.172ns 0.0852862mA
+ 5.174ns 0.089912mA
+ 5.176ns 0.0945367mA
+ 5.178ns 0.0977948mA
+ 5.18ns 0.0934239mA
+ 5.182ns 0.0892474mA
+ 5.184ns 0.0852584mA
+ 5.186ns 0.0814477mA
+ 5.188ns 0.0778064mA
+ 5.19ns 0.0743287mA
+ 5.192ns 0.0710064mA
+ 5.194ns 0.0678318mA
+ 5.196ns 0.0647998mA
+ 5.198ns 0.0619033mA
+ 5.2ns 0.0591356mA
+ 5.202ns 0.0564923mA
+ 5.204ns 0.053967mA
+ 5.206ns 0.0515547mA
+ 5.208ns 0.0492496mA
+ 5.21ns 0.047048mA
+ 5.212ns 0.0449449mA
+ 5.214ns 0.0429352mA
+ 5.216ns 0.0410159mA
+ 5.218ns 0.0391823mA
+ 5.22ns 0.0374303mA
+ 5.222ns 0.035757mA
+ 5.224ns 0.0341584mA
+ 5.226ns 0.0326314mA
+ 5.228ns 0.0311722mA
+ 5.23ns 0mA
I79 130 0 PWL 0 0
+ 2.88ns 0mA
+ 2.882ns 0.0023285mA
+ 2.884ns 0.00618379mA
+ 2.886ns 0.0100391mA
+ 2.888ns 0.0138939mA
+ 2.89ns 0.0177492mA
+ 2.892ns 0.021604mA
+ 2.894ns 0.0254593mA
+ 2.896ns 0.0293146mA
+ 2.898ns 0.0331694mA
+ 2.9ns 0.0370247mA
+ 2.902ns 0.0408795mA
+ 2.904ns 0.0447348mA
+ 2.906ns 0.0485901mA
+ 2.908ns 0.0524449mA
+ 2.91ns 0.0563002mA
+ 2.912ns 0.0601551mA
+ 2.914ns 0.0640103mA
+ 2.916ns 0.0678656mA
+ 2.918ns 0.0717205mA
+ 2.92ns 0.0755758mA
+ 2.922ns 0.0794306mA
+ 2.924ns 0.0832859mA
+ 2.926ns 0.0871412mA
+ 2.928ns 0.090996mA
+ 2.93ns 0.0948513mA
+ 2.932ns 0.0987066mA
+ 2.934ns 0.102561mA
+ 2.936ns 0.106417mA
+ 2.938ns 0.110272mA
+ 2.94ns 0.114127mA
+ 2.942ns 0.117982mA
+ 2.944ns 0.121837mA
+ 2.946ns 0.125692mA
+ 2.948ns 0.129547mA
+ 2.95ns 0.133402mA
+ 2.952ns 0.137258mA
+ 2.954ns 0.141112mA
+ 2.956ns 0.144968mA
+ 2.958ns 0.148823mA
+ 2.96ns 0.152678mA
+ 2.962ns 0.156533mA
+ 2.964ns 0.160388mA
+ 2.966ns 0.164243mA
+ 2.968ns 0.168098mA
+ 2.97ns 0.171953mA
+ 2.972ns 0.175809mA
+ 2.974ns 0.179663mA
+ 2.976ns 0.183519mA
+ 2.978ns 0.187374mA
+ 2.98ns 0.191229mA
+ 2.982ns 0.195084mA
+ 2.984ns 0.198939mA
+ 2.986ns 0.202794mA
+ 2.988ns 0.20665mA
+ 2.99ns 0.210504mA
+ 2.992ns 0.21436mA
+ 2.994ns 0.218215mA
+ 2.996ns 0.22207mA
+ 2.998ns 0.225925mA
+ 3ns 0.22978mA
+ 3.002ns 0.233635mA
+ 3.004ns 0.23749mA
+ 3.006ns 0.241345mA
+ 3.008ns 0.245201mA
+ 3.01ns 0.249055mA
+ 3.012ns 0.252911mA
+ 3.014ns 0.256766mA
+ 3.016ns 0.260621mA
+ 3.018ns 0.264476mA
+ 3.02ns 0.268331mA
+ 3.022ns 0.272186mA
+ 3.024ns 0.276042mA
+ 3.026ns 0.279896mA
+ 3.028ns 0.283752mA
+ 3.03ns 0.287606mA
+ 3.032ns 0.291462mA
+ 3.034ns 0.295317mA
+ 3.036ns 0.299172mA
+ 3.038ns 0.303027mA
+ 3.04ns 0.306882mA
+ 3.042ns 0.310737mA
+ 3.044ns 0.314593mA
+ 3.046ns 0.318447mA
+ 3.048ns 0.322303mA
+ 3.05ns 0.326158mA
+ 3.052ns 0.330013mA
+ 3.054ns 0.333868mA
+ 3.056ns 0.337723mA
+ 3.058ns 0.341578mA
+ 3.06ns 0.345433mA
+ 3.062ns 0.349288mA
+ 3.064ns 0.353144mA
+ 3.066ns 0.356998mA
+ 3.068ns 0.360854mA
+ 3.07ns 0.364709mA
+ 3.072ns 0.368564mA
+ 3.074ns 0.372419mA
+ 3.076ns 0.376274mA
+ 3.078ns 0.380129mA
+ 3.08ns 0.383985mA
+ 3.082ns 0.387839mA
+ 3.084ns 0.391695mA
+ 3.086ns 0.395549mA
+ 3.088ns 0.399405mA
+ 3.09ns 0.40326mA
+ 3.092ns 0.407115mA
+ 3.094ns 0.41097mA
+ 3.096ns 0.414825mA
+ 3.098ns 0.41868mA
+ 3.1ns 0.422536mA
+ 3.102ns 0.42639mA
+ 3.104ns 0.430246mA
+ 3.106ns 0.432228mA
+ 3.108ns 0.430737mA
+ 3.11ns 0.429251mA
+ 3.112ns 0.42777mA
+ 3.114ns 0.426294mA
+ 3.116ns 0.424823mA
+ 3.118ns 0.423357mA
+ 3.12ns 0.421896mA
+ 3.122ns 0.420441mA
+ 3.124ns 0.41899mA
+ 3.126ns 0.417545mA
+ 3.128ns 0.416104mA
+ 3.13ns 0.414668mA
+ 3.132ns 0.413238mA
+ 3.134ns 0.411812mA
+ 3.136ns 0.410391mA
+ 3.138ns 0.408975mA
+ 3.14ns 0.407564mA
+ 3.142ns 0.406158mA
+ 3.144ns 0.404757mA
+ 3.146ns 0.40336mA
+ 3.148ns 0.401968mA
+ 3.15ns 0.400581mA
+ 3.152ns 0.399199mA
+ 3.154ns 0.397822mA
+ 3.156ns 0.396449mA
+ 3.158ns 0.395082mA
+ 3.16ns 0.393718mA
+ 3.162ns 0.39236mA
+ 3.164ns 0.391006mA
+ 3.166ns 0.389657mA
+ 3.168ns 0.388313mA
+ 3.17ns 0.386973mA
+ 3.172ns 0.385638mA
+ 3.174ns 0.384307mA
+ 3.176ns 0.382981mA
+ 3.178ns 0.38166mA
+ 3.18ns 0.380343mA
+ 3.182ns 0.379031mA
+ 3.184ns 0.377723mA
+ 3.186ns 0.37642mA
+ 3.188ns 0.375121mA
+ 3.19ns 0.373827mA
+ 3.192ns 0.372537mA
+ 3.194ns 0.371251mA
+ 3.196ns 0.36997mA
+ 3.198ns 0.368694mA
+ 3.2ns 0.367422mA
+ 3.202ns 0.366154mA
+ 3.204ns 0.364891mA
+ 3.206ns 0.363632mA
+ 3.208ns 0.362377mA
+ 3.21ns 0.361127mA
+ 3.212ns 0.359881mA
+ 3.214ns 0.358639mA
+ 3.216ns 0.357402mA
+ 3.218ns 0.356168mA
+ 3.22ns 0.35494mA
+ 3.222ns 0.353715mA
+ 3.224ns 0.352495mA
+ 3.226ns 0.351278mA
+ 3.228ns 0.350066mA
+ 3.23ns 0.348858mA
+ 3.232ns 0.347655mA
+ 3.234ns 0.346455mA
+ 3.236ns 0.34526mA
+ 3.238ns 0.344068mA
+ 3.24ns 0.342881mA
+ 3.242ns 0.341698mA
+ 3.244ns 0.340519mA
+ 3.246ns 0.339344mA
+ 3.248ns 0.338173mA
+ 3.25ns 0.337007mA
+ 3.252ns 0.335844mA
+ 3.254ns 0.334685mA
+ 3.256ns 0.33353mA
+ 3.258ns 0.332379mA
+ 3.26ns 0.331233mA
+ 3.262ns 0.33009mA
+ 3.264ns 0.328951mA
+ 3.266ns 0.327816mA
+ 3.268ns 0.326685mA
+ 3.27ns 0.325557mA
+ 3.272ns 0.324434mA
+ 3.274ns 0.323315mA
+ 3.276ns 0.322199mA
+ 3.278ns 0.321087mA
+ 3.28ns 0.319979mA
+ 3.282ns 0.318875mA
+ 3.284ns 0.317775mA
+ 3.286ns 0.316679mA
+ 3.288ns 0.315586mA
+ 3.29ns 0.314497mA
+ 3.292ns 0.313412mA
+ 3.294ns 0.31233mA
+ 3.296ns 0.311253mA
+ 3.298ns 0.310179mA
+ 3.3ns 0.309109mA
+ 3.302ns 0.308042mA
+ 3.304ns 0.306979mA
+ 3.306ns 0.30592mA
+ 3.308ns 0.304864mA
+ 3.31ns 0.303812mA
+ 3.312ns 0.302764mA
+ 3.314ns 0.301719mA
+ 3.316ns 0.300678mA
+ 3.318ns 0.299641mA
+ 3.32ns 0.298607mA
+ 3.322ns 0.297577mA
+ 3.324ns 0.29655mA
+ 3.326ns 0.295527mA
+ 3.328ns 0.294507mA
+ 3.33ns 0.29349mA
+ 3.332ns 0.292478mA
+ 3.334ns 0.291469mA
+ 3.336ns 0.290463mA
+ 3.338ns 0.289461mA
+ 3.34ns 0.288462mA
+ 3.342ns 0.287467mA
+ 3.344ns 0.286475mA
+ 3.346ns 0.285486mA
+ 3.348ns 0.284501mA
+ 3.35ns 0.283519mA
+ 3.352ns 0.282541mA
+ 3.354ns 0.281566mA
+ 3.356ns 0.280595mA
+ 3.358ns 0.279626mA
+ 3.36ns 0.278661mA
+ 3.362ns 0.2777mA
+ 3.364ns 0.276742mA
+ 3.366ns 0.275787mA
+ 3.368ns 0.274835mA
+ 3.37ns 0.273887mA
+ 3.372ns 0.272942mA
+ 3.374ns 0.272mA
+ 3.376ns 0.271061mA
+ 3.378ns 0.270126mA
+ 3.38ns 0.269194mA
+ 3.382ns 0.268265mA
+ 3.384ns 0.267339mA
+ 3.386ns 0.266417mA
+ 3.388ns 0.265498mA
+ 3.39ns 0.264582mA
+ 3.392ns 0.263669mA
+ 3.394ns 0.262759mA
+ 3.396ns 0.261852mA
+ 3.398ns 0.260949mA
+ 3.4ns 0.260048mA
+ 3.402ns 0.259151mA
+ 3.404ns 0.258257mA
+ 3.406ns 0.257365mA
+ 3.408ns 0.256477mA
+ 3.41ns 0.255592mA
+ 3.412ns 0.25471mA
+ 3.414ns 0.253832mA
+ 3.416ns 0.252956mA
+ 3.418ns 0.252083mA
+ 3.42ns 0.251213mA
+ 3.422ns 0.250346mA
+ 3.424ns 0.249482mA
+ 3.426ns 0.248621mA
+ 3.428ns 0.247763mA
+ 3.43ns 0.246908mA
+ 3.432ns 0.246056mA
+ 3.434ns 0.245207mA
+ 3.436ns 0.244361mA
+ 3.438ns 0.243518mA
+ 3.44ns 0.242678mA
+ 3.442ns 0.24184mA
+ 3.444ns 0.241006mA
+ 3.446ns 0.240174mA
+ 3.448ns 0.239346mA
+ 3.45ns 0.23852mA
+ 3.452ns 0.237696mA
+ 3.454ns 0.236876mA
+ 3.456ns 0.236059mA
+ 3.458ns 0.235244mA
+ 3.46ns 0.234433mA
+ 3.462ns 0.233624mA
+ 3.464ns 0.232817mA
+ 3.466ns 0.232014mA
+ 3.468ns 0.231213mA
+ 3.47ns 0.230416mA
+ 3.472ns 0.22962mA
+ 3.474ns 0.228828mA
+ 3.476ns 0.228039mA
+ 3.478ns 0.227252mA
+ 3.48ns 0.226467mA
+ 3.482ns 0.225686mA
+ 3.484ns 0.224907mA
+ 3.486ns 0.224131mA
+ 3.488ns 0.223358mA
+ 3.49ns 0.222587mA
+ 3.492ns 0.221819mA
+ 3.494ns 0.221053mA
+ 3.496ns 0.220291mA
+ 3.498ns 0.21953mA
+ 3.5ns 0.218773mA
+ 3.502ns 0.218018mA
+ 3.504ns 0.217266mA
+ 3.506ns 0.216516mA
+ 3.508ns 0.215769mA
+ 3.51ns 0.215024mA
+ 3.512ns 0.214282mA
+ 3.514ns 0.213543mA
+ 3.516ns 0.212806mA
+ 3.518ns 0.212071mA
+ 3.52ns 0.21134mA
+ 3.522ns 0.21061mA
+ 3.524ns 0.209884mA
+ 3.526ns 0.209159mA
+ 3.528ns 0.208438mA
+ 3.53ns 0.207718mA
+ 3.532ns 0.207001mA
+ 3.534ns 0.206287mA
+ 3.536ns 0.205575mA
+ 3.538ns 0.204866mA
+ 3.54ns 0.204159mA
+ 3.542ns 0.203454mA
+ 3.544ns 0.202752mA
+ 3.546ns 0.202053mA
+ 3.548ns 0.201355mA
+ 3.55ns 0.200661mA
+ 3.552ns 0.199968mA
+ 3.554ns 0.199278mA
+ 3.556ns 0.19859mA
+ 3.558ns 0.197905mA
+ 3.56ns 0.197222mA
+ 3.562ns 0.196542mA
+ 3.564ns 0.195863mA
+ 3.566ns 0.195187mA
+ 3.568ns 0.194514mA
+ 3.57ns 0.193843mA
+ 3.572ns 0.193174mA
+ 3.574ns 0.192507mA
+ 3.576ns 0.191843mA
+ 3.578ns 0.191181mA
+ 3.58ns 0.190521mA
+ 3.582ns 0.189864mA
+ 3.584ns 0.189208mA
+ 3.586ns 0.188555mA
+ 3.588ns 0.187905mA
+ 3.59ns 0.187256mA
+ 3.592ns 0.18661mA
+ 3.594ns 0.185966mA
+ 3.596ns 0.185324mA
+ 3.598ns 0.184685mA
+ 3.6ns 0.184047mA
+ 3.602ns 0.183412mA
+ 3.604ns 0.182779mA
+ 3.606ns 0.182149mA
+ 3.608ns 0.18152mA
+ 3.61ns 0.180894mA
+ 3.612ns 0.180269mA
+ 3.614ns 0.179647mA
+ 3.616ns 0.179027mA
+ 3.618ns 0.17841mA
+ 3.62ns 0mA
+ 7.998ns 0mA
+ 8ns 0.22978mA
+ 8.002ns 0.233635mA
+ 8.004ns 0.23749mA
+ 8.006ns 0.241344mA
+ 8.008ns 0.245201mA
+ 8.01ns 0.249056mA
+ 8.012ns 0.252911mA
+ 8.014ns 0.256766mA
+ 8.016ns 0.26062mA
+ 8.018ns 0.264475mA
+ 8.02ns 0.268332mA
+ 8.022ns 0.272187mA
+ 8.024ns 0.276042mA
+ 8.026ns 0.279896mA
+ 8.028ns 0.283751mA
+ 8.03ns 0.287606mA
+ 8.032ns 0.291461mA
+ 8.034ns 0.295318mA
+ 8.036ns 0.299172mA
+ 8.038ns 0.303027mA
+ 8.04ns 0.306882mA
+ 8.042ns 0.310737mA
+ 8.044ns 0.314592mA
+ 8.046ns 0.318446mA
+ 8.048ns 0.322303mA
+ 8.05ns 0.326158mA
+ 8.052ns 0.330013mA
+ 8.054ns 0.333868mA
+ 8.056ns 0.337722mA
+ 8.058ns 0.341577mA
+ 8.06ns 0.345434mA
+ 8.062ns 0.349289mA
+ 8.064ns 0.353144mA
+ 8.066ns 0.356998mA
+ 8.068ns 0.360853mA
+ 8.07ns 0.364708mA
+ 8.072ns 0.368563mA
+ 8.074ns 0.37242mA
+ 8.076ns 0.376274mA
+ 8.078ns 0.380129mA
+ 8.08ns 0.383984mA
+ 8.082ns 0.387839mA
+ 8.084ns 0.391694mA
+ 8.086ns 0.39555mA
+ 8.088ns 0.399405mA
+ 8.09ns 0.40326mA
+ 8.092ns 0.407115mA
+ 8.094ns 0.41097mA
+ 8.096ns 0.414825mA
+ 8.098ns 0.418679mA
+ 8.1ns 0.422536mA
+ 8.102ns 0.426391mA
+ 8.104ns 0.430246mA
+ 8.106ns 0.432228mA
+ 8.108ns 0.430737mA
+ 8.11ns 0.429251mA
+ 8.112ns 0.427769mA
+ 8.114ns 0.426294mA
+ 8.116ns 0.424823mA
+ 8.118ns 0.423357mA
+ 8.12ns 0.421897mA
+ 8.122ns 0.420441mA
+ 8.124ns 0.418991mA
+ 8.126ns 0.417544mA
+ 8.128ns 0.416104mA
+ 8.13ns 0.414668mA
+ 8.132ns 0.413238mA
+ 8.134ns 0.411812mA
+ 8.136ns 0.410391mA
+ 8.138ns 0.408976mA
+ 8.14ns 0.407564mA
+ 8.142ns 0.406158mA
+ 8.144ns 0.404757mA
+ 8.146ns 0.40336mA
+ 8.148ns 0.401969mA
+ 8.15ns 0.400582mA
+ 8.152ns 0.399199mA
+ 8.154ns 0.397822mA
+ 8.156ns 0.396449mA
+ 8.158ns 0.395082mA
+ 8.16ns 0.393719mA
+ 8.162ns 0.39236mA
+ 8.164ns 0.391007mA
+ 8.166ns 0.389657mA
+ 8.168ns 0.388313mA
+ 8.17ns 0.386973mA
+ 8.172ns 0.385638mA
+ 8.174ns 0.384307mA
+ 8.176ns 0.382982mA
+ 8.178ns 0.38166mA
+ 8.18ns 0.380343mA
+ 8.182ns 0.379031mA
+ 8.184ns 0.377723mA
+ 8.186ns 0.37642mA
+ 8.188ns 0.375121mA
+ 8.19ns 0.373827mA
+ 8.192ns 0.372537mA
+ 8.194ns 0.371251mA
+ 8.196ns 0.36997mA
+ 8.198ns 0.368694mA
+ 8.2ns 0.367422mA
+ 8.202ns 0.366154mA
+ 8.204ns 0.364891mA
+ 8.206ns 0.363632mA
+ 8.208ns 0.362377mA
+ 8.21ns 0.361127mA
+ 8.212ns 0.359881mA
+ 8.214ns 0.358639mA
+ 8.216ns 0.357402mA
+ 8.218ns 0.356168mA
+ 8.22ns 0.354939mA
+ 8.222ns 0.353715mA
+ 8.224ns 0.352495mA
+ 8.226ns 0.351278mA
+ 8.228ns 0.350066mA
+ 8.23ns 0.348859mA
+ 8.232ns 0.347654mA
+ 8.234ns 0.346455mA
+ 8.236ns 0.34526mA
+ 8.238ns 0.344069mA
+ 8.24ns 0.342881mA
+ 8.242ns 0.341698mA
+ 8.244ns 0.340519mA
+ 8.246ns 0.339344mA
+ 8.248ns 0.338173mA
+ 8.25ns 0.337007mA
+ 8.252ns 0.335844mA
+ 8.254ns 0.334685mA
+ 8.256ns 0.33353mA
+ 8.258ns 0.332379mA
+ 8.26ns 0.331232mA
+ 8.262ns 0.33009mA
+ 8.264ns 0.328951mA
+ 8.266ns 0.327816mA
+ 8.268ns 0.326685mA
+ 8.27ns 0.325557mA
+ 8.272ns 0.324434mA
+ 8.274ns 0.323315mA
+ 8.276ns 0.322199mA
+ 8.278ns 0.321087mA
+ 8.28ns 0.31998mA
+ 8.282ns 0.318876mA
+ 8.284ns 0.317775mA
+ 8.286ns 0.316678mA
+ 8.288ns 0.315586mA
+ 8.29ns 0.314497mA
+ 8.292ns 0.313412mA
+ 8.294ns 0.312331mA
+ 8.296ns 0.311253mA
+ 8.298ns 0.310179mA
+ 8.3ns 0.309108mA
+ 8.302ns 0.308042mA
+ 8.304ns 0.306979mA
+ 8.306ns 0.30592mA
+ 8.308ns 0.304864mA
+ 8.31ns 0.303812mA
+ 8.312ns 0.302764mA
+ 8.314ns 0.301719mA
+ 8.316ns 0.300678mA
+ 8.318ns 0.299641mA
+ 8.32ns 0.298607mA
+ 8.322ns 0.297577mA
+ 8.324ns 0.29655mA
+ 8.326ns 0.295526mA
+ 8.328ns 0.294507mA
+ 8.33ns 0.293491mA
+ 8.332ns 0.292478mA
+ 8.334ns 0.291469mA
+ 8.336ns 0.290463mA
+ 8.338ns 0.289461mA
+ 8.34ns 0.288462mA
+ 8.342ns 0.287467mA
+ 8.344ns 0.286475mA
+ 8.346ns 0.285486mA
+ 8.348ns 0.284501mA
+ 8.35ns 0.283519mA
+ 8.352ns 0.282541mA
+ 8.354ns 0.281566mA
+ 8.356ns 0.280595mA
+ 8.358ns 0.279627mA
+ 8.36ns 0.278662mA
+ 8.362ns 0.2777mA
+ 8.364ns 0.276742mA
+ 8.366ns 0.275787mA
+ 8.368ns 0.274835mA
+ 8.37ns 0.273887mA
+ 8.372ns 0.272942mA
+ 8.374ns 0.272mA
+ 8.376ns 0.271061mA
+ 8.378ns 0.270126mA
+ 8.38ns 0.269194mA
+ 8.382ns 0.268265mA
+ 8.384ns 0.26734mA
+ 8.386ns 0.266417mA
+ 8.388ns 0.265498mA
+ 8.39ns 0.264581mA
+ 8.392ns 0.263669mA
+ 8.394ns 0.262759mA
+ 8.396ns 0.261852mA
+ 8.398ns 0.260949mA
+ 8.4ns 0.260048mA
+ 8.402ns 0.259151mA
+ 8.404ns 0.258256mA
+ 8.406ns 0.257365mA
+ 8.408ns 0.256477mA
+ 8.41ns 0.255592mA
+ 8.412ns 0.254711mA
+ 8.414ns 0.253832mA
+ 8.416ns 0.252955mA
+ 8.418ns 0.252083mA
+ 8.42ns 0.251213mA
+ 8.422ns 0.250346mA
+ 8.424ns 0.249482mA
+ 8.426ns 0.248622mA
+ 8.428ns 0.247763mA
+ 8.43ns 0.246908mA
+ 8.432ns 0.246056mA
+ 8.434ns 0.245207mA
+ 8.436ns 0.244361mA
+ 8.438ns 0.243518mA
+ 8.44ns 0.242678mA
+ 8.442ns 0.24184mA
+ 8.444ns 0.241006mA
+ 8.446ns 0.240174mA
+ 8.448ns 0.239346mA
+ 8.45ns 0.23852mA
+ 8.452ns 0.237697mA
+ 8.454ns 0.236876mA
+ 8.456ns 0.236059mA
+ 8.458ns 0.235244mA
+ 8.46ns 0.234433mA
+ 8.462ns 0.233624mA
+ 8.464ns 0.232818mA
+ 8.466ns 0.232014mA
+ 8.468ns 0.231213mA
+ 8.47ns 0.230416mA
+ 8.472ns 0.22962mA
+ 8.474ns 0.228828mA
+ 8.476ns 0.228039mA
+ 8.478ns 0.227252mA
+ 8.48ns 0.226467mA
+ 8.482ns 0.225686mA
+ 8.484ns 0.224907mA
+ 8.486ns 0.224131mA
+ 8.488ns 0.223358mA
+ 8.49ns 0.222587mA
+ 8.492ns 0.221819mA
+ 8.494ns 0.221053mA
+ 8.496ns 0.22029mA
+ 8.498ns 0.21953mA
+ 8.5ns 0.218773mA
+ 8.502ns 0.218018mA
+ 8.504ns 0.217266mA
+ 8.506ns 0.216516mA
+ 8.508ns 0.215769mA
+ 8.51ns 0.215024mA
+ 8.512ns 0.214282mA
+ 8.514ns 0.213543mA
+ 8.516ns 0.212806mA
+ 8.518ns 0.212072mA
+ 8.52ns 0.211339mA
+ 8.522ns 0.21061mA
+ 8.524ns 0.209884mA
+ 8.526ns 0.209159mA
+ 8.528ns 0.208438mA
+ 8.53ns 0.207718mA
+ 8.532ns 0.207002mA
+ 8.534ns 0.206287mA
+ 8.536ns 0.205575mA
+ 8.538ns 0.204866mA
+ 8.54ns 0.204159mA
+ 8.542ns 0.203454mA
+ 8.544ns 0.202752mA
+ 8.546ns 0.202053mA
+ 8.548ns 0.201355mA
+ 8.55ns 0.200661mA
+ 8.552ns 0.199968mA
+ 8.554ns 0.199278mA
+ 8.556ns 0.19859mA
+ 8.558ns 0.197905mA
+ 8.56ns 0.197222mA
+ 8.562ns 0.196541mA
+ 8.564ns 0.195863mA
+ 8.566ns 0.195187mA
+ 8.568ns 0.194514mA
+ 8.57ns 0.193843mA
+ 8.572ns 0.193174mA
+ 8.574ns 0.192507mA
+ 8.576ns 0.191843mA
+ 8.578ns 0.191181mA
+ 8.58ns 0.190521mA
+ 8.582ns 0.189864mA
+ 8.584ns 0.189208mA
+ 8.586ns 0.188555mA
+ 8.588ns 0.187905mA
+ 8.59ns 0.187256mA
+ 8.592ns 0.18661mA
+ 8.594ns 0.185966mA
+ 8.596ns 0.185324mA
+ 8.598ns 0.184685mA
+ 8.6ns 0.184047mA
+ 8.602ns 0.183412mA
+ 8.604ns 0.182779mA
+ 8.606ns 0.182149mA
+ 8.608ns 0.18152mA
+ 8.61ns 0.180894mA
+ 8.612ns 0.180269mA
+ 8.614ns 0.179647mA
+ 8.616ns 0.179027mA
+ 8.618ns 0.17841mA
+ 8.62ns 0mA
I80 131 0 PWL 0 0
+ 2.638ns 0mA
+ 2.64ns 0.00411812mA
+ 2.642ns 0.00895925mA
+ 2.644ns 0.013801mA
+ 2.646ns 0.0186427mA
+ 2.648ns 0.0234838mA
+ 2.65ns 0.0283255mA
+ 2.652ns 0.0331666mA
+ 2.654ns 0.0380083mA
+ 2.656ns 0.0428501mA
+ 2.658ns 0.0476912mA
+ 2.66ns 0.0525329mA
+ 2.662ns 0.057374mA
+ 2.664ns 0.0622157mA
+ 2.666ns 0.0670574mA
+ 2.668ns 0.0718986mA
+ 2.67ns 0.0767403mA
+ 2.672ns 0.0815814mA
+ 2.674ns 0.0864231mA
+ 2.676ns 0.0912648mA
+ 2.678ns 0.0961059mA
+ 2.68ns 0.100948mA
+ 2.682ns 0.105789mA
+ 2.684ns 0.10236mA
+ 2.686ns 0.0986342mA
+ 2.688ns 0.0950442mA
+ 2.69ns 0.0915843mA
+ 2.692ns 0.0882504mA
+ 2.694ns 0.0850382mA
+ 2.696ns 0.0819425mA
+ 2.698ns 0.0789599mA
+ 2.7ns 0.0760854mA
+ 2.702ns 0.0733156mA
+ 2.704ns 0.0706468mA
+ 2.706ns 0.0680749mA
+ 2.708ns 0.0655969mA
+ 2.71ns 0.0632088mA
+ 2.712ns 0.0609077mA
+ 2.714ns 0.0586905mA
+ 2.716ns 0.0565538mA
+ 2.718ns 0.0544951mA
+ 2.72ns 0.0525111mA
+ 2.722ns 0.0505993mA
+ 2.724ns 0.0487573mA
+ 2.726ns 0.0469821mA
+ 2.728ns 0.0452717mA
+ 2.73ns 0.0436234mA
+ 2.732ns 0.0420352mA
+ 2.734ns 0.0405049mA
+ 2.736ns 0.0390301mA
+ 2.738ns 0.0376091mA
+ 2.74ns 0.0362398mA
+ 2.742ns 0mA
+ 7.638ns 0mA
+ 7.64ns 0.00411755mA
+ 7.642ns 0.00895983mA
+ 7.644ns 0.013801mA
+ 7.646ns 0.0186421mA
+ 7.648ns 0.0234844mA
+ 7.65ns 0.0283255mA
+ 7.652ns 0.0331666mA
+ 7.654ns 0.0380089mA
+ 7.656ns 0.0428501mA
+ 7.658ns 0.0476912mA
+ 7.66ns 0.0525323mA
+ 7.662ns 0.0573746mA
+ 7.664ns 0.0622157mA
+ 7.666ns 0.0670569mA
+ 7.668ns 0.0718991mA
+ 7.67ns 0.0767403mA
+ 7.672ns 0.0815814mA
+ 7.674ns 0.0864237mA
+ 7.676ns 0.0912648mA
+ 7.678ns 0.0961059mA
+ 7.68ns 0.100948mA
+ 7.682ns 0.105789mA
+ 7.684ns 0.10236mA
+ 7.686ns 0.0986347mA
+ 7.688ns 0.0950438mA
+ 7.69ns 0.0915843mA
+ 7.692ns 0.0882508mA
+ 7.694ns 0.0850378mA
+ 7.696ns 0.0819425mA
+ 7.698ns 0.0789599mA
+ 7.7ns 0.0760851mA
+ 7.702ns 0.0733156mA
+ 7.704ns 0.0706468mA
+ 7.706ns 0.0680752mA
+ 7.708ns 0.0655967mA
+ 7.71ns 0.0632088mA
+ 7.712ns 0.0609079mA
+ 7.714ns 0.0586902mA
+ 7.716ns 0.0565538mA
+ 7.718ns 0.0544951mA
+ 7.72ns 0.0525108mA
+ 7.722ns 0.0505993mA
+ 7.724ns 0.0487573mA
+ 7.726ns 0.0469819mA
+ 7.728ns 0.0452715mA
+ 7.73ns 0.0436234mA
+ 7.732ns 0.0420353mA
+ 7.734ns 0.0405047mA
+ 7.736ns 0.0390301mA
+ 7.738ns 0.0376091mA
+ 7.74ns 0.0362396mA
+ 7.742ns 0mA
I81 132 0 PWL 0 0
+ 0.232ns 0mA
+ 0.234ns 0.0017326mA
+ 0.236ns 0.00619455mA
+ 0.238ns 0.0106565mA
+ 0.24ns 0.0151184mA
+ 0.242ns 0.0195804mA
+ 0.244ns 0.0240423mA
+ 0.246ns 0.0285042mA
+ 0.248ns 0.0329662mA
+ 0.25ns 0.0374281mA
+ 0.252ns 0.0418901mA
+ 0.254ns 0.046352mA
+ 0.256ns 0.050814mA
+ 0.258ns 0.0552759mA
+ 0.26ns 0.0539806mA
+ 0.262ns 0.0484552mA
+ 0.264ns 0.0434954mA
+ 0.266ns 0.039043mA
+ 0.268ns 0.0350464mA
+ 0.27ns 0.0314587mA
+ 0.272ns 0.0282382mA
+ 0.274ns 0.0253474mA
+ 0.276ns 0.0227524mA
+ 0.278ns 0.0204231mA
+ 0.28ns 0.0183321mA
+ 0.282ns 0.0164552mA
+ 0.284ns 0.0147704mA
+ 0.286ns 0mA
I82 136 0 PWL 0 0
+ 2.636ns 0mA
+ 2.638ns 0.00369638mA
+ 2.64ns 0.00809599mA
+ 2.642ns 0.0124951mA
+ 2.644ns 0.0168947mA
+ 2.646ns 0.0212943mA
+ 2.648ns 0.0256934mA
+ 2.65ns 0.030093mA
+ 2.652ns 0.034492mA
+ 2.654ns 0.0388917mA
+ 2.656ns 0.0432913mA
+ 2.658ns 0.0476903mA
+ 2.66ns 0.0520899mA
+ 2.662ns 0.056489mA
+ 2.664ns 0.0608886mA
+ 2.666ns 0.0652882mA
+ 2.668ns 0.0696873mA
+ 2.67ns 0.0740869mA
+ 2.672ns 0.078486mA
+ 2.674ns 0.0828856mA
+ 2.676ns 0.0872852mA
+ 2.678ns 0.0916843mA
+ 2.68ns 0.0960839mA
+ 2.682ns 0.100483mA
+ 2.684ns 0.104883mA
+ 2.686ns 0.109282mA
+ 2.688ns 0.112895mA
+ 2.69ns 0.109487mA
+ 2.692ns 0.106182mA
+ 2.694ns 0.102978mA
+ 2.696ns 0.0998692mA
+ 2.698ns 0.096855mA
+ 2.7ns 0.0939314mA
+ 2.702ns 0.0910961mA
+ 2.704ns 0.0883466mA
+ 2.706ns 0.0856798mA
+ 2.708ns 0.0830937mA
+ 2.71ns 0.0805854mA
+ 2.712ns 0.0781528mA
+ 2.714ns 0.0757939mA
+ 2.716ns 0.0735059mA
+ 2.718ns 0.0712873mA
+ 2.72ns 0.0691353mA
+ 2.722ns 0.0670483mA
+ 2.724ns 0.0650244mA
+ 2.726ns 0.0630615mA
+ 2.728ns 0.061158mA
+ 2.73ns 0.0593117mA
+ 2.732ns 0.0575212mA
+ 2.734ns 0.0557849mA
+ 2.736ns 0.0541008mA
+ 2.738ns 0.0524677mA
+ 2.74ns 0.0508837mA
+ 2.742ns 0.0493475mA
+ 2.744ns 0.0478579mA
+ 2.746ns 0.046413mA
+ 2.748ns 0.0450118mA
+ 2.75ns 0.043653mA
+ 2.752ns 0.0423351mA
+ 2.754ns 0.0410571mA
+ 2.756ns 0.0398175mA
+ 2.758ns 0.0386154mA
+ 2.76ns 0mA
+ 5.136ns 0mA
+ 5.138ns 0.00369638mA
+ 5.14ns 0.00809547mA
+ 5.142ns 0.0124956mA
+ 5.144ns 0.0168947mA
+ 5.146ns 0.0212938mA
+ 5.148ns 0.0256939mA
+ 5.15ns 0.030093mA
+ 5.152ns 0.034492mA
+ 5.154ns 0.0388922mA
+ 5.156ns 0.0432913mA
+ 5.158ns 0.0476903mA
+ 5.16ns 0.0520894mA
+ 5.162ns 0.0564896mA
+ 5.164ns 0.0608886mA
+ 5.166ns 0.0652877mA
+ 5.168ns 0.0696878mA
+ 5.17ns 0.0740869mA
+ 5.172ns 0.078486mA
+ 5.174ns 0.0828861mA
+ 5.176ns 0.0872852mA
+ 5.178ns 0.0916843mA
+ 5.18ns 0.0960834mA
+ 5.182ns 0.100484mA
+ 5.184ns 0.104883mA
+ 5.186ns 0.109282mA
+ 5.188ns 0.112894mA
+ 5.19ns 0.109487mA
+ 5.192ns 0.106183mA
+ 5.194ns 0.102977mA
+ 5.196ns 0.0998692mA
+ 5.198ns 0.096855mA
+ 5.2ns 0.0939311mA
+ 5.202ns 0.0910961mA
+ 5.204ns 0.0883466mA
+ 5.206ns 0.0856801mA
+ 5.208ns 0.0830934mA
+ 5.21ns 0.0805854mA
+ 5.212ns 0.0781531mA
+ 5.214ns 0.0757937mA
+ 5.216ns 0.0735059mA
+ 5.218ns 0.0712873mA
+ 5.22ns 0.069135mA
+ 5.222ns 0.0670483mA
+ 5.224ns 0.0650244mA
+ 5.226ns 0.0630617mA
+ 5.228ns 0.0611578mA
+ 5.23ns 0.0593117mA
+ 5.232ns 0.0575214mA
+ 5.234ns 0.0557847mA
+ 5.236ns 0.0541008mA
+ 5.238ns 0.0524677mA
+ 5.24ns 0.0508835mA
+ 5.242ns 0.0493475mA
+ 5.244ns 0.0478579mA
+ 5.246ns 0.0464129mA
+ 5.248ns 0.0450118mA
+ 5.25ns 0.043653mA
+ 5.252ns 0.0423352mA
+ 5.254ns 0.0410569mA
+ 5.256ns 0.0398175mA
+ 5.258ns 0.0386155mA
+ 5.26ns 0mA
I83 137 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00937594mA
+ 2.656ns 0.0202933mA
+ 2.658ns 0.0312093mA
+ 2.66ns 0.0421267mA
+ 2.662ns 0.0530427mA
+ 2.664ns 0.0639601mA
+ 2.666ns 0.0748774mA
+ 2.668ns 0.0857935mA
+ 2.67ns 0.0967109mA
+ 2.672ns 0.107627mA
+ 2.674ns 0.0995686mA
+ 2.676ns 0.0868079mA
+ 2.678ns 0.0756834mA
+ 2.68ns 0.0659832mA
+ 2.682ns 0.0575269mA
+ 2.684ns 0.0501533mA
+ 2.686ns 0.0437246mA
+ 2.688ns 0.0381205mA
+ 2.69ns 0.0332338mA
+ 2.692ns 0.0289735mA
+ 2.694ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00937854mA
+ 7.656ns 0.0202946mA
+ 7.658ns 0.0312106mA
+ 7.66ns 0.0421267mA
+ 7.662ns 0.0530453mA
+ 7.664ns 0.0639614mA
+ 7.666ns 0.0748774mA
+ 7.668ns 0.0857961mA
+ 7.67ns 0.0967121mA
+ 7.672ns 0.107628mA
+ 7.674ns 0.0995654mA
+ 7.676ns 0.0868065mA
+ 7.678ns 0.0756822mA
+ 7.68ns 0.0659811mA
+ 7.682ns 0.057525mA
+ 7.684ns 0.0501525mA
+ 7.686ns 0.0437246mA
+ 7.688ns 0.0381192mA
+ 7.69ns 0.0332333mA
+ 7.692ns 0.0289735mA
+ 7.694ns 0mA
I84 139 0 PWL 0 0
+ 0.226ns 0mA
+ 0.228ns 0.00500457mA
+ 0.23ns 0.0112203mA
+ 0.232ns 0.0174361mA
+ 0.234ns 0.0236519mA
+ 0.236ns 0.0298677mA
+ 0.238ns 0.0360835mA
+ 0.24ns 0.0422993mA
+ 0.242ns 0.0485151mA
+ 0.244ns 0.0547309mA
+ 0.246ns 0.0609467mA
+ 0.248ns 0.0671625mA
+ 0.25ns 0.0597641mA
+ 0.252ns 0.0525987mA
+ 0.254ns 0.0462921mA
+ 0.256ns 0.0407416mA
+ 0.258ns 0.0358564mA
+ 0.26ns 0.0315569mA
+ 0.262ns 0.0277728mA
+ 0.264ns 0.0244424mA
+ 0.266ns 0.0215113mA
+ 0.268ns 0.0189316mA
+ 0.27ns 0mA
I85 141 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00442462mA
+ 2.656ns 0.0154759mA
+ 2.658ns 0.0265258mA
+ 2.66ns 0.0375771mA
+ 2.662ns 0.048627mA
+ 2.664ns 0.0596782mA
+ 2.666ns 0.0707295mA
+ 2.668ns 0.0817794mA
+ 2.67ns 0.0928307mA
+ 2.672ns 0.103881mA
+ 2.674ns 0.114932mA
+ 2.676ns 0.125983mA
+ 2.678ns 0.121528mA
+ 2.68ns 0.108057mA
+ 2.682ns 0.0960796mA
+ 2.684ns 0.0854287mA
+ 2.686ns 0.0759583mA
+ 2.688ns 0.0675384mA
+ 2.69ns 0.0600509mA
+ 2.692ns 0.0533932mA
+ 2.694ns 0.0474742mA
+ 2.696ns 0.0422106mA
+ 2.698ns 0.037531mA
+ 2.7ns 0.0333696mA
+ 2.702ns 0mA
I86 142 0 PWL 0 0
+ 3.008ns 0mA
+ 3.01ns 0.00115518mA
+ 3.012ns 0.00889698mA
+ 3.014ns 0.0166379mA
+ 3.016ns 0.0243797mA
+ 3.018ns 0.0321215mA
+ 3.02ns 0.0398623mA
+ 3.022ns 0.0476041mA
+ 3.024ns 0.0553459mA
+ 3.026ns 0.0630868mA
+ 3.028ns 0.0708286mA
+ 3.03ns 0.0785695mA
+ 3.032ns 0.0863113mA
+ 3.034ns 0.0940531mA
+ 3.036ns 0.101794mA
+ 3.038ns 0.109536mA
+ 3.04ns 0.117277mA
+ 3.042ns 0.125018mA
+ 3.044ns 0.13276mA
+ 3.046ns 0.140501mA
+ 3.048ns 0.148243mA
+ 3.05ns 0.155984mA
+ 3.052ns 0.163726mA
+ 3.054ns 0.171467mA
+ 3.056ns 0.179208mA
+ 3.058ns 0.18695mA
+ 3.06ns 0.194691mA
+ 3.062ns 0.202433mA
+ 3.064ns 0.210175mA
+ 3.066ns 0.217915mA
+ 3.068ns 0.225657mA
+ 3.07ns 0.233398mA
+ 3.072ns 0.24114mA
+ 3.074ns 0.248882mA
+ 3.076ns 0.256623mA
+ 3.078ns 0.264364mA
+ 3.08ns 0.272106mA
+ 3.082ns 0.279847mA
+ 3.084ns 0.287589mA
+ 3.086ns 0.29533mA
+ 3.088ns 0.303072mA
+ 3.09ns 0.310813mA
+ 3.092ns 0.318554mA
+ 3.094ns 0.326296mA
+ 3.096ns 0.334037mA
+ 3.098ns 0.341779mA
+ 3.1ns 0.349521mA
+ 3.102ns 0.357261mA
+ 3.104ns 0.365003mA
+ 3.106ns 0.372744mA
+ 3.108ns 0.380486mA
+ 3.11ns 0.388228mA
+ 3.112ns 0.395969mA
+ 3.114ns 0.40371mA
+ 3.116ns 0.411451mA
+ 3.118ns 0.419193mA
+ 3.12ns 0.426935mA
+ 3.122ns 0.434676mA
+ 3.124ns 0.442417mA
+ 3.126ns 0.450159mA
+ 3.128ns 0.4579mA
+ 3.13ns 0.465642mA
+ 3.132ns 0.473383mA
+ 3.134ns 0.481125mA
+ 3.136ns 0.488866mA
+ 3.138ns 0.496607mA
+ 3.14ns 0.504349mA
+ 3.142ns 0.51209mA
+ 3.144ns 0.519832mA
+ 3.146ns 0.527574mA
+ 3.148ns 0.535314mA
+ 3.15ns 0.543056mA
+ 3.152ns 0.550797mA
+ 3.154ns 0.548901mA
+ 3.156ns 0.546507mA
+ 3.158ns 0.544125mA
+ 3.16ns 0.541753mA
+ 3.162ns 0.539391mA
+ 3.164ns 0.53704mA
+ 3.166ns 0.534698mA
+ 3.168ns 0.532367mA
+ 3.17ns 0.530046mA
+ 3.172ns 0.527735mA
+ 3.174ns 0.525435mA
+ 3.176ns 0.523144mA
+ 3.178ns 0.520864mA
+ 3.18ns 0.518593mA
+ 3.182ns 0.516332mA
+ 3.184ns 0.514081mA
+ 3.186ns 0.51184mA
+ 3.188ns 0.509608mA
+ 3.19ns 0.507386mA
+ 3.192ns 0.505174mA
+ 3.194ns 0.502972mA
+ 3.196ns 0.500779mA
+ 3.198ns 0.498596mA
+ 3.2ns 0.496422mA
+ 3.202ns 0.494258mA
+ 3.204ns 0.492103mA
+ 3.206ns 0.489958mA
+ 3.208ns 0.487822mA
+ 3.21ns 0.485695mA
+ 3.212ns 0.483577mA
+ 3.214ns 0.481469mA
+ 3.216ns 0.47937mA
+ 3.218ns 0.47728mA
+ 3.22ns 0.4752mA
+ 3.222ns 0.473128mA
+ 3.224ns 0.471065mA
+ 3.226ns 0.469011mA
+ 3.228ns 0.466967mA
+ 3.23ns 0.464931mA
+ 3.232ns 0.462904mA
+ 3.234ns 0.460886mA
+ 3.236ns 0.458876mA
+ 3.238ns 0.456876mA
+ 3.24ns 0.454884mA
+ 3.242ns 0.452901mA
+ 3.244ns 0.450926mA
+ 3.246ns 0.44896mA
+ 3.248ns 0.447003mA
+ 3.25ns 0.445054mA
+ 3.252ns 0.443114mA
+ 3.254ns 0.441182mA
+ 3.256ns 0.439258mA
+ 3.258ns 0.437343mA
+ 3.26ns 0.435437mA
+ 3.262ns 0.433538mA
+ 3.264ns 0.431648mA
+ 3.266ns 0.429766mA
+ 3.268ns 0.427892mA
+ 3.27ns 0.426027mA
+ 3.272ns 0.424169mA
+ 3.274ns 0.42232mA
+ 3.276ns 0.420479mA
+ 3.278ns 0.418646mA
+ 3.28ns 0.41682mA
+ 3.282ns 0.415003mA
+ 3.284ns 0.413194mA
+ 3.286ns 0.411392mA
+ 3.288ns 0.409599mA
+ 3.29ns 0.407813mA
+ 3.292ns 0.406035mA
+ 3.294ns 0.404265mA
+ 3.296ns 0.402502mA
+ 3.298ns 0.400747mA
+ 3.3ns 0.399mA
+ 3.302ns 0.39726mA
+ 3.304ns 0.395528mA
+ 3.306ns 0.393804mA
+ 3.308ns 0.392087mA
+ 3.31ns 0.390377mA
+ 3.312ns 0.388675mA
+ 3.314ns 0.386981mA
+ 3.316ns 0.385294mA
+ 3.318ns 0.383614mA
+ 3.32ns 0.381941mA
+ 3.322ns 0.380276mA
+ 3.324ns 0.378618mA
+ 3.326ns 0.376967mA
+ 3.328ns 0.375324mA
+ 3.33ns 0.373687mA
+ 3.332ns 0.372058mA
+ 3.334ns 0.370436mA
+ 3.336ns 0.368821mA
+ 3.338ns 0.367213mA
+ 3.34ns 0.365612mA
+ 3.342ns 0.364018mA
+ 3.344ns 0.36243mA
+ 3.346ns 0.36085mA
+ 3.348ns 0.359277mA
+ 3.35ns 0.35771mA
+ 3.352ns 0.356151mA
+ 3.354ns 0.354598mA
+ 3.356ns 0.353052mA
+ 3.358ns 0.351513mA
+ 3.36ns 0.34998mA
+ 3.362ns 0.348454mA
+ 3.364ns 0.346935mA
+ 3.366ns 0.345422mA
+ 3.368ns 0.343916mA
+ 3.37ns 0.342417mA
+ 3.372ns 0.340924mA
+ 3.374ns 0.339437mA
+ 3.376ns 0.337957mA
+ 3.378ns 0.336484mA
+ 3.38ns 0.335017mA
+ 3.382ns 0.333556mA
+ 3.384ns 0.332102mA
+ 3.386ns 0.330654mA
+ 3.388ns 0.329212mA
+ 3.39ns 0.327777mA
+ 3.392ns 0.326348mA
+ 3.394ns 0.324925mA
+ 3.396ns 0.323508mA
+ 3.398ns 0.322097mA
+ 3.4ns 0.320693mA
+ 3.402ns 0.319295mA
+ 3.404ns 0.317902mA
+ 3.406ns 0.316516mA
+ 3.408ns 0.315136mA
+ 3.41ns 0.313762mA
+ 3.412ns 0.312394mA
+ 3.414ns 0.311032mA
+ 3.416ns 0.309676mA
+ 3.418ns 0.308326mA
+ 3.42ns 0.306981mA
+ 3.422ns 0.305643mA
+ 3.424ns 0.30431mA
+ 3.426ns 0.302983mA
+ 3.428ns 0.301662mA
+ 3.43ns 0.300347mA
+ 3.432ns 0.299037mA
+ 3.434ns 0.297734mA
+ 3.436ns 0.296435mA
+ 3.438ns 0.295143mA
+ 3.44ns 0.293856mA
+ 3.442ns 0.292575mA
+ 3.444ns 0.291299mA
+ 3.446ns 0.290029mA
+ 3.448ns 0.288764mA
+ 3.45ns 0.287505mA
+ 3.452ns 0.286252mA
+ 3.454ns 0.285004mA
+ 3.456ns 0.283761mA
+ 3.458ns 0.282523mA
+ 3.46ns 0.281292mA
+ 3.462ns 0.280065mA
+ 3.464ns 0.278844mA
+ 3.466ns 0.277628mA
+ 3.468ns 0.276418mA
+ 3.47ns 0.275212mA
+ 3.472ns 0.274012mA
+ 3.474ns 0.272818mA
+ 3.476ns 0.271628mA
+ 3.478ns 0.270444mA
+ 3.48ns 0.269264mA
+ 3.482ns 0.26809mA
+ 3.484ns 0.266921mA
+ 3.486ns 0.265757mA
+ 3.488ns 0.264599mA
+ 3.49ns 0.263445mA
+ 3.492ns 0.262296mA
+ 3.494ns 0.261153mA
+ 3.496ns 0.260014mA
+ 3.498ns 0.25888mA
+ 3.5ns 0.257751mA
+ 3.502ns 0.256627mA
+ 3.504ns 0.255508mA
+ 3.506ns 0.254394mA
+ 3.508ns 0.253285mA
+ 3.51ns 0.252181mA
+ 3.512ns 0.251081mA
+ 3.514ns 0.249986mA
+ 3.516ns 0.248896mA
+ 3.518ns 0.247811mA
+ 3.52ns 0.24673mA
+ 3.522ns 0.245654mA
+ 3.524ns 0.244583mA
+ 3.526ns 0.243517mA
+ 3.528ns 0.242455mA
+ 3.53ns 0.241398mA
+ 3.532ns 0.240345mA
+ 3.534ns 0.239297mA
+ 3.536ns 0.238254mA
+ 3.538ns 0.237215mA
+ 3.54ns 0.23618mA
+ 3.542ns 0mA
I87 143 0 PWL 0 0
+ 3.012ns 0mA
+ 3.014ns 0.00474122mA
+ 3.016ns 0.012396mA
+ 3.018ns 0.0200507mA
+ 3.02ns 0.0277046mA
+ 3.022ns 0.0353593mA
+ 3.024ns 0.0430141mA
+ 3.026ns 0.0506679mA
+ 3.028ns 0.0583226mA
+ 3.03ns 0.0659765mA
+ 3.032ns 0.0736312mA
+ 3.034ns 0.081286mA
+ 3.036ns 0.0889398mA
+ 3.038ns 0.0965946mA
+ 3.04ns 0.104248mA
+ 3.042ns 0.111903mA
+ 3.044ns 0.119558mA
+ 3.046ns 0.127212mA
+ 3.048ns 0.134867mA
+ 3.05ns 0.14252mA
+ 3.052ns 0.150175mA
+ 3.054ns 0.15783mA
+ 3.056ns 0.165484mA
+ 3.058ns 0.173138mA
+ 3.06ns 0.180792mA
+ 3.062ns 0.188447mA
+ 3.064ns 0.196102mA
+ 3.066ns 0.203756mA
+ 3.068ns 0.21141mA
+ 3.07ns 0.219064mA
+ 3.072ns 0.226719mA
+ 3.074ns 0.234374mA
+ 3.076ns 0.242028mA
+ 3.078ns 0.249682mA
+ 3.08ns 0.257337mA
+ 3.082ns 0.264991mA
+ 3.084ns 0.272646mA
+ 3.086ns 0.280299mA
+ 3.088ns 0.287954mA
+ 3.09ns 0.295609mA
+ 3.092ns 0.303263mA
+ 3.094ns 0.310918mA
+ 3.096ns 0.318571mA
+ 3.098ns 0.326226mA
+ 3.1ns 0.333881mA
+ 3.102ns 0.341535mA
+ 3.104ns 0.349189mA
+ 3.106ns 0.356843mA
+ 3.108ns 0.364498mA
+ 3.11ns 0.372153mA
+ 3.112ns 0.379807mA
+ 3.114ns 0.387461mA
+ 3.116ns 0.395115mA
+ 3.118ns 0.40277mA
+ 3.12ns 0.410425mA
+ 3.122ns 0.418079mA
+ 3.124ns 0.425733mA
+ 3.126ns 0.433388mA
+ 3.128ns 0.441042mA
+ 3.13ns 0.448697mA
+ 3.132ns 0.456351mA
+ 3.134ns 0.464005mA
+ 3.136ns 0.47166mA
+ 3.138ns 0.479314mA
+ 3.14ns 0.486969mA
+ 3.142ns 0.494622mA
+ 3.144ns 0.502277mA
+ 3.146ns 0.509932mA
+ 3.148ns 0.517586mA
+ 3.15ns 0.525241mA
+ 3.152ns 0.532894mA
+ 3.154ns 0.540549mA
+ 3.156ns 0.548204mA
+ 3.158ns 0.55032mA
+ 3.16ns 0.547915mA
+ 3.162ns 0.54552mA
+ 3.164ns 0.543136mA
+ 3.166ns 0.540762mA
+ 3.168ns 0.538399mA
+ 3.17ns 0.536045mA
+ 3.172ns 0.533702mA
+ 3.174ns 0.53137mA
+ 3.176ns 0.529047mA
+ 3.178ns 0.526735mA
+ 3.18ns 0.524433mA
+ 3.182ns 0.522141mA
+ 3.184ns 0.519859mA
+ 3.186ns 0.517587mA
+ 3.188ns 0.515325mA
+ 3.19ns 0.513072mA
+ 3.192ns 0.51083mA
+ 3.194ns 0.508597mA
+ 3.196ns 0.506374mA
+ 3.198ns 0.504161mA
+ 3.2ns 0.501957mA
+ 3.202ns 0.499763mA
+ 3.204ns 0.497579mA
+ 3.206ns 0.495404mA
+ 3.208ns 0.493239mA
+ 3.21ns 0.491083mA
+ 3.212ns 0.488937mA
+ 3.214ns 0.4868mA
+ 3.216ns 0.484672mA
+ 3.218ns 0.482554mA
+ 3.22ns 0.480445mA
+ 3.222ns 0.478345mA
+ 3.224ns 0.476254mA
+ 3.226ns 0.474172mA
+ 3.228ns 0.4721mA
+ 3.23ns 0.470037mA
+ 3.232ns 0.467982mA
+ 3.234ns 0.465937mA
+ 3.236ns 0.4639mA
+ 3.238ns 0.461872mA
+ 3.24ns 0.459854mA
+ 3.242ns 0.457844mA
+ 3.244ns 0.455843mA
+ 3.246ns 0.45385mA
+ 3.248ns 0.451867mA
+ 3.25ns 0.449892mA
+ 3.252ns 0.447925mA
+ 3.254ns 0.445967mA
+ 3.256ns 0.444018mA
+ 3.258ns 0.442077mA
+ 3.26ns 0.440145mA
+ 3.262ns 0.438221mA
+ 3.264ns 0.436306mA
+ 3.266ns 0.434399mA
+ 3.268ns 0.4325mA
+ 3.27ns 0.43061mA
+ 3.272ns 0.428728mA
+ 3.274ns 0.426854mA
+ 3.276ns 0.424988mA
+ 3.278ns 0.42313mA
+ 3.28ns 0.421281mA
+ 3.282ns 0.41944mA
+ 3.284ns 0.417606mA
+ 3.286ns 0.415781mA
+ 3.288ns 0.413964mA
+ 3.29ns 0.412154mA
+ 3.292ns 0.410353mA
+ 3.294ns 0.408559mA
+ 3.296ns 0.406773mA
+ 3.298ns 0.404995mA
+ 3.3ns 0.403225mA
+ 3.302ns 0.401463mA
+ 3.304ns 0.399708mA
+ 3.306ns 0.397961mA
+ 3.308ns 0.396221mA
+ 3.31ns 0.394489mA
+ 3.312ns 0.392765mA
+ 3.314ns 0.391048mA
+ 3.316ns 0.389339mA
+ 3.318ns 0.387637mA
+ 3.32ns 0.385943mA
+ 3.322ns 0.384256mA
+ 3.324ns 0.382576mA
+ 3.326ns 0.380904mA
+ 3.328ns 0.379239mA
+ 3.33ns 0.377582mA
+ 3.332ns 0.375931mA
+ 3.334ns 0.374288mA
+ 3.336ns 0.372652mA
+ 3.338ns 0.371023mA
+ 3.34ns 0.369401mA
+ 3.342ns 0.367787mA
+ 3.344ns 0.366179mA
+ 3.346ns 0.364579mA
+ 3.348ns 0.362985mA
+ 3.35ns 0.361398mA
+ 3.352ns 0.359819mA
+ 3.354ns 0.358246mA
+ 3.356ns 0.35668mA
+ 3.358ns 0.355121mA
+ 3.36ns 0.353569mA
+ 3.362ns 0.352023mA
+ 3.364ns 0.350484mA
+ 3.366ns 0.348952mA
+ 3.368ns 0.347427mA
+ 3.37ns 0.345908mA
+ 3.372ns 0.344397mA
+ 3.374ns 0.342891mA
+ 3.376ns 0.341392mA
+ 3.378ns 0.3399mA
+ 3.38ns 0.338414mA
+ 3.382ns 0.336935mA
+ 3.384ns 0.335462mA
+ 3.386ns 0.333996mA
+ 3.388ns 0.332536mA
+ 3.39ns 0.331082mA
+ 3.392ns 0.329635mA
+ 3.394ns 0.328194mA
+ 3.396ns 0.32676mA
+ 3.398ns 0.325331mA
+ 3.4ns 0.323909mA
+ 3.402ns 0.322493mA
+ 3.404ns 0.321084mA
+ 3.406ns 0.31968mA
+ 3.408ns 0.318283mA
+ 3.41ns 0.316892mA
+ 3.412ns 0.315506mA
+ 3.414ns 0.314127mA
+ 3.416ns 0.312754mA
+ 3.418ns 0.311387mA
+ 3.42ns 0.310026mA
+ 3.422ns 0.308671mA
+ 3.424ns 0.307321mA
+ 3.426ns 0.305978mA
+ 3.428ns 0.304641mA
+ 3.43ns 0.303309mA
+ 3.432ns 0.301983mA
+ 3.434ns 0.300663mA
+ 3.436ns 0.299349mA
+ 3.438ns 0.29804mA
+ 3.44ns 0.296737mA
+ 3.442ns 0.29544mA
+ 3.444ns 0.294149mA
+ 3.446ns 0.292863mA
+ 3.448ns 0.291583mA
+ 3.45ns 0.290308mA
+ 3.452ns 0.289039mA
+ 3.454ns 0.287776mA
+ 3.456ns 0.286518mA
+ 3.458ns 0.285265mA
+ 3.46ns 0.284018mA
+ 3.462ns 0.282777mA
+ 3.464ns 0.281541mA
+ 3.466ns 0.28031mA
+ 3.468ns 0.279085mA
+ 3.47ns 0.277865mA
+ 3.472ns 0.27665mA
+ 3.474ns 0.275441mA
+ 3.476ns 0.274237mA
+ 3.478ns 0.273038mA
+ 3.48ns 0.271844mA
+ 3.482ns 0.270656mA
+ 3.484ns 0.269473mA
+ 3.486ns 0.268295mA
+ 3.488ns 0.267122mA
+ 3.49ns 0.265954mA
+ 3.492ns 0.264792mA
+ 3.494ns 0.263634mA
+ 3.496ns 0.262482mA
+ 3.498ns 0.261334mA
+ 3.5ns 0.260192mA
+ 3.502ns 0.259055mA
+ 3.504ns 0.257922mA
+ 3.506ns 0.256795mA
+ 3.508ns 0.255672mA
+ 3.51ns 0.254555mA
+ 3.512ns 0.253442mA
+ 3.514ns 0.252334mA
+ 3.516ns 0.251231mA
+ 3.518ns 0.250133mA
+ 3.52ns 0.249039mA
+ 3.522ns 0.24795mA
+ 3.524ns 0.246867mA
+ 3.526ns 0.245787mA
+ 3.528ns 0.244713mA
+ 3.53ns 0.243643mA
+ 3.532ns 0.242578mA
+ 3.534ns 0.241518mA
+ 3.536ns 0.240462mA
+ 3.538ns 0.239411mA
+ 3.54ns 0.238364mA
+ 3.542ns 0.237322mA
+ 3.544ns 0.236285mA
+ 3.546ns 0mA
+ 8.012ns 0mA
+ 8.014ns 0.00474304mA
+ 8.016ns 0.0123969mA
+ 8.018ns 0.0200507mA
+ 8.02ns 0.0277082mA
+ 8.022ns 0.035362mA
+ 8.024ns 0.0430159mA
+ 8.026ns 0.0506697mA
+ 8.028ns 0.0583236mA
+ 8.03ns 0.0659774mA
+ 8.032ns 0.0736312mA
+ 8.034ns 0.0812887mA
+ 8.036ns 0.0889426mA
+ 8.038ns 0.0965964mA
+ 8.04ns 0.10425mA
+ 8.042ns 0.111904mA
+ 8.044ns 0.119558mA
+ 8.046ns 0.127212mA
+ 8.048ns 0.134869mA
+ 8.05ns 0.142523mA
+ 8.052ns 0.150177mA
+ 8.054ns 0.157831mA
+ 8.056ns 0.165485mA
+ 8.058ns 0.173138mA
+ 8.06ns 0.180796mA
+ 8.062ns 0.18845mA
+ 8.064ns 0.196104mA
+ 8.066ns 0.203757mA
+ 8.068ns 0.211411mA
+ 8.07ns 0.219065mA
+ 8.072ns 0.226719mA
+ 8.074ns 0.234376mA
+ 8.076ns 0.24203mA
+ 8.078ns 0.249684mA
+ 8.08ns 0.257338mA
+ 8.082ns 0.264992mA
+ 8.084ns 0.272646mA
+ 8.086ns 0.280303mA
+ 8.088ns 0.287957mA
+ 8.09ns 0.295611mA
+ 8.092ns 0.303265mA
+ 8.094ns 0.310918mA
+ 8.096ns 0.318572mA
+ 8.098ns 0.326226mA
+ 8.1ns 0.333884mA
+ 8.102ns 0.341537mA
+ 8.104ns 0.349191mA
+ 8.106ns 0.356845mA
+ 8.108ns 0.364499mA
+ 8.11ns 0.372153mA
+ 8.112ns 0.37981mA
+ 8.114ns 0.387464mA
+ 8.116ns 0.395118mA
+ 8.118ns 0.402772mA
+ 8.12ns 0.410426mA
+ 8.122ns 0.418079mA
+ 8.124ns 0.425733mA
+ 8.126ns 0.433391mA
+ 8.128ns 0.441045mA
+ 8.13ns 0.448698mA
+ 8.132ns 0.456352mA
+ 8.134ns 0.464006mA
+ 8.136ns 0.47166mA
+ 8.138ns 0.479314mA
+ 8.14ns 0.486971mA
+ 8.142ns 0.494625mA
+ 8.144ns 0.502279mA
+ 8.146ns 0.509933mA
+ 8.148ns 0.517587mA
+ 8.15ns 0.525241mA
+ 8.152ns 0.532898mA
+ 8.154ns 0.540552mA
+ 8.156ns 0.548206mA
+ 8.158ns 0.550319mA
+ 8.16ns 0.547914mA
+ 8.162ns 0.54552mA
+ 8.164ns 0.543136mA
+ 8.166ns 0.540761mA
+ 8.168ns 0.538398mA
+ 8.17ns 0.536045mA
+ 8.172ns 0.533702mA
+ 8.174ns 0.53137mA
+ 8.176ns 0.529047mA
+ 8.178ns 0.526734mA
+ 8.18ns 0.524432mA
+ 8.182ns 0.52214mA
+ 8.184ns 0.519858mA
+ 8.186ns 0.517586mA
+ 8.188ns 0.515324mA
+ 8.19ns 0.513072mA
+ 8.192ns 0.510829mA
+ 8.194ns 0.508596mA
+ 8.196ns 0.506373mA
+ 8.198ns 0.50416mA
+ 8.2ns 0.501957mA
+ 8.202ns 0.499763mA
+ 8.204ns 0.497578mA
+ 8.206ns 0.495403mA
+ 8.208ns 0.493238mA
+ 8.21ns 0.491083mA
+ 8.212ns 0.488936mA
+ 8.214ns 0.4868mA
+ 8.216ns 0.484672mA
+ 8.218ns 0.482553mA
+ 8.22ns 0.480444mA
+ 8.222ns 0.478344mA
+ 8.224ns 0.476254mA
+ 8.226ns 0.474172mA
+ 8.228ns 0.4721mA
+ 8.23ns 0.470037mA
+ 8.232ns 0.467981mA
+ 8.234ns 0.465936mA
+ 8.236ns 0.4639mA
+ 8.238ns 0.461872mA
+ 8.24ns 0.459854mA
+ 8.242ns 0.457844mA
+ 8.244ns 0.455842mA
+ 8.246ns 0.45385mA
+ 8.248ns 0.451866mA
+ 8.25ns 0.449891mA
+ 8.252ns 0.447925mA
+ 8.254ns 0.445967mA
+ 8.256ns 0.444018mA
+ 8.258ns 0.442077mA
+ 8.26ns 0.440145mA
+ 8.262ns 0.438221mA
+ 8.264ns 0.436306mA
+ 8.266ns 0.434399mA
+ 8.268ns 0.4325mA
+ 8.27ns 0.430609mA
+ 8.272ns 0.428727mA
+ 8.274ns 0.426853mA
+ 8.276ns 0.424988mA
+ 8.278ns 0.42313mA
+ 8.28ns 0.421281mA
+ 8.282ns 0.41944mA
+ 8.284ns 0.417606mA
+ 8.286ns 0.41578mA
+ 8.288ns 0.413963mA
+ 8.29ns 0.412154mA
+ 8.292ns 0.410353mA
+ 8.294ns 0.408559mA
+ 8.296ns 0.406773mA
+ 8.298ns 0.404995mA
+ 8.3ns 0.403225mA
+ 8.302ns 0.401462mA
+ 8.304ns 0.399708mA
+ 8.306ns 0.397961mA
+ 8.308ns 0.396221mA
+ 8.31ns 0.394489mA
+ 8.312ns 0.392765mA
+ 8.314ns 0.391048mA
+ 8.316ns 0.389339mA
+ 8.318ns 0.387637mA
+ 8.32ns 0.385943mA
+ 8.322ns 0.384256mA
+ 8.324ns 0.382576mA
+ 8.326ns 0.380904mA
+ 8.328ns 0.379239mA
+ 8.33ns 0.377581mA
+ 8.332ns 0.375931mA
+ 8.334ns 0.374288mA
+ 8.336ns 0.372651mA
+ 8.338ns 0.371023mA
+ 8.34ns 0.369401mA
+ 8.342ns 0.367786mA
+ 8.344ns 0.366179mA
+ 8.346ns 0.364578mA
+ 8.348ns 0.362985mA
+ 8.35ns 0.361398mA
+ 8.352ns 0.359818mA
+ 8.354ns 0.358245mA
+ 8.356ns 0.35668mA
+ 8.358ns 0.355121mA
+ 8.36ns 0.353569mA
+ 8.362ns 0.352022mA
+ 8.364ns 0.350484mA
+ 8.366ns 0.348952mA
+ 8.368ns 0.347427mA
+ 8.37ns 0.345908mA
+ 8.372ns 0.344396mA
+ 8.374ns 0.342891mA
+ 8.376ns 0.341392mA
+ 8.378ns 0.339899mA
+ 8.38ns 0.338414mA
+ 8.382ns 0.336935mA
+ 8.384ns 0.335462mA
+ 8.386ns 0.333996mA
+ 8.388ns 0.332535mA
+ 8.39ns 0.331082mA
+ 8.392ns 0.329635mA
+ 8.394ns 0.328194mA
+ 8.396ns 0.326759mA
+ 8.398ns 0.325331mA
+ 8.4ns 0.323909mA
+ 8.402ns 0.322493mA
+ 8.404ns 0.321083mA
+ 8.406ns 0.31968mA
+ 8.408ns 0.318283mA
+ 8.41ns 0.316891mA
+ 8.412ns 0.315506mA
+ 8.414ns 0.314127mA
+ 8.416ns 0.312754mA
+ 8.418ns 0.311387mA
+ 8.42ns 0.310026mA
+ 8.422ns 0.30867mA
+ 8.424ns 0.307321mA
+ 8.426ns 0.305978mA
+ 8.428ns 0.30464mA
+ 8.43ns 0.303308mA
+ 8.432ns 0.301983mA
+ 8.434ns 0.300663mA
+ 8.436ns 0.299349mA
+ 8.438ns 0.29804mA
+ 8.44ns 0.296737mA
+ 8.442ns 0.29544mA
+ 8.444ns 0.294148mA
+ 8.446ns 0.292863mA
+ 8.448ns 0.291583mA
+ 8.45ns 0.290308mA
+ 8.452ns 0.289039mA
+ 8.454ns 0.287775mA
+ 8.456ns 0.286517mA
+ 8.458ns 0.285265mA
+ 8.46ns 0.284018mA
+ 8.462ns 0.282777mA
+ 8.464ns 0.281541mA
+ 8.466ns 0.28031mA
+ 8.468ns 0.279084mA
+ 8.47ns 0.277864mA
+ 8.472ns 0.27665mA
+ 8.474ns 0.275441mA
+ 8.476ns 0.274237mA
+ 8.478ns 0.273038mA
+ 8.48ns 0.271844mA
+ 8.482ns 0.270656mA
+ 8.484ns 0.269473mA
+ 8.486ns 0.268295mA
+ 8.488ns 0.267122mA
+ 8.49ns 0.265954mA
+ 8.492ns 0.264792mA
+ 8.494ns 0.263634mA
+ 8.496ns 0.262481mA
+ 8.498ns 0.261334mA
+ 8.5ns 0.260192mA
+ 8.502ns 0.259055mA
+ 8.504ns 0.257922mA
+ 8.506ns 0.256795mA
+ 8.508ns 0.255672mA
+ 8.51ns 0.254554mA
+ 8.512ns 0.253441mA
+ 8.514ns 0.252334mA
+ 8.516ns 0.251231mA
+ 8.518ns 0.250133mA
+ 8.52ns 0.249039mA
+ 8.522ns 0.24795mA
+ 8.524ns 0.246866mA
+ 8.526ns 0.245787mA
+ 8.528ns 0.244713mA
+ 8.53ns 0.243643mA
+ 8.532ns 0.242578mA
+ 8.534ns 0.241517mA
+ 8.536ns 0.240462mA
+ 8.538ns 0.23941mA
+ 8.54ns 0.238364mA
+ 8.542ns 0.237322mA
+ 8.544ns 0.236285mA
+ 8.546ns 0mA
I88 144 0 PWL 0 0
+ 3.008ns 0mA
+ 3.01ns 0.00500888mA
+ 3.012ns 0.0126921mA
+ 3.014ns 0.0203744mA
+ 3.016ns 0.0280576mA
+ 3.018ns 0.0357408mA
+ 3.02ns 0.0434231mA
+ 3.022ns 0.0511063mA
+ 3.024ns 0.0587896mA
+ 3.026ns 0.0664719mA
+ 3.028ns 0.0741551mA
+ 3.03ns 0.0818374mA
+ 3.032ns 0.0895206mA
+ 3.034ns 0.0972038mA
+ 3.036ns 0.104886mA
+ 3.038ns 0.112569mA
+ 3.04ns 0.120252mA
+ 3.042ns 0.127935mA
+ 3.044ns 0.135618mA
+ 3.046ns 0.1433mA
+ 3.048ns 0.150984mA
+ 3.05ns 0.158666mA
+ 3.052ns 0.166349mA
+ 3.054ns 0.174032mA
+ 3.056ns 0.181715mA
+ 3.058ns 0.189398mA
+ 3.06ns 0.19708mA
+ 3.062ns 0.204763mA
+ 3.064ns 0.212447mA
+ 3.066ns 0.220129mA
+ 3.068ns 0.227812mA
+ 3.07ns 0.235494mA
+ 3.072ns 0.243178mA
+ 3.074ns 0.250861mA
+ 3.076ns 0.258543mA
+ 3.078ns 0.266226mA
+ 3.08ns 0.273909mA
+ 3.082ns 0.281592mA
+ 3.084ns 0.289275mA
+ 3.086ns 0.296957mA
+ 3.088ns 0.304641mA
+ 3.09ns 0.312324mA
+ 3.092ns 0.320006mA
+ 3.094ns 0.327689mA
+ 3.096ns 0.335372mA
+ 3.098ns 0.343055mA
+ 3.1ns 0.350738mA
+ 3.102ns 0.35842mA
+ 3.104ns 0.366103mA
+ 3.106ns 0.373786mA
+ 3.108ns 0.381469mA
+ 3.11ns 0.389152mA
+ 3.112ns 0.396834mA
+ 3.114ns 0.404518mA
+ 3.116ns 0.4122mA
+ 3.118ns 0.419883mA
+ 3.12ns 0.427566mA
+ 3.122ns 0.435249mA
+ 3.124ns 0.442932mA
+ 3.126ns 0.450615mA
+ 3.128ns 0.458297mA
+ 3.13ns 0.465981mA
+ 3.132ns 0.473663mA
+ 3.134ns 0.481346mA
+ 3.136ns 0.489029mA
+ 3.138ns 0.496712mA
+ 3.14ns 0.504395mA
+ 3.142ns 0.512077mA
+ 3.144ns 0.51976mA
+ 3.146ns 0.527444mA
+ 3.148ns 0.535126mA
+ 3.15ns 0.542809mA
+ 3.152ns 0.550491mA
+ 3.154ns 0.550096mA
+ 3.156ns 0.54769mA
+ 3.158ns 0.545294mA
+ 3.16ns 0.542909mA
+ 3.162ns 0.540534mA
+ 3.164ns 0.53817mA
+ 3.166ns 0.535816mA
+ 3.168ns 0.533472mA
+ 3.17ns 0.531139mA
+ 3.172ns 0.528816mA
+ 3.174ns 0.526503mA
+ 3.176ns 0.5242mA
+ 3.178ns 0.521907mA
+ 3.18ns 0.519624mA
+ 3.182ns 0.517351mA
+ 3.184ns 0.515088mA
+ 3.186ns 0.512835mA
+ 3.188ns 0.510592mA
+ 3.19ns 0.508359mA
+ 3.192ns 0.506135mA
+ 3.194ns 0.503921mA
+ 3.196ns 0.501717mA
+ 3.198ns 0.499523mA
+ 3.2ns 0.497337mA
+ 3.202ns 0.495162mA
+ 3.204ns 0.492996mA
+ 3.206ns 0.49084mA
+ 3.208ns 0.488693mA
+ 3.21ns 0.486555mA
+ 3.212ns 0.484427mA
+ 3.214ns 0.482308mA
+ 3.216ns 0.480198mA
+ 3.218ns 0.478098mA
+ 3.22ns 0.476007mA
+ 3.222ns 0.473924mA
+ 3.224ns 0.471852mA
+ 3.226ns 0.469788mA
+ 3.228ns 0.467732mA
+ 3.23ns 0.465687mA
+ 3.232ns 0.46365mA
+ 3.234ns 0.461622mA
+ 3.236ns 0.459602mA
+ 3.238ns 0.457592mA
+ 3.24ns 0.45559mA
+ 3.242ns 0.453598mA
+ 3.244ns 0.451614mA
+ 3.246ns 0.449638mA
+ 3.248ns 0.447671mA
+ 3.25ns 0.445713mA
+ 3.252ns 0.443763mA
+ 3.254ns 0.441822mA
+ 3.256ns 0.43989mA
+ 3.258ns 0.437965mA
+ 3.26ns 0.43605mA
+ 3.262ns 0.434142mA
+ 3.264ns 0.432243mA
+ 3.266ns 0.430353mA
+ 3.268ns 0.42847mA
+ 3.27ns 0.426596mA
+ 3.272ns 0.42473mA
+ 3.274ns 0.422872mA
+ 3.276ns 0.421022mA
+ 3.278ns 0.41918mA
+ 3.28ns 0.417347mA
+ 3.282ns 0.415521mA
+ 3.284ns 0.413704mA
+ 3.286ns 0.411894mA
+ 3.288ns 0.410092mA
+ 3.29ns 0.408298mA
+ 3.292ns 0.406512mA
+ 3.294ns 0.404734mA
+ 3.296ns 0.402964mA
+ 3.298ns 0.401201mA
+ 3.3ns 0.399446mA
+ 3.302ns 0.397699mA
+ 3.304ns 0.395959mA
+ 3.306ns 0.394227mA
+ 3.308ns 0.392503mA
+ 3.31ns 0.390785mA
+ 3.312ns 0.389076mA
+ 3.314ns 0.387374mA
+ 3.316ns 0.38568mA
+ 3.318ns 0.383993mA
+ 3.32ns 0.382313mA
+ 3.322ns 0.380641mA
+ 3.324ns 0.378975mA
+ 3.326ns 0.377318mA
+ 3.328ns 0.375667mA
+ 3.33ns 0.374024mA
+ 3.332ns 0.372388mA
+ 3.334ns 0.370759mA
+ 3.336ns 0.369137mA
+ 3.338ns 0.367522mA
+ 3.34ns 0.365914mA
+ 3.342ns 0.364314mA
+ 3.344ns 0.36272mA
+ 3.346ns 0.361133mA
+ 3.348ns 0.359554mA
+ 3.35ns 0.357981mA
+ 3.352ns 0.356415mA
+ 3.354ns 0.354856mA
+ 3.356ns 0.353303mA
+ 3.358ns 0.351758mA
+ 3.36ns 0.350219mA
+ 3.362ns 0.348687mA
+ 3.364ns 0.347162mA
+ 3.366ns 0.345643mA
+ 3.368ns 0.344131mA
+ 3.37ns 0.342626mA
+ 3.372ns 0.341127mA
+ 3.374ns 0.339635mA
+ 3.376ns 0.338149mA
+ 3.378ns 0.33667mA
+ 3.38ns 0.335197mA
+ 3.382ns 0.333731mA
+ 3.384ns 0.332271mA
+ 3.386ns 0.330817mA
+ 3.388ns 0.32937mA
+ 3.39ns 0.327929mA
+ 3.392ns 0.326495mA
+ 3.394ns 0.325066mA
+ 3.396ns 0.323644mA
+ 3.398ns 0.322229mA
+ 3.4ns 0.320819mA
+ 3.402ns 0.319416mA
+ 3.404ns 0.318018mA
+ 3.406ns 0.316627mA
+ 3.408ns 0.315242mA
+ 3.41ns 0.313863mA
+ 3.412ns 0.31249mA
+ 3.414ns 0.311123mA
+ 3.416ns 0.309762mA
+ 3.418ns 0.308407mA
+ 3.42ns 0.307057mA
+ 3.422ns 0.305714mA
+ 3.424ns 0.304377mA
+ 3.426ns 0.303045mA
+ 3.428ns 0.30172mA
+ 3.43ns 0.3004mA
+ 3.432ns 0.299085mA
+ 3.434ns 0.297777mA
+ 3.436ns 0.296474mA
+ 3.438ns 0.295178mA
+ 3.44ns 0.293886mA
+ 3.442ns 0.292601mA
+ 3.444ns 0.291321mA
+ 3.446ns 0.290046mA
+ 3.448ns 0.288777mA
+ 3.45ns 0.287514mA
+ 3.452ns 0.286256mA
+ 3.454ns 0.285004mA
+ 3.456ns 0.283757mA
+ 3.458ns 0.282516mA
+ 3.46ns 0.28128mA
+ 3.462ns 0.280049mA
+ 3.464ns 0.278824mA
+ 3.466ns 0.277604mA
+ 3.468ns 0.27639mA
+ 3.47ns 0.275181mA
+ 3.472ns 0.273977mA
+ 3.474ns 0.272778mA
+ 3.476ns 0.271585mA
+ 3.478ns 0.270397mA
+ 3.48ns 0.269214mA
+ 3.482ns 0.268036mA
+ 3.484ns 0.266864mA
+ 3.486ns 0.265696mA
+ 3.488ns 0.264534mA
+ 3.49ns 0.263377mA
+ 3.492ns 0.262224mA
+ 3.494ns 0.261077mA
+ 3.496ns 0.259935mA
+ 3.498ns 0.258798mA
+ 3.5ns 0.257666mA
+ 3.502ns 0.256539mA
+ 3.504ns 0.255416mA
+ 3.506ns 0.254299mA
+ 3.508ns 0.253186mA
+ 3.51ns 0.252079mA
+ 3.512ns 0.250976mA
+ 3.514ns 0.249878mA
+ 3.516ns 0.248785mA
+ 3.518ns 0.247696mA
+ 3.52ns 0.246613mA
+ 3.522ns 0.245534mA
+ 3.524ns 0.24446mA
+ 3.526ns 0.24339mA
+ 3.528ns 0.242325mA
+ 3.53ns 0.241265mA
+ 3.532ns 0.24021mA
+ 3.534ns 0.239159mA
+ 3.536ns 0.238113mA
+ 3.538ns 0.237071mA
+ 3.54ns 0.236034mA
+ 3.542ns 0mA
+ 8.008ns 0mA
+ 8.01ns 0.0050098mA
+ 8.012ns 0.0126921mA
+ 8.014ns 0.0203744mA
+ 8.016ns 0.0280567mA
+ 8.018ns 0.035739mA
+ 8.02ns 0.043425mA
+ 8.022ns 0.0511073mA
+ 8.024ns 0.0587896mA
+ 8.026ns 0.0664719mA
+ 8.028ns 0.0741541mA
+ 8.03ns 0.0818364mA
+ 8.032ns 0.0895187mA
+ 8.034ns 0.0972047mA
+ 8.036ns 0.104887mA
+ 8.038ns 0.112569mA
+ 8.04ns 0.120252mA
+ 8.042ns 0.127934mA
+ 8.044ns 0.135616mA
+ 8.046ns 0.143299mA
+ 8.048ns 0.150984mA
+ 8.05ns 0.158667mA
+ 8.052ns 0.166349mA
+ 8.054ns 0.174031mA
+ 8.056ns 0.181714mA
+ 8.058ns 0.189396mA
+ 8.06ns 0.197082mA
+ 8.062ns 0.204764mA
+ 8.064ns 0.212447mA
+ 8.066ns 0.220129mA
+ 8.068ns 0.227811mA
+ 8.07ns 0.235493mA
+ 8.072ns 0.243176mA
+ 8.074ns 0.250862mA
+ 8.076ns 0.258544mA
+ 8.078ns 0.266226mA
+ 8.08ns 0.273909mA
+ 8.082ns 0.281591mA
+ 8.084ns 0.289273mA
+ 8.086ns 0.296959mA
+ 8.088ns 0.304641mA
+ 8.09ns 0.312324mA
+ 8.092ns 0.320006mA
+ 8.094ns 0.327688mA
+ 8.096ns 0.335371mA
+ 8.098ns 0.343053mA
+ 8.1ns 0.350739mA
+ 8.102ns 0.358421mA
+ 8.104ns 0.366103mA
+ 8.106ns 0.373786mA
+ 8.108ns 0.381468mA
+ 8.11ns 0.38915mA
+ 8.112ns 0.396836mA
+ 8.114ns 0.404519mA
+ 8.116ns 0.412201mA
+ 8.118ns 0.419883mA
+ 8.12ns 0.427566mA
+ 8.122ns 0.435248mA
+ 8.124ns 0.44293mA
+ 8.126ns 0.450616mA
+ 8.128ns 0.458298mA
+ 8.13ns 0.465981mA
+ 8.132ns 0.473663mA
+ 8.134ns 0.481345mA
+ 8.136ns 0.489028mA
+ 8.138ns 0.49671mA
+ 8.14ns 0.504396mA
+ 8.142ns 0.512078mA
+ 8.144ns 0.51976mA
+ 8.146ns 0.527443mA
+ 8.148ns 0.535125mA
+ 8.15ns 0.542807mA
+ 8.152ns 0.550493mA
+ 8.154ns 0.550095mA
+ 8.156ns 0.54769mA
+ 8.158ns 0.545294mA
+ 8.16ns 0.542909mA
+ 8.162ns 0.540535mA
+ 8.164ns 0.538171mA
+ 8.166ns 0.535816mA
+ 8.168ns 0.533472mA
+ 8.17ns 0.531139mA
+ 8.172ns 0.528816mA
+ 8.174ns 0.526503mA
+ 8.176ns 0.5242mA
+ 8.178ns 0.521906mA
+ 8.18ns 0.519624mA
+ 8.182ns 0.517351mA
+ 8.184ns 0.515088mA
+ 8.186ns 0.512835mA
+ 8.188ns 0.510592mA
+ 8.19ns 0.508359mA
+ 8.192ns 0.506135mA
+ 8.194ns 0.503921mA
+ 8.196ns 0.501717mA
+ 8.198ns 0.499523mA
+ 8.2ns 0.497338mA
+ 8.202ns 0.495163mA
+ 8.204ns 0.492996mA
+ 8.206ns 0.490839mA
+ 8.208ns 0.488693mA
+ 8.21ns 0.486555mA
+ 8.212ns 0.484427mA
+ 8.214ns 0.482308mA
+ 8.216ns 0.480199mA
+ 8.218ns 0.478097mA
+ 8.22ns 0.476006mA
+ 8.222ns 0.473924mA
+ 8.224ns 0.471852mA
+ 8.226ns 0.469788mA
+ 8.228ns 0.467733mA
+ 8.23ns 0.465687mA
+ 8.232ns 0.463649mA
+ 8.234ns 0.461621mA
+ 8.236ns 0.459602mA
+ 8.238ns 0.457592mA
+ 8.24ns 0.455591mA
+ 8.242ns 0.453598mA
+ 8.244ns 0.451613mA
+ 8.246ns 0.449638mA
+ 8.248ns 0.447671mA
+ 8.25ns 0.445713mA
+ 8.252ns 0.443764mA
+ 8.254ns 0.441823mA
+ 8.256ns 0.43989mA
+ 8.258ns 0.437965mA
+ 8.26ns 0.43605mA
+ 8.262ns 0.434142mA
+ 8.264ns 0.432243mA
+ 8.266ns 0.430353mA
+ 8.268ns 0.42847mA
+ 8.27ns 0.426595mA
+ 8.272ns 0.42473mA
+ 8.274ns 0.422872mA
+ 8.276ns 0.421022mA
+ 8.278ns 0.419181mA
+ 8.28ns 0.417347mA
+ 8.282ns 0.415522mA
+ 8.284ns 0.413703mA
+ 8.286ns 0.411894mA
+ 8.288ns 0.410092mA
+ 8.29ns 0.408298mA
+ 8.292ns 0.406513mA
+ 8.294ns 0.404734mA
+ 8.296ns 0.402963mA
+ 8.298ns 0.401201mA
+ 8.3ns 0.399446mA
+ 8.302ns 0.397699mA
+ 8.304ns 0.395959mA
+ 8.306ns 0.394227mA
+ 8.308ns 0.392503mA
+ 8.31ns 0.390785mA
+ 8.312ns 0.389076mA
+ 8.314ns 0.387374mA
+ 8.316ns 0.38568mA
+ 8.318ns 0.383993mA
+ 8.32ns 0.382313mA
+ 8.322ns 0.380641mA
+ 8.324ns 0.378975mA
+ 8.326ns 0.377317mA
+ 8.328ns 0.375667mA
+ 8.33ns 0.374024mA
+ 8.332ns 0.372388mA
+ 8.334ns 0.370759mA
+ 8.336ns 0.369137mA
+ 8.338ns 0.367522mA
+ 8.34ns 0.365914mA
+ 8.342ns 0.364314mA
+ 8.344ns 0.36272mA
+ 8.346ns 0.361134mA
+ 8.348ns 0.359554mA
+ 8.35ns 0.35798mA
+ 8.352ns 0.356415mA
+ 8.354ns 0.354856mA
+ 8.356ns 0.353303mA
+ 8.358ns 0.351758mA
+ 8.36ns 0.350219mA
+ 8.362ns 0.348687mA
+ 8.364ns 0.347162mA
+ 8.366ns 0.345643mA
+ 8.368ns 0.344131mA
+ 8.37ns 0.342626mA
+ 8.372ns 0.341127mA
+ 8.374ns 0.339635mA
+ 8.376ns 0.338149mA
+ 8.378ns 0.33667mA
+ 8.38ns 0.335197mA
+ 8.382ns 0.333731mA
+ 8.384ns 0.332271mA
+ 8.386ns 0.330817mA
+ 8.388ns 0.32937mA
+ 8.39ns 0.327929mA
+ 8.392ns 0.326494mA
+ 8.394ns 0.325066mA
+ 8.396ns 0.323644mA
+ 8.398ns 0.322229mA
+ 8.4ns 0.320819mA
+ 8.402ns 0.319415mA
+ 8.404ns 0.318018mA
+ 8.406ns 0.316627mA
+ 8.408ns 0.315242mA
+ 8.41ns 0.313863mA
+ 8.412ns 0.31249mA
+ 8.414ns 0.311123mA
+ 8.416ns 0.309762mA
+ 8.418ns 0.308407mA
+ 8.42ns 0.307057mA
+ 8.422ns 0.305714mA
+ 8.424ns 0.304377mA
+ 8.426ns 0.303046mA
+ 8.428ns 0.301719mA
+ 8.43ns 0.3004mA
+ 8.432ns 0.299085mA
+ 8.434ns 0.297777mA
+ 8.436ns 0.296475mA
+ 8.438ns 0.295178mA
+ 8.44ns 0.293887mA
+ 8.442ns 0.2926mA
+ 8.444ns 0.29132mA
+ 8.446ns 0.290046mA
+ 8.448ns 0.288777mA
+ 8.45ns 0.287514mA
+ 8.452ns 0.286256mA
+ 8.454ns 0.285004mA
+ 8.456ns 0.283757mA
+ 8.458ns 0.282516mA
+ 8.46ns 0.28128mA
+ 8.462ns 0.280049mA
+ 8.464ns 0.278824mA
+ 8.466ns 0.277605mA
+ 8.468ns 0.27639mA
+ 8.47ns 0.275181mA
+ 8.472ns 0.273977mA
+ 8.474ns 0.272778mA
+ 8.476ns 0.271585mA
+ 8.478ns 0.270397mA
+ 8.48ns 0.269214mA
+ 8.482ns 0.268036mA
+ 8.484ns 0.266864mA
+ 8.486ns 0.265696mA
+ 8.488ns 0.264534mA
+ 8.49ns 0.263377mA
+ 8.492ns 0.262225mA
+ 8.494ns 0.261077mA
+ 8.496ns 0.259935mA
+ 8.498ns 0.258798mA
+ 8.5ns 0.257666mA
+ 8.502ns 0.256539mA
+ 8.504ns 0.255416mA
+ 8.506ns 0.254299mA
+ 8.508ns 0.253186mA
+ 8.51ns 0.252079mA
+ 8.512ns 0.250976mA
+ 8.514ns 0.249878mA
+ 8.516ns 0.248785mA
+ 8.518ns 0.247697mA
+ 8.52ns 0.246612mA
+ 8.522ns 0.245534mA
+ 8.524ns 0.24446mA
+ 8.526ns 0.24339mA
+ 8.528ns 0.242325mA
+ 8.53ns 0.241265mA
+ 8.532ns 0.24021mA
+ 8.534ns 0.239159mA
+ 8.536ns 0.238112mA
+ 8.538ns 0.237071mA
+ 8.54ns 0.236034mA
+ 8.542ns 0mA
I89 146 0 PWL 0 0
+ 3.016ns 0mA
+ 3.018ns 0.00312427mA
+ 3.02ns 0.0105398mA
+ 3.022ns 0.0179562mA
+ 3.024ns 0.0253726mA
+ 3.026ns 0.0327881mA
+ 3.028ns 0.0402044mA
+ 3.03ns 0.0476199mA
+ 3.032ns 0.0550363mA
+ 3.034ns 0.0624527mA
+ 3.036ns 0.0698682mA
+ 3.038ns 0.0772846mA
+ 3.04ns 0.0847001mA
+ 3.042ns 0.0921165mA
+ 3.044ns 0.0995329mA
+ 3.046ns 0.106948mA
+ 3.048ns 0.114365mA
+ 3.05ns 0.12178mA
+ 3.052ns 0.129197mA
+ 3.054ns 0.136613mA
+ 3.056ns 0.144029mA
+ 3.058ns 0.151445mA
+ 3.06ns 0.15886mA
+ 3.062ns 0.166277mA
+ 3.064ns 0.173693mA
+ 3.066ns 0.181109mA
+ 3.068ns 0.188525mA
+ 3.07ns 0.195941mA
+ 3.072ns 0.203357mA
+ 3.074ns 0.210773mA
+ 3.076ns 0.218189mA
+ 3.078ns 0.225605mA
+ 3.08ns 0.233022mA
+ 3.082ns 0.240437mA
+ 3.084ns 0.247854mA
+ 3.086ns 0.255269mA
+ 3.088ns 0.262685mA
+ 3.09ns 0.270102mA
+ 3.092ns 0.277517mA
+ 3.094ns 0.284934mA
+ 3.096ns 0.292349mA
+ 3.098ns 0.299766mA
+ 3.1ns 0.307182mA
+ 3.102ns 0.314598mA
+ 3.104ns 0.322014mA
+ 3.106ns 0.329429mA
+ 3.108ns 0.336846mA
+ 3.11ns 0.344262mA
+ 3.112ns 0.351678mA
+ 3.114ns 0.359094mA
+ 3.116ns 0.36651mA
+ 3.118ns 0.373926mA
+ 3.12ns 0.381342mA
+ 3.122ns 0.388758mA
+ 3.124ns 0.396174mA
+ 3.126ns 0.403591mA
+ 3.128ns 0.411006mA
+ 3.13ns 0.418423mA
+ 3.132ns 0.425838mA
+ 3.134ns 0.433254mA
+ 3.136ns 0.440671mA
+ 3.138ns 0.448086mA
+ 3.14ns 0.455503mA
+ 3.142ns 0.462918mA
+ 3.144ns 0.470335mA
+ 3.146ns 0.477751mA
+ 3.148ns 0.485166mA
+ 3.15ns 0.492583mA
+ 3.152ns 0.499998mA
+ 3.154ns 0.507415mA
+ 3.156ns 0.514831mA
+ 3.158ns 0.522247mA
+ 3.16ns 0.529663mA
+ 3.162ns 0.537079mA
+ 3.164ns 0.544495mA
+ 3.166ns 0.551911mA
+ 3.168ns 0.551557mA
+ 3.17ns 0.54927mA
+ 3.172ns 0.546992mA
+ 3.174ns 0.544724mA
+ 3.176ns 0.542466mA
+ 3.178ns 0.540216mA
+ 3.18ns 0.537976mA
+ 3.182ns 0.535745mA
+ 3.184ns 0.533524mA
+ 3.186ns 0.531312mA
+ 3.188ns 0.529109mA
+ 3.19ns 0.526914mA
+ 3.192ns 0.524729mA
+ 3.194ns 0.522554mA
+ 3.196ns 0.520387mA
+ 3.198ns 0.518229mA
+ 3.2ns 0.51608mA
+ 3.202ns 0.51394mA
+ 3.204ns 0.511809mA
+ 3.206ns 0.509687mA
+ 3.208ns 0.507573mA
+ 3.21ns 0.505468mA
+ 3.212ns 0.503372mA
+ 3.214ns 0.501285mA
+ 3.216ns 0.499206mA
+ 3.218ns 0.497136mA
+ 3.22ns 0.495075mA
+ 3.222ns 0.493022mA
+ 3.224ns 0.490978mA
+ 3.226ns 0.488942mA
+ 3.228ns 0.486914mA
+ 3.23ns 0.484895mA
+ 3.232ns 0.482884mA
+ 3.234ns 0.480882mA
+ 3.236ns 0.478888mA
+ 3.238ns 0.476902mA
+ 3.24ns 0.474925mA
+ 3.242ns 0.472955mA
+ 3.244ns 0.470994mA
+ 3.246ns 0.469041mA
+ 3.248ns 0.467096mA
+ 3.25ns 0.465159mA
+ 3.252ns 0.46323mA
+ 3.254ns 0.461309mA
+ 3.256ns 0.459396mA
+ 3.258ns 0.457491mA
+ 3.26ns 0.455594mA
+ 3.262ns 0.453705mA
+ 3.264ns 0.451823mA
+ 3.266ns 0.44995mA
+ 3.268ns 0.448084mA
+ 3.27ns 0.446226mA
+ 3.272ns 0.444375mA
+ 3.274ns 0.442533mA
+ 3.276ns 0.440698mA
+ 3.278ns 0.43887mA
+ 3.28ns 0.43705mA
+ 3.282ns 0.435238mA
+ 3.284ns 0.433433mA
+ 3.286ns 0.431636mA
+ 3.288ns 0.429846mA
+ 3.29ns 0.428063mA
+ 3.292ns 0.426288mA
+ 3.294ns 0.42452mA
+ 3.296ns 0.42276mA
+ 3.298ns 0.421007mA
+ 3.3ns 0.419261mA
+ 3.302ns 0.417522mA
+ 3.304ns 0.415791mA
+ 3.306ns 0.414067mA
+ 3.308ns 0.41235mA
+ 3.31ns 0.41064mA
+ 3.312ns 0.408937mA
+ 3.314ns 0.407241mA
+ 3.316ns 0.405552mA
+ 3.318ns 0.40387mA
+ 3.32ns 0.402196mA
+ 3.322ns 0.400528mA
+ 3.324ns 0.398867mA
+ 3.326ns 0.397213mA
+ 3.328ns 0.395566mA
+ 3.33ns 0.393925mA
+ 3.332ns 0.392292mA
+ 3.334ns 0.390665mA
+ 3.336ns 0.389045mA
+ 3.338ns 0.387431mA
+ 3.34ns 0.385825mA
+ 3.342ns 0.384225mA
+ 3.344ns 0.382631mA
+ 3.346ns 0.381045mA
+ 3.348ns 0.379465mA
+ 3.35ns 0.377891mA
+ 3.352ns 0.376324mA
+ 3.354ns 0.374763mA
+ 3.356ns 0.373209mA
+ 3.358ns 0.371661mA
+ 3.36ns 0.37012mA
+ 3.362ns 0.368585mA
+ 3.364ns 0.367057mA
+ 3.366ns 0.365534mA
+ 3.368ns 0.364019mA
+ 3.37ns 0.362509mA
+ 3.372ns 0.361006mA
+ 3.374ns 0.359509mA
+ 3.376ns 0.358018mA
+ 3.378ns 0.356533mA
+ 3.38ns 0.355054mA
+ 3.382ns 0.353582mA
+ 3.384ns 0.352116mA
+ 3.386ns 0.350655mA
+ 3.388ns 0.349201mA
+ 3.39ns 0.347753mA
+ 3.392ns 0.346311mA
+ 3.394ns 0.344875mA
+ 3.396ns 0.343445mA
+ 3.398ns 0.34202mA
+ 3.4ns 0.340602mA
+ 3.402ns 0.33919mA
+ 3.404ns 0.337783mA
+ 3.406ns 0.336382mA
+ 3.408ns 0.334987mA
+ 3.41ns 0.333598mA
+ 3.412ns 0.332214mA
+ 3.414ns 0.330837mA
+ 3.416ns 0.329465mA
+ 3.418ns 0.328098mA
+ 3.42ns 0.326738mA
+ 3.422ns 0.325383mA
+ 3.424ns 0.324033mA
+ 3.426ns 0.322689mA
+ 3.428ns 0.321351mA
+ 3.43ns 0.320019mA
+ 3.432ns 0.318691mA
+ 3.434ns 0.31737mA
+ 3.436ns 0.316054mA
+ 3.438ns 0.314743mA
+ 3.44ns 0.313438mA
+ 3.442ns 0.312138mA
+ 3.444ns 0.310843mA
+ 3.446ns 0.309554mA
+ 3.448ns 0.30827mA
+ 3.45ns 0.306992mA
+ 3.452ns 0.305719mA
+ 3.454ns 0.304451mA
+ 3.456ns 0.303188mA
+ 3.458ns 0.301931mA
+ 3.46ns 0.300679mA
+ 3.462ns 0.299432mA
+ 3.464ns 0.29819mA
+ 3.466ns 0.296953mA
+ 3.468ns 0.295722mA
+ 3.47ns 0.294495mA
+ 3.472ns 0.293274mA
+ 3.474ns 0.292058mA
+ 3.476ns 0.290847mA
+ 3.478ns 0.28964mA
+ 3.48ns 0.288439mA
+ 3.482ns 0.287243mA
+ 3.484ns 0.286052mA
+ 3.486ns 0.284865mA
+ 3.488ns 0.283684mA
+ 3.49ns 0.282507mA
+ 3.492ns 0.281336mA
+ 3.494ns 0.280169mA
+ 3.496ns 0.279007mA
+ 3.498ns 0.27785mA
+ 3.5ns 0.276698mA
+ 3.502ns 0.27555mA
+ 3.504ns 0.274407mA
+ 3.506ns 0.273269mA
+ 3.508ns 0.272136mA
+ 3.51ns 0.271007mA
+ 3.512ns 0.269883mA
+ 3.514ns 0.268764mA
+ 3.516ns 0.267649mA
+ 3.518ns 0.266539mA
+ 3.52ns 0.265434mA
+ 3.522ns 0.264333mA
+ 3.524ns 0.263237mA
+ 3.526ns 0.262145mA
+ 3.528ns 0.261058mA
+ 3.53ns 0.259975mA
+ 3.532ns 0.258897mA
+ 3.534ns 0.257823mA
+ 3.536ns 0.256754mA
+ 3.538ns 0.255689mA
+ 3.54ns 0.254629mA
+ 3.542ns 0.253573mA
+ 3.544ns 0.252521mA
+ 3.546ns 0.251474mA
+ 3.548ns 0.250431mA
+ 3.55ns 0.249392mA
+ 3.552ns 0.248358mA
+ 3.554ns 0.247328mA
+ 3.556ns 0.246302mA
+ 3.558ns 0.245281mA
+ 3.56ns 0.244263mA
+ 3.562ns 0.24325mA
+ 3.564ns 0.242241mA
+ 3.566ns 0.241237mA
+ 3.568ns 0.240236mA
+ 3.57ns 0.23924mA
+ 3.572ns 0.238248mA
+ 3.574ns 0.237259mA
+ 3.576ns 0mA
+ 8.016ns 0mA
+ 8.018ns 0.0031225mA
+ 8.02ns 0.0105415mA
+ 8.022ns 0.017957mA
+ 8.024ns 0.0253726mA
+ 8.026ns 0.0327881mA
+ 8.028ns 0.0402036mA
+ 8.03ns 0.0476191mA
+ 8.032ns 0.0550346mA
+ 8.034ns 0.0624536mA
+ 8.036ns 0.0698691mA
+ 8.038ns 0.0772846mA
+ 8.04ns 0.0847001mA
+ 8.042ns 0.0921156mA
+ 8.044ns 0.0995311mA
+ 8.046ns 0.106947mA
+ 8.048ns 0.114366mA
+ 8.05ns 0.121781mA
+ 8.052ns 0.129197mA
+ 8.054ns 0.136612mA
+ 8.056ns 0.144028mA
+ 8.058ns 0.151443mA
+ 8.06ns 0.158862mA
+ 8.062ns 0.166278mA
+ 8.064ns 0.173693mA
+ 8.066ns 0.181109mA
+ 8.068ns 0.188524mA
+ 8.07ns 0.19594mA
+ 8.072ns 0.203355mA
+ 8.074ns 0.210774mA
+ 8.076ns 0.21819mA
+ 8.078ns 0.225605mA
+ 8.08ns 0.233021mA
+ 8.082ns 0.240436mA
+ 8.084ns 0.247852mA
+ 8.086ns 0.255271mA
+ 8.088ns 0.262686mA
+ 8.09ns 0.270102mA
+ 8.092ns 0.277517mA
+ 8.094ns 0.284933mA
+ 8.096ns 0.292348mA
+ 8.098ns 0.299764mA
+ 8.1ns 0.307183mA
+ 8.102ns 0.314598mA
+ 8.104ns 0.322014mA
+ 8.106ns 0.329429mA
+ 8.108ns 0.336845mA
+ 8.11ns 0.34426mA
+ 8.112ns 0.351679mA
+ 8.114ns 0.359095mA
+ 8.116ns 0.36651mA
+ 8.118ns 0.373926mA
+ 8.12ns 0.381341mA
+ 8.122ns 0.388757mA
+ 8.124ns 0.396172mA
+ 8.126ns 0.403592mA
+ 8.128ns 0.411007mA
+ 8.13ns 0.418423mA
+ 8.132ns 0.425838mA
+ 8.134ns 0.433254mA
+ 8.136ns 0.440669mA
+ 8.138ns 0.448085mA
+ 8.14ns 0.455504mA
+ 8.142ns 0.462919mA
+ 8.144ns 0.470335mA
+ 8.146ns 0.47775mA
+ 8.148ns 0.485166mA
+ 8.15ns 0.492581mA
+ 8.152ns 0.5mA
+ 8.154ns 0.507416mA
+ 8.156ns 0.514831mA
+ 8.158ns 0.522247mA
+ 8.16ns 0.529662mA
+ 8.162ns 0.537078mA
+ 8.164ns 0.544493mA
+ 8.166ns 0.551912mA
+ 8.168ns 0.551557mA
+ 8.17ns 0.54927mA
+ 8.172ns 0.546993mA
+ 8.174ns 0.544725mA
+ 8.176ns 0.542466mA
+ 8.178ns 0.540216mA
+ 8.18ns 0.537976mA
+ 8.182ns 0.535745mA
+ 8.184ns 0.533524mA
+ 8.186ns 0.531312mA
+ 8.188ns 0.529109mA
+ 8.19ns 0.526915mA
+ 8.192ns 0.524729mA
+ 8.194ns 0.522554mA
+ 8.196ns 0.520387mA
+ 8.198ns 0.518229mA
+ 8.2ns 0.51608mA
+ 8.202ns 0.513941mA
+ 8.204ns 0.511809mA
+ 8.206ns 0.509686mA
+ 8.208ns 0.507573mA
+ 8.21ns 0.505468mA
+ 8.212ns 0.503373mA
+ 8.214ns 0.501285mA
+ 8.216ns 0.499207mA
+ 8.218ns 0.497136mA
+ 8.22ns 0.495075mA
+ 8.222ns 0.493022mA
+ 8.224ns 0.490978mA
+ 8.226ns 0.488942mA
+ 8.228ns 0.486915mA
+ 8.23ns 0.484896mA
+ 8.232ns 0.482884mA
+ 8.234ns 0.480882mA
+ 8.236ns 0.478888mA
+ 8.238ns 0.476902mA
+ 8.24ns 0.474925mA
+ 8.242ns 0.472956mA
+ 8.244ns 0.470994mA
+ 8.246ns 0.469041mA
+ 8.248ns 0.467096mA
+ 8.25ns 0.465159mA
+ 8.252ns 0.46323mA
+ 8.254ns 0.461309mA
+ 8.256ns 0.459397mA
+ 8.258ns 0.457491mA
+ 8.26ns 0.455594mA
+ 8.262ns 0.453705mA
+ 8.264ns 0.451824mA
+ 8.266ns 0.44995mA
+ 8.268ns 0.448084mA
+ 8.27ns 0.446225mA
+ 8.272ns 0.444375mA
+ 8.274ns 0.442533mA
+ 8.276ns 0.440698mA
+ 8.278ns 0.43887mA
+ 8.28ns 0.437051mA
+ 8.282ns 0.435238mA
+ 8.284ns 0.433433mA
+ 8.286ns 0.431635mA
+ 8.288ns 0.429846mA
+ 8.29ns 0.428063mA
+ 8.292ns 0.426288mA
+ 8.294ns 0.424521mA
+ 8.296ns 0.42276mA
+ 8.298ns 0.421007mA
+ 8.3ns 0.419261mA
+ 8.302ns 0.417522mA
+ 8.304ns 0.415791mA
+ 8.306ns 0.414067mA
+ 8.308ns 0.41235mA
+ 8.31ns 0.410639mA
+ 8.312ns 0.408937mA
+ 8.314ns 0.407241mA
+ 8.316ns 0.405552mA
+ 8.318ns 0.403871mA
+ 8.32ns 0.402196mA
+ 8.322ns 0.400528mA
+ 8.324ns 0.398867mA
+ 8.326ns 0.397213mA
+ 8.328ns 0.395566mA
+ 8.33ns 0.393925mA
+ 8.332ns 0.392292mA
+ 8.334ns 0.390665mA
+ 8.336ns 0.389044mA
+ 8.338ns 0.387431mA
+ 8.34ns 0.385825mA
+ 8.342ns 0.384225mA
+ 8.344ns 0.382632mA
+ 8.346ns 0.381045mA
+ 8.348ns 0.379465mA
+ 8.35ns 0.377891mA
+ 8.352ns 0.376324mA
+ 8.354ns 0.374763mA
+ 8.356ns 0.373209mA
+ 8.358ns 0.371662mA
+ 8.36ns 0.37012mA
+ 8.362ns 0.368585mA
+ 8.364ns 0.367057mA
+ 8.366ns 0.365534mA
+ 8.368ns 0.364019mA
+ 8.37ns 0.362509mA
+ 8.372ns 0.361006mA
+ 8.374ns 0.359509mA
+ 8.376ns 0.358018mA
+ 8.378ns 0.356533mA
+ 8.38ns 0.355054mA
+ 8.382ns 0.353582mA
+ 8.384ns 0.352116mA
+ 8.386ns 0.350656mA
+ 8.388ns 0.349201mA
+ 8.39ns 0.347753mA
+ 8.392ns 0.346311mA
+ 8.394ns 0.344875mA
+ 8.396ns 0.343445mA
+ 8.398ns 0.342021mA
+ 8.4ns 0.340602mA
+ 8.402ns 0.339189mA
+ 8.404ns 0.337783mA
+ 8.406ns 0.336382mA
+ 8.408ns 0.334987mA
+ 8.41ns 0.333598mA
+ 8.412ns 0.332215mA
+ 8.414ns 0.330837mA
+ 8.416ns 0.329464mA
+ 8.418ns 0.328098mA
+ 8.42ns 0.326738mA
+ 8.422ns 0.325383mA
+ 8.424ns 0.324033mA
+ 8.426ns 0.32269mA
+ 8.428ns 0.321351mA
+ 8.43ns 0.320018mA
+ 8.432ns 0.318691mA
+ 8.434ns 0.31737mA
+ 8.436ns 0.316054mA
+ 8.438ns 0.314743mA
+ 8.44ns 0.313438mA
+ 8.442ns 0.312137mA
+ 8.444ns 0.310843mA
+ 8.446ns 0.309554mA
+ 8.448ns 0.30827mA
+ 8.45ns 0.306992mA
+ 8.452ns 0.305719mA
+ 8.454ns 0.304451mA
+ 8.456ns 0.303188mA
+ 8.458ns 0.301931mA
+ 8.46ns 0.300679mA
+ 8.462ns 0.299432mA
+ 8.464ns 0.29819mA
+ 8.466ns 0.296954mA
+ 8.468ns 0.295722mA
+ 8.47ns 0.294495mA
+ 8.472ns 0.293274mA
+ 8.474ns 0.292058mA
+ 8.476ns 0.290847mA
+ 8.478ns 0.289641mA
+ 8.48ns 0.288439mA
+ 8.482ns 0.287243mA
+ 8.484ns 0.286052mA
+ 8.486ns 0.284865mA
+ 8.488ns 0.283684mA
+ 8.49ns 0.282508mA
+ 8.492ns 0.281336mA
+ 8.494ns 0.280169mA
+ 8.496ns 0.279007mA
+ 8.498ns 0.27785mA
+ 8.5ns 0.276698mA
+ 8.502ns 0.27555mA
+ 8.504ns 0.274408mA
+ 8.506ns 0.27327mA
+ 8.508ns 0.272136mA
+ 8.51ns 0.271007mA
+ 8.512ns 0.269883mA
+ 8.514ns 0.268764mA
+ 8.516ns 0.26765mA
+ 8.518ns 0.26654mA
+ 8.52ns 0.265434mA
+ 8.522ns 0.264333mA
+ 8.524ns 0.263237mA
+ 8.526ns 0.262145mA
+ 8.528ns 0.261058mA
+ 8.53ns 0.259975mA
+ 8.532ns 0.258897mA
+ 8.534ns 0.257823mA
+ 8.536ns 0.256754mA
+ 8.538ns 0.255689mA
+ 8.54ns 0.254629mA
+ 8.542ns 0.253573mA
+ 8.544ns 0.252521mA
+ 8.546ns 0.251474mA
+ 8.548ns 0.250431mA
+ 8.55ns 0.249392mA
+ 8.552ns 0.248358mA
+ 8.554ns 0.247328mA
+ 8.556ns 0.246302mA
+ 8.558ns 0.245281mA
+ 8.56ns 0.244263mA
+ 8.562ns 0.24325mA
+ 8.564ns 0.242241mA
+ 8.566ns 0.241237mA
+ 8.568ns 0.240236mA
+ 8.57ns 0.23924mA
+ 8.572ns 0.238247mA
+ 8.574ns 0.237259mA
+ 8.576ns 0mA
I90 147 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00736666mA
+ 2.656ns 0.0177064mA
+ 2.658ns 0.0280449mA
+ 2.66ns 0.0383846mA
+ 2.662ns 0.0487231mA
+ 2.664ns 0.0590628mA
+ 2.666ns 0.0694026mA
+ 2.668ns 0.0797411mA
+ 2.67ns 0.0900808mA
+ 2.672ns 0.100419mA
+ 2.674ns 0.110759mA
+ 2.676ns 0.121099mA
+ 2.678ns 0.124105mA
+ 2.68ns 0.11099mA
+ 2.682ns 0.0992612mA
+ 2.684ns 0.0887705mA
+ 2.686ns 0.0793884mA
+ 2.688ns 0.0709985mA
+ 2.69ns 0.0634943mA
+ 2.692ns 0.0567831mA
+ 2.694ns 0.0507817mA
+ 2.696ns 0.0454139mA
+ 2.698ns 0.0406139mA
+ 2.7ns 0.0363206mA
+ 2.702ns 0.0324811mA
+ 2.704ns 0mA
I91 148 0 PWL 0 0
+ 0.224ns 0mA
+ 0.226ns 0.000736661mA
+ 0.228ns 0.00391778mA
+ 0.23ns 0.00709888mA
+ 0.232ns 0.01028mA
+ 0.234ns 0.0134611mA
+ 0.236ns 0.0166422mA
+ 0.238ns 0.0198233mA
+ 0.24ns 0.0230045mA
+ 0.242ns 0.0261856mA
+ 0.244ns 0.0293667mA
+ 0.246ns 0.0325478mA
+ 0.248ns 0.0357289mA
+ 0.25ns 0.03891mA
+ 0.252ns 0.0420911mA
+ 0.254ns 0.0452722mA
+ 0.256ns 0.0484534mA
+ 0.258ns 0.0516345mA
+ 0.26ns 0.0548156mA
+ 0.262ns 0.0576175mA
+ 0.264ns 0.0533877mA
+ 0.266ns 0.0494682mA
+ 0.268ns 0.0458364mA
+ 0.27ns 0.0424712mA
+ 0.272ns 0.039353mA
+ 0.274ns 0.0364637mA
+ 0.276ns 0.0337865mA
+ 0.278ns 0.0313058mA
+ 0.28ns 0.0290072mA
+ 0.282ns 0.0268773mA
+ 0.284ns 0.0249038mA
+ 0.286ns 0.0230752mA
+ 0.288ns 0.0213808mA
+ 0.29ns 0.0198108mA
+ 0.292ns 0.018356mA
+ 0.294ns 0.0170081mA
+ 0.296ns 0.0157591mA
+ 0.298ns 0.0146018mA
+ 0.3ns 0mA
+ 5.224ns 0mA
+ 5.226ns 0.000736471mA
+ 5.228ns 0.00391811mA
+ 5.23ns 0.007099mA
+ 5.232ns 0.0102799mA
+ 5.234ns 0.0134615mA
+ 5.236ns 0.0166424mA
+ 5.238ns 0.0198233mA
+ 5.24ns 0.0230049mA
+ 5.242ns 0.0261858mA
+ 5.244ns 0.0293667mA
+ 5.246ns 0.0325483mA
+ 5.248ns 0.0357292mA
+ 5.25ns 0.0389101mA
+ 5.252ns 0.042091mA
+ 5.254ns 0.0452726mA
+ 5.256ns 0.0484535mA
+ 5.258ns 0.0516344mA
+ 5.26ns 0.054816mA
+ 5.262ns 0.0576173mA
+ 5.264ns 0.0533877mA
+ 5.266ns 0.0494676mA
+ 5.268ns 0.0458361mA
+ 5.27ns 0.0424712mA
+ 5.272ns 0.0393532mA
+ 5.274ns 0.0364634mA
+ 5.276ns 0.0337864mA
+ 5.278ns 0.0313059mA
+ 5.28ns 0.0290069mA
+ 5.282ns 0.0268772mA
+ 5.284ns 0.0249038mA
+ 5.286ns 0.0230749mA
+ 5.288ns 0.0213807mA
+ 5.29ns 0.0198108mA
+ 5.292ns 0.0183558mA
+ 5.294ns 0.017008mA
+ 5.296ns 0.0157591mA
+ 5.298ns 0.0146019mA
+ 5.3ns 0mA
I92 149 0 PWL 0 0
+ 0.662ns 0mA
+ 0.664ns 0.00147653mA
+ 0.666ns 0.00750799mA
+ 0.668ns 0.0135396mA
+ 0.67ns 0.0195711mA
+ 0.672ns 0.0256027mA
+ 0.674ns 0.0316342mA
+ 0.676ns 0.0376658mA
+ 0.678ns 0.0436973mA
+ 0.68ns 0.0497288mA
+ 0.682ns 0.0557604mA
+ 0.684ns 0.0617919mA
+ 0.686ns 0.0678235mA
+ 0.688ns 0.073855mA
+ 0.69ns 0.0693451mA
+ 0.692ns 0.0620626mA
+ 0.694ns 0.0555447mA
+ 0.696ns 0.049711mA
+ 0.698ns 0.0444901mA
+ 0.7ns 0.0398172mA
+ 0.702ns 0.0356351mA
+ 0.704ns 0.0318921mA
+ 0.706ns 0.0285422mA
+ 0.708ns 0.0255441mA
+ 0.71ns 0.0228608mA
+ 0.712ns 0.0204594mA
+ 0.714ns 0mA
+ 5.662ns 0mA
+ 5.664ns 0.00177869mA
+ 5.666ns 0.0078098mA
+ 5.668ns 0.0138423mA
+ 5.67ns 0.0198734mA
+ 5.672ns 0.0259045mA
+ 5.674ns 0.0319371mA
+ 5.676ns 0.0379682mA
+ 5.678ns 0.0439993mA
+ 5.68ns 0.0500318mA
+ 5.682ns 0.0560629mA
+ 5.684ns 0.062094mA
+ 5.686ns 0.0681251mA
+ 5.688ns 0.0741577mA
+ 5.69ns 0.0689608mA
+ 5.692ns 0.061719mA
+ 5.694ns 0.0552361mA
+ 5.696ns 0.0494353mA
+ 5.698ns 0.0442436mA
+ 5.7ns 0.0395959mA
+ 5.702ns 0.0354373mA
+ 5.704ns 0.0317154mA
+ 5.706ns 0.0283842mA
+ 5.708ns 0.0254023mA
+ 5.71ns 0.0227341mA
+ 5.712ns 0.0203461mA
+ 5.714ns 0mA
I93 151 0 PWL 0 0
+ 5.74ns 0mA
+ 5.742ns 0.0105166mA
+ 5.744ns 0.0211173mA
+ 5.746ns 0.0317206mA
+ 5.748ns 0.0423213mA
+ 5.75ns 0.0529221mA
+ 5.752ns 0.0635228mA
+ 5.754ns 0.0741261mA
+ 5.756ns 0.0847268mA
+ 5.758ns 0.0953276mA
+ 5.76ns 0.0935386mA
+ 5.762ns 0.0808284mA
+ 5.764ns 0.069845mA
+ 5.766ns 0.0603516mA
+ 5.768ns 0.0521501mA
+ 5.77ns 0.0450629mA
+ 5.772ns 0.0389373mA
+ 5.774ns 0.0336454mA
+ 5.776ns 0.0290725mA
+ 5.778ns 0mA
I94 152 0 PWL 0 0
+ 7.758ns 0mA
+ 7.76ns 0.00296103mA
+ 7.762ns 0.105158mA
+ 7.764ns 0.106259mA
+ 7.766ns 0.102212mA
+ 7.768ns 0.0983209mA
+ 7.77ns 0.0945776mA
+ 7.772ns 0.0909759mA
+ 7.774ns 0.0875121mA
+ 7.776ns 0.0841802mA
+ 7.778ns 0.0809751mA
+ 7.78ns 0.0778913mA
+ 7.782ns 0.0749256mA
+ 7.784ns 0.0720728mA
+ 7.786ns 0.0693279mA
+ 7.788ns 0.0666882mA
+ 7.79ns 0.0641489mA
+ 7.792ns 0.0617058mA
+ 7.794ns 0.0593562mA
+ 7.796ns 0.0570961mA
+ 7.798ns 0.054922mA
+ 7.8ns 0mA
I95 154 0 PWL 0 0
+ 7.818ns 0mA
+ 7.82ns 0.000435998mA
+ 7.822ns 0.00839025mA
+ 7.824ns 0.0163445mA
+ 7.826ns 0.0243007mA
+ 7.828ns 0.0322549mA
+ 7.83ns 0.0402092mA
+ 7.832ns 0.0481653mA
+ 7.834ns 0.0561196mA
+ 7.836ns 0.0631258mA
+ 7.838ns 0.0530858mA
+ 7.84ns 0.0446442mA
+ 7.842ns 0.0375447mA
+ 7.844ns 0.031574mA
+ 7.846ns 0.0265514mA
+ 7.848ns 0.0223286mA
+ 7.85ns 0.0187773mA
+ 7.852ns 0mA
I96 156 0 PWL 0 0
+ 2.744ns 0mA
+ 2.746ns 0.000196569mA
+ 2.748ns 0.00521569mA
+ 2.75ns 0.0102342mA
+ 2.752ns 0.0152533mA
+ 2.754ns 0.0202718mA
+ 2.756ns 0.025291mA
+ 2.758ns 0.0303101mA
+ 2.76ns 0.0353286mA
+ 2.762ns 0.0403477mA
+ 2.764ns 0.0453662mA
+ 2.766ns 0.0503854mA
+ 2.768ns 0.0554045mA
+ 2.77ns 0.060423mA
+ 2.772ns 0.0654421mA
+ 2.774ns 0.0704606mA
+ 2.776ns 0.0719154mA
+ 2.778ns 0.0654593mA
+ 2.78ns 0.0595833mA
+ 2.782ns 0.0542341mA
+ 2.784ns 0.0493656mA
+ 2.786ns 0.0449335mA
+ 2.788ns 0.0408992mA
+ 2.79ns 0.0372275mA
+ 2.792ns 0.0338849mA
+ 2.794ns 0.0308424mA
+ 2.796ns 0.0280734mA
+ 2.798ns 0.0255526mA
+ 2.8ns 0.0232583mA
+ 2.802ns 0.0211698mA
+ 2.804ns 0.0192688mA
+ 2.806ns 0mA
I97 160 0 PWL 0 0
+ 7.858ns 0mA
+ 7.86ns 0.00423951mA
+ 7.862ns 0.0100416mA
+ 7.864ns 0.0158451mA
+ 7.866ns 0.0216472mA
+ 7.868ns 0.0274493mA
+ 7.87ns 0.0332514mA
+ 7.872ns 0.0390548mA
+ 7.874ns 0.0448569mA
+ 7.876ns 0.050659mA
+ 7.878ns 0.0564625mA
+ 7.88ns 0.0622646mA
+ 7.882ns 0.0680667mA
+ 7.884ns 0.0738702mA
+ 7.886ns 0.075553mA
+ 7.888ns 0.0681438mA
+ 7.89ns 0.061461mA
+ 7.892ns 0.055432mA
+ 7.894ns 0.0499956mA
+ 7.896ns 0.0450923mA
+ 7.898ns 0.0406687mA
+ 7.9ns 0.0366799mA
+ 7.902ns 0.0330822mA
+ 7.904ns 0.0298366mA
+ 7.906ns 0.02691mA
+ 7.908ns 0.0242704mA
+ 7.91ns 0.0218891mA
+ 7.912ns 0.0197419mA
+ 7.914ns 0mA
I98 166 0 PWL 0 0
+ 5.52ns 0mA
+ 5.522ns 0.00547573mA
+ 5.524ns 0.0128817mA
+ 5.526ns 0.020286mA
+ 5.528ns 0.0276902mA
+ 5.53ns 0.0350962mA
+ 5.532ns 0.0425005mA
+ 5.534ns 0.0499047mA
+ 5.536ns 0.0573107mA
+ 5.538ns 0.064715mA
+ 5.54ns 0.0721192mA
+ 5.542ns 0.0795252mA
+ 5.544ns 0.0869295mA
+ 5.546ns 0.0943337mA
+ 5.548ns 0.101738mA
+ 5.55ns 0.109144mA
+ 5.552ns 0.116548mA
+ 5.554ns 0.123952mA
+ 5.556ns 0.131358mA
+ 5.558ns 0.138763mA
+ 5.56ns 0.146167mA
+ 5.562ns 0.153573mA
+ 5.564ns 0.160977mA
+ 5.566ns 0.168381mA
+ 5.568ns 0.175786mA
+ 5.57ns 0.183192mA
+ 5.572ns 0.190596mA
+ 5.574ns 0.198mA
+ 5.576ns 0.205406mA
+ 5.578ns 0.21281mA
+ 5.58ns 0.220215mA
+ 5.582ns 0.227621mA
+ 5.584ns 0.235025mA
+ 5.586ns 0.242429mA
+ 5.588ns 0.249835mA
+ 5.59ns 0.257239mA
+ 5.592ns 0.264644mA
+ 5.594ns 0.272048mA
+ 5.596ns 0.279454mA
+ 5.598ns 0.286858mA
+ 5.6ns 0.294262mA
+ 5.602ns 0.301668mA
+ 5.604ns 0.309073mA
+ 5.606ns 0.316477mA
+ 5.608ns 0.323883mA
+ 5.61ns 0.331287mA
+ 5.612ns 0.338691mA
+ 5.614ns 0.346096mA
+ 5.616ns 0.353502mA
+ 5.618ns 0.360906mA
+ 5.62ns 0.36831mA
+ 5.622ns 0.375716mA
+ 5.624ns 0.38312mA
+ 5.626ns 0.390525mA
+ 5.628ns 0.397931mA
+ 5.63ns 0.405335mA
+ 5.632ns 0.412739mA
+ 5.634ns 0.420145mA
+ 5.636ns 0.427549mA
+ 5.638ns 0.434954mA
+ 5.64ns 0.442358mA
+ 5.642ns 0.449764mA
+ 5.644ns 0.457168mA
+ 5.646ns 0.464572mA
+ 5.648ns 0.471978mA
+ 5.65ns 0.479383mA
+ 5.652ns 0.486787mA
+ 5.654ns 0.494193mA
+ 5.656ns 0.501597mA
+ 5.658ns 0.509001mA
+ 5.66ns 0.516406mA
+ 5.662ns 0.523812mA
+ 5.664ns 0.531216mA
+ 5.666ns 0.534754mA
+ 5.668ns 0.5325mA
+ 5.67ns 0.530257mA
+ 5.672ns 0.528023mA
+ 5.674ns 0.525798mA
+ 5.676ns 0.523583mA
+ 5.678ns 0.521377mA
+ 5.68ns 0.51918mA
+ 5.682ns 0.516993mA
+ 5.684ns 0.514815mA
+ 5.686ns 0.512646mA
+ 5.688ns 0.510486mA
+ 5.69ns 0.508336mA
+ 5.692ns 0.506194mA
+ 5.694ns 0.504061mA
+ 5.696ns 0.501937mA
+ 5.698ns 0.499823mA
+ 5.7ns 0.497717mA
+ 5.702ns 0.49562mA
+ 5.704ns 0.493532mA
+ 5.706ns 0.491453mA
+ 5.708ns 0.489382mA
+ 5.71ns 0.48732mA
+ 5.712ns 0.485267mA
+ 5.714ns 0.483222mA
+ 5.716ns 0.481186mA
+ 5.718ns 0.479159mA
+ 5.72ns 0.47714mA
+ 5.722ns 0.47513mA
+ 5.724ns 0.473128mA
+ 5.726ns 0.471134mA
+ 5.728ns 0.46915mA
+ 5.73ns 0.467173mA
+ 5.732ns 0.465205mA
+ 5.734ns 0.463245mA
+ 5.736ns 0.461293mA
+ 5.738ns 0.459349mA
+ 5.74ns 0.457414mA
+ 5.742ns 0.455487mA
+ 5.744ns 0.453568mA
+ 5.746ns 0.451656mA
+ 5.748ns 0.449754mA
+ 5.75ns 0.447859mA
+ 5.752ns 0.445972mA
+ 5.754ns 0.444093mA
+ 5.756ns 0.442222mA
+ 5.758ns 0.440359mA
+ 5.76ns 0.438503mA
+ 5.762ns 0.436656mA
+ 5.764ns 0.434816mA
+ 5.766ns 0.432984mA
+ 5.768ns 0.431159mA
+ 5.77ns 0.429343mA
+ 5.772ns 0.427534mA
+ 5.774ns 0.425732mA
+ 5.776ns 0.423939mA
+ 5.778ns 0.422153mA
+ 5.78ns 0.420374mA
+ 5.782ns 0.418603mA
+ 5.784ns 0.416839mA
+ 5.786ns 0.415083mA
+ 5.788ns 0.413334mA
+ 5.79ns 0.411592mA
+ 5.792ns 0.409858mA
+ 5.794ns 0.408131mA
+ 5.796ns 0.406412mA
+ 5.798ns 0.404699mA
+ 5.8ns 0.402994mA
+ 5.802ns 0.401296mA
+ 5.804ns 0.399605mA
+ 5.806ns 0.397921mA
+ 5.808ns 0.396245mA
+ 5.81ns 0.394576mA
+ 5.812ns 0.392913mA
+ 5.814ns 0.391257mA
+ 5.816ns 0.389609mA
+ 5.818ns 0.387967mA
+ 5.82ns 0.386332mA
+ 5.822ns 0.384705mA
+ 5.824ns 0.383084mA
+ 5.826ns 0.38147mA
+ 5.828ns 0.379862mA
+ 5.83ns 0.378262mA
+ 5.832ns 0.376668mA
+ 5.834ns 0.375081mA
+ 5.836ns 0.373501mA
+ 5.838ns 0.371927mA
+ 5.84ns 0.37036mA
+ 5.842ns 0.368799mA
+ 5.844ns 0.367246mA
+ 5.846ns 0.365698mA
+ 5.848ns 0.364157mA
+ 5.85ns 0.362623mA
+ 5.852ns 0.361095mA
+ 5.854ns 0.359573mA
+ 5.856ns 0.358058mA
+ 5.858ns 0.356549mA
+ 5.86ns 0.355047mA
+ 5.862ns 0.353551mA
+ 5.864ns 0.352061mA
+ 5.866ns 0.350578mA
+ 5.868ns 0.349101mA
+ 5.87ns 0.34763mA
+ 5.872ns 0.346165mA
+ 5.874ns 0.344707mA
+ 5.876ns 0.343254mA
+ 5.878ns 0.341808mA
+ 5.88ns 0.340368mA
+ 5.882ns 0.338934mA
+ 5.884ns 0.337505mA
+ 5.886ns 0.336083mA
+ 5.888ns 0.334667mA
+ 5.89ns 0.333257mA
+ 5.892ns 0.331853mA
+ 5.894ns 0.330454mA
+ 5.896ns 0.329062mA
+ 5.898ns 0.327675mA
+ 5.9ns 0.326295mA
+ 5.902ns 0.32492mA
+ 5.904ns 0.323551mA
+ 5.906ns 0.322188mA
+ 5.908ns 0.32083mA
+ 5.91ns 0.319478mA
+ 5.912ns 0.318132mA
+ 5.914ns 0.316791mA
+ 5.916ns 0.315457mA
+ 5.918ns 0.314127mA
+ 5.92ns 0.312804mA
+ 5.922ns 0.311486mA
+ 5.924ns 0.310173mA
+ 5.926ns 0.308866mA
+ 5.928ns 0.307565mA
+ 5.93ns 0.306269mA
+ 5.932ns 0.304978mA
+ 5.934ns 0.303693mA
+ 5.936ns 0.302414mA
+ 5.938ns 0.301139mA
+ 5.94ns 0.29987mA
+ 5.942ns 0.298607mA
+ 5.944ns 0.297348mA
+ 5.946ns 0.296096mA
+ 5.948ns 0.294848mA
+ 5.95ns 0.293605mA
+ 5.952ns 0.292368mA
+ 5.954ns 0.291136mA
+ 5.956ns 0.289909mA
+ 5.958ns 0.288688mA
+ 5.96ns 0.287472mA
+ 5.962ns 0.28626mA
+ 5.964ns 0.285054mA
+ 5.966ns 0.283853mA
+ 5.968ns 0.282657mA
+ 5.97ns 0.281466mA
+ 5.972ns 0.28028mA
+ 5.974ns 0.279099mA
+ 5.976ns 0.277922mA
+ 5.978ns 0.276751mA
+ 5.98ns 0.275585mA
+ 5.982ns 0.274424mA
+ 5.984ns 0.273268mA
+ 5.986ns 0.272116mA
+ 5.988ns 0.27097mA
+ 5.99ns 0.269828mA
+ 5.992ns 0.268691mA
+ 5.994ns 0.267559mA
+ 5.996ns 0.266431mA
+ 5.998ns 0.265308mA
+ 6ns 0.26419mA
+ 6.002ns 0.263077mA
+ 6.004ns 0.261969mA
+ 6.006ns 0.260865mA
+ 6.008ns 0.259766mA
+ 6.01ns 0.258671mA
+ 6.012ns 0.257581mA
+ 6.014ns 0.256496mA
+ 6.016ns 0.255415mA
+ 6.018ns 0.254338mA
+ 6.02ns 0.253267mA
+ 6.022ns 0.252199mA
+ 6.024ns 0.251137mA
+ 6.026ns 0.250078mA
+ 6.028ns 0.249025mA
+ 6.03ns 0.247975mA
+ 6.032ns 0.24693mA
+ 6.034ns 0.24589mA
+ 6.036ns 0.244854mA
+ 6.038ns 0.243822mA
+ 6.04ns 0.242794mA
+ 6.042ns 0.241771mA
+ 6.044ns 0.240752mA
+ 6.046ns 0.239738mA
+ 6.048ns 0.238728mA
+ 6.05ns 0.237722mA
+ 6.052ns 0.23672mA
+ 6.054ns 0.235722mA
+ 6.056ns 0.234729mA
+ 6.058ns 0.23374mA
+ 6.06ns 0.232755mA
+ 6.062ns 0.231774mA
+ 6.064ns 0.230797mA
+ 6.066ns 0mA
I99 167 0 PWL 0 0
+ 7.998ns 0mA
+ 8ns 0.0686868mA
+ 8.002ns 0.069614mA
+ 8.004ns 0.0705413mA
+ 8.006ns 0.0714686mA
+ 8.008ns 0.0723963mA
+ 8.01ns 0.0733236mA
+ 8.012ns 0.0742509mA
+ 8.014ns 0.0751781mA
+ 8.016ns 0.0761054mA
+ 8.018ns 0.0770327mA
+ 8.02ns 0.0779604mA
+ 8.022ns 0.0788877mA
+ 8.024ns 0.079815mA
+ 8.026ns 0.0807422mA
+ 8.028ns 0.0816695mA
+ 8.03ns 0.0825968mA
+ 8.032ns 0.0835241mA
+ 8.034ns 0.0844518mA
+ 8.036ns 0.0853791mA
+ 8.038ns 0.0863063mA
+ 8.04ns 0.0872336mA
+ 8.042ns 0.0881609mA
+ 8.044ns 0.0890882mA
+ 8.046ns 0.0900155mA
+ 8.048ns 0.0909432mA
+ 8.05ns 0.0918705mA
+ 8.052ns 0.0927977mA
+ 8.054ns 0.093725mA
+ 8.056ns 0.0946523mA
+ 8.058ns 0.0955796mA
+ 8.06ns 0.0965073mA
+ 8.062ns 0.0974346mA
+ 8.064ns 0.0983618mA
+ 8.066ns 0.0992891mA
+ 8.068ns 0.100216mA
+ 8.07ns 0.101144mA
+ 8.072ns 0.102071mA
+ 8.074ns 0.102999mA
+ 8.076ns 0.103926mA
+ 8.078ns 0.104853mA
+ 8.08ns 0.10578mA
+ 8.082ns 0.106708mA
+ 8.084ns 0.107635mA
+ 8.086ns 0.107678mA
+ 8.088ns 0.106406mA
+ 8.09ns 0.105149mA
+ 8.092ns 0.103907mA
+ 8.094ns 0.10268mA
+ 8.096ns 0.101467mA
+ 8.098ns 0.100269mA
+ 8.1ns 0.0990837mA
+ 8.102ns 0.0979133mA
+ 8.104ns 0.0967568mA
+ 8.106ns 0.095614mA
+ 8.108ns 0.0944846mA
+ 8.11ns 0.0933686mA
+ 8.112ns 0.0922652mA
+ 8.114ns 0.0911754mA
+ 8.116ns 0.0900985mA
+ 8.118ns 0.0890343mA
+ 8.12ns 0.0879826mA
+ 8.122ns 0.0869434mA
+ 8.124ns 0.0859164mA
+ 8.126ns 0.0849011mA
+ 8.128ns 0.0838982mA
+ 8.13ns 0.0829072mA
+ 8.132ns 0.0819279mA
+ 8.134ns 0.0809602mA
+ 8.136ns 0.0800039mA
+ 8.138ns 0.0790589mA
+ 8.14ns 0.0781246mA
+ 8.142ns 0.0772018mA
+ 8.144ns 0.0762898mA
+ 8.146ns 0.0753887mA
+ 8.148ns 0.0744982mA
+ 8.15ns 0.0736182mA
+ 8.152ns 0.0727482mA
+ 8.154ns 0.0718888mA
+ 8.156ns 0.0710396mA
+ 8.158ns 0.0702005mA
+ 8.16ns 0.0693712mA
+ 8.162ns 0.0685518mA
+ 8.164ns 0.067742mA
+ 8.166ns 0.0669414mA
+ 8.168ns 0.0661507mA
+ 8.17ns 0.0653693mA
+ 8.172ns 0.0645971mA
+ 8.174ns 0.063834mA
+ 8.176ns 0.06308mA
+ 8.178ns 0.0623345mA
+ 8.18ns 0.0615981mA
+ 8.182ns 0.0608705mA
+ 8.184ns 0.0601514mA
+ 8.186ns 0.0594408mA
+ 8.188ns 0.0587387mA
+ 8.19ns 0.0580448mA
+ 8.192ns 0.0573588mA
+ 8.194ns 0.0566812mA
+ 8.196ns 0.0560116mA
+ 8.198ns 0.0553499mA
+ 8.2ns 0.0546961mA
+ 8.202ns 0.0540499mA
+ 8.204ns 0.0534111mA
+ 8.206ns 0.0527802mA
+ 8.208ns 0.0521567mA
+ 8.21ns 0.0515405mA
+ 8.212ns 0.0509317mA
+ 8.214ns 0.05033mA
+ 8.216ns 0.0497354mA
+ 8.218ns 0.0491476mA
+ 8.22ns 0.048567mA
+ 8.222ns 0.0479932mA
+ 8.224ns 0.0474263mA
+ 8.226ns 0.046866mA
+ 8.228ns 0.0463123mA
+ 8.23ns 0.0457652mA
+ 8.232ns 0.0452243mA
+ 8.234ns 0.04469mA
+ 8.236ns 0.0441621mA
+ 8.238ns 0.0436403mA
+ 8.24ns 0.0431248mA
+ 8.242ns 0.0426153mA
+ 8.244ns 0.0421116mA
+ 8.246ns 0.0416141mA
+ 8.248ns 0.0411225mA
+ 8.25ns 0.0406367mA
+ 8.252ns 0.0401566mA
+ 8.254ns 0.0396822mA
+ 8.256ns 0.0392134mA
+ 8.258ns 0.0387499mA
+ 8.26ns 0.0382921mA
+ 8.262ns 0.0378397mA
+ 8.264ns 0.0373926mA
+ 8.266ns 0.0369509mA
+ 8.268ns 0.0365143mA
+ 8.27ns 0.0360827mA
+ 8.272ns 0.0356564mA
+ 8.274ns 0.0352352mA
+ 8.276ns 0.0348189mA
+ 8.278ns 0.0344075mA
+ 8.28ns 0.034001mA
+ 8.282ns 0.0335993mA
+ 8.284ns 0.0332021mA
+ 8.286ns 0.0328099mA
+ 8.288ns 0.0324222mA
+ 8.29ns 0.0320392mA
+ 8.292ns 0.0316606mA
+ 8.294ns 0.0312866mA
+ 8.296ns 0.0309168mA
+ 8.298ns 0.0305515mA
+ 8.3ns 0.0301905mA
+ 8.302ns 0.0298338mA
+ 8.304ns 0.0294813mA
+ 8.306ns 0.029133mA
+ 8.308ns 0.0287888mA
+ 8.31ns 0.0284485mA
+ 8.312ns 0.0281124mA
+ 8.314ns 0.0277802mA
+ 8.316ns 0.027452mA
+ 8.318ns 0.0271277mA
+ 8.32ns 0mA
I100 170 0 PWL 0 0
+ 7.758ns 0mA
+ 7.76ns 0.109625mA
+ 7.762ns 0.10536mA
+ 7.764ns 0.10126mA
+ 7.766ns 0.0973191mA
+ 7.768ns 0.0935323mA
+ 7.77ns 0.0898928mA
+ 7.772ns 0.0863941mA
+ 7.774ns 0.0830323mA
+ 7.776ns 0.0798013mA
+ 7.778ns 0.076696mA
+ 7.78ns 0.0737108mA
+ 7.782ns 0.0708424mA
+ 7.784ns 0.0680856mA
+ 7.786ns 0.0654355mA
+ 7.788ns 0.0628891mA
+ 7.79ns 0.0604417mA
+ 7.792ns 0.0580891mA
+ 7.794ns 0.0558285mA
+ 7.796ns 0mA
I101 171 0 PWL 0 0
+ 3.224ns 0mA
+ 3.226ns 0.00182329mA
+ 3.228ns 0.0119734mA
+ 3.23ns 0.0221224mA
+ 3.232ns 0.0322725mA
+ 3.234ns 0.0424214mA
+ 3.236ns 0.0525716mA
+ 3.238ns 0.0627217mA
+ 3.24ns 0.0728707mA
+ 3.242ns 0.0830208mA
+ 3.244ns 0.0931698mA
+ 3.246ns 0.0857142mA
+ 3.248ns 0.0739944mA
+ 3.25ns 0.0638778mA
+ 3.252ns 0.0551432mA
+ 3.254ns 0.0476034mA
+ 3.256ns 0.0410937mA
+ 3.258ns 0.035474mA
+ 3.26ns 0.0306231mA
+ 3.262ns 0.026435mA
+ 3.264ns 0mA
+ 8.224ns 0mA
+ 8.226ns 0.00182087mA
+ 8.228ns 0.0119698mA
+ 8.23ns 0.0221187mA
+ 8.232ns 0.0322725mA
+ 8.234ns 0.0424214mA
+ 8.236ns 0.0525704mA
+ 8.238ns 0.0627193mA
+ 8.24ns 0.0728683mA
+ 8.242ns 0.0830172mA
+ 8.244ns 0.093171mA
+ 8.246ns 0.0857142mA
+ 8.248ns 0.0739957mA
+ 8.25ns 0.063879mA
+ 8.252ns 0.0551451mA
+ 8.254ns 0.0476051mA
+ 8.256ns 0.0410959mA
+ 8.258ns 0.035474mA
+ 8.26ns 0.0306231mA
+ 8.262ns 0.0264355mA
+ 8.264ns 0mA
I102 173 0 PWL 0 0
+ 3.366ns 0mA
+ 3.368ns 0.00339276mA
+ 3.37ns 0.00840128mA
+ 3.372ns 0.0134092mA
+ 3.374ns 0.0184177mA
+ 3.376ns 0.0234262mA
+ 3.378ns 0.0284342mA
+ 3.38ns 0.0334427mA
+ 3.382ns 0.0384506mA
+ 3.384ns 0.0434591mA
+ 3.386ns 0.0484677mA
+ 3.388ns 0.0534756mA
+ 3.39ns 0.0584841mA
+ 3.392ns 0.063492mA
+ 3.394ns 0.0685006mA
+ 3.396ns 0.0735091mA
+ 3.398ns 0.078517mA
+ 3.4ns 0.0835255mA
+ 3.402ns 0.0885334mA
+ 3.404ns 0.093542mA
+ 3.406ns 0.0985505mA
+ 3.408ns 0.103558mA
+ 3.41ns 0.108567mA
+ 3.412ns 0.113575mA
+ 3.414ns 0.118583mA
+ 3.416ns 0.123592mA
+ 3.418ns 0.1286mA
+ 3.42ns 0.133608mA
+ 3.422ns 0.138617mA
+ 3.424ns 0.143625mA
+ 3.426ns 0.148633mA
+ 3.428ns 0.14779mA
+ 3.43ns 0.145517mA
+ 3.432ns 0.143278mA
+ 3.434ns 0.141074mA
+ 3.436ns 0.138904mA
+ 3.438ns 0.136767mA
+ 3.44ns 0.134663mA
+ 3.442ns 0.132592mA
+ 3.444ns 0.130552mA
+ 3.446ns 0.128544mA
+ 3.448ns 0.126566mA
+ 3.45ns 0.124619mA
+ 3.452ns 0.122702mA
+ 3.454ns 0.120815mA
+ 3.456ns 0.118956mA
+ 3.458ns 0.117126mA
+ 3.46ns 0.115324mA
+ 3.462ns 0.11355mA
+ 3.464ns 0.111803mA
+ 3.466ns 0.110083mA
+ 3.468ns 0.10839mA
+ 3.47ns 0.106722mA
+ 3.472ns 0.10508mA
+ 3.474ns 0.103464mA
+ 3.476ns 0.101872mA
+ 3.478ns 0.100305mA
+ 3.48ns 0.0987617mA
+ 3.482ns 0.0972423mA
+ 3.484ns 0.0957464mA
+ 3.486ns 0.0942733mA
+ 3.488ns 0.0928228mA
+ 3.49ns 0.0913949mA
+ 3.492ns 0.0899888mA
+ 3.494ns 0.0886044mA
+ 3.496ns 0.0872412mA
+ 3.498ns 0.0858989mA
+ 3.5ns 0.0845775mA
+ 3.502ns 0.0832762mA
+ 3.504ns 0.0819949mA
+ 3.506ns 0.0807335mA
+ 3.508ns 0.0794913mA
+ 3.51ns 0.0782684mA
+ 3.512ns 0.0770642mA
+ 3.514ns 0.0758785mA
+ 3.516ns 0.0747111mA
+ 3.518ns 0.0735616mA
+ 3.52ns 0.0724299mA
+ 3.522ns 0.0713155mA
+ 3.524ns 0.0702182mA
+ 3.526ns 0.0691379mA
+ 3.528ns 0.0680741mA
+ 3.53ns 0.0670268mA
+ 3.532ns 0.0659955mA
+ 3.534ns 0.0649801mA
+ 3.536ns 0.0639804mA
+ 3.538ns 0.0629959mA
+ 3.54ns 0.0620267mA
+ 3.542ns 0.0610723mA
+ 3.544ns 0.0601326mA
+ 3.546ns 0mA
+ 8.366ns 0mA
+ 8.368ns 0.00339216mA
+ 8.37ns 0.00840009mA
+ 8.372ns 0.013408mA
+ 8.374ns 0.0184159mA
+ 8.376ns 0.0234262mA
+ 8.378ns 0.0284342mA
+ 8.38ns 0.0334421mA
+ 8.382ns 0.03845mA
+ 8.384ns 0.0434579mA
+ 8.386ns 0.0484659mA
+ 8.388ns 0.0534762mA
+ 8.39ns 0.0584841mA
+ 8.392ns 0.063492mA
+ 8.394ns 0.0685mA
+ 8.396ns 0.0735079mA
+ 8.398ns 0.0785158mA
+ 8.4ns 0.0835237mA
+ 8.402ns 0.088534mA
+ 8.404ns 0.093542mA
+ 8.406ns 0.0985499mA
+ 8.408ns 0.103558mA
+ 8.41ns 0.108566mA
+ 8.412ns 0.113574mA
+ 8.414ns 0.118582mA
+ 8.416ns 0.123592mA
+ 8.418ns 0.1286mA
+ 8.42ns 0.133608mA
+ 8.422ns 0.138616mA
+ 8.424ns 0.143624mA
+ 8.426ns 0.148632mA
+ 8.428ns 0.14779mA
+ 8.43ns 0.145517mA
+ 8.432ns 0.143278mA
+ 8.434ns 0.141074mA
+ 8.436ns 0.138904mA
+ 8.438ns 0.136768mA
+ 8.44ns 0.134664mA
+ 8.442ns 0.132592mA
+ 8.444ns 0.130552mA
+ 8.446ns 0.128544mA
+ 8.448ns 0.126567mA
+ 8.45ns 0.12462mA
+ 8.452ns 0.122703mA
+ 8.454ns 0.120814mA
+ 8.456ns 0.118956mA
+ 8.458ns 0.117126mA
+ 8.46ns 0.115324mA
+ 8.462ns 0.11355mA
+ 8.464ns 0.111804mA
+ 8.466ns 0.110084mA
+ 8.468ns 0.10839mA
+ 8.47ns 0.106722mA
+ 8.472ns 0.10508mA
+ 8.474ns 0.103464mA
+ 8.476ns 0.101872mA
+ 8.478ns 0.100305mA
+ 8.48ns 0.0987615mA
+ 8.482ns 0.0972423mA
+ 8.484ns 0.0957464mA
+ 8.486ns 0.0942734mA
+ 8.488ns 0.0928232mA
+ 8.49ns 0.0913952mA
+ 8.492ns 0.0899893mA
+ 8.494ns 0.0886042mA
+ 8.496ns 0.0872412mA
+ 8.498ns 0.0858991mA
+ 8.5ns 0.0845776mA
+ 8.502ns 0.0832765mA
+ 8.504ns 0.0819954mA
+ 8.506ns 0.0807339mA
+ 8.508ns 0.0794913mA
+ 8.51ns 0.0782684mA
+ 8.512ns 0.0770643mA
+ 8.514ns 0.0758788mA
+ 8.516ns 0.0747114mA
+ 8.518ns 0.073562mA
+ 8.52ns 0.0724298mA
+ 8.522ns 0.0713155mA
+ 8.524ns 0.0702183mA
+ 8.526ns 0.0691381mA
+ 8.528ns 0.0680744mA
+ 8.53ns 0.0670271mA
+ 8.532ns 0.0659959mA
+ 8.534ns 0.0649801mA
+ 8.536ns 0.0639804mA
+ 8.538ns 0.062996mA
+ 8.54ns 0.0620268mA
+ 8.542ns 0.0610725mA
+ 8.544ns 0.0601329mA
+ 8.546ns 0mA
I103 174 0 PWL 0 0
+ 5.638ns 0mA
+ 5.64ns 0.0019429mA
+ 5.642ns 0.00410517mA
+ 5.644ns 0.00626692mA
+ 5.646ns 0.00842867mA
+ 5.648ns 0.0105909mA
+ 5.65ns 0.0127527mA
+ 5.652ns 0.0149144mA
+ 5.654ns 0.0170767mA
+ 5.656ns 0.0192385mA
+ 5.658ns 0.0214002mA
+ 5.66ns 0.023562mA
+ 5.662ns 0.0257242mA
+ 5.664ns 0.0255605mA
+ 5.666ns 0.0249989mA
+ 5.668ns 0.0244495mA
+ 5.67ns 0.0239123mA
+ 5.672ns 0.0233869mA
+ 5.674ns 0.022873mA
+ 5.676ns 0.0223704mA
+ 5.678ns 0.0218789mA
+ 5.68ns 0.021398mA
+ 5.682ns 0.0209279mA
+ 5.684ns 0.020468mA
+ 5.686ns 0.0200183mA
+ 5.688ns 0.0195783mA
+ 5.69ns 0.0191481mA
+ 5.692ns 0.0187274mA
+ 5.694ns 0.0183158mA
+ 5.696ns 0.0179133mA
+ 5.698ns 0.0175197mA
+ 5.7ns 0.0171347mA
+ 5.702ns 0.0167582mA
+ 5.704ns 0.0163899mA
+ 5.706ns 0.0160298mA
+ 5.708ns 0.0156774mA
+ 5.71ns 0.015333mA
+ 5.712ns 0.014996mA
+ 5.714ns 0.0146664mA
+ 5.716ns 0.0143441mA
+ 5.718ns 0.0140289mA
+ 5.72ns 0.0137206mA
+ 5.722ns 0.0134191mA
+ 5.724ns 0.0131242mA
+ 5.726ns 0.0128357mA
+ 5.728ns 0.0125536mA
+ 5.73ns 0.0122778mA
+ 5.732ns 0.012008mA
+ 5.734ns 0.011744mA
+ 5.736ns 0.0114859mA
+ 5.738ns 0mA
I104 177 0 PWL 0 0
+ 5.91ns 0mA
+ 5.912ns 0.0029933mA
+ 5.914ns 0.00770282mA
+ 5.916ns 0.0124123mA
+ 5.918ns 0.017123mA
+ 5.92ns 0.0218325mA
+ 5.922ns 0.026542mA
+ 5.924ns 0.0312527mA
+ 5.926ns 0.0359622mA
+ 5.928ns 0.0406717mA
+ 5.93ns 0.0453824mA
+ 5.932ns 0.0500919mA
+ 5.934ns 0.0444901mA
+ 5.936ns 0.039077mA
+ 5.938ns 0.0343212mA
+ 5.94ns 0.0301451mA
+ 5.942ns 0.026477mA
+ 5.944ns 0.0232544mA
+ 5.946ns 0.0204246mA
+ 5.948ns 0.017939mA
+ 5.95ns 0.0157554mA
+ 5.952ns 0.013838mA
+ 5.954ns 0mA
I105 179 0 PWL 0 0
+ 0.24ns 0mA
+ 0.242ns 0.00106746mA
+ 0.244ns 0.00450677mA
+ 0.246ns 0.00794604mA
+ 0.248ns 0.0113853mA
+ 0.25ns 0.0148246mA
+ 0.252ns 0.0182639mA
+ 0.254ns 0.0217032mA
+ 0.256ns 0.0251425mA
+ 0.258ns 0.0285818mA
+ 0.26ns 0.0320211mA
+ 0.262ns 0.0354604mA
+ 0.264ns 0.0388997mA
+ 0.266ns 0.042339mA
+ 0.268ns 0.0457783mA
+ 0.27ns 0.0492176mA
+ 0.272ns 0.0462332mA
+ 0.274ns 0.0420204mA
+ 0.276ns 0.0381915mA
+ 0.278ns 0.0347113mA
+ 0.28ns 0.0315483mA
+ 0.282ns 0.0286734mA
+ 0.284ns 0.0260604mA
+ 0.286ns 0.0236855mA
+ 0.288ns 0.0215269mA
+ 0.29ns 0.0195651mA
+ 0.292ns 0.017782mA
+ 0.294ns 0.0161614mA
+ 0.296ns 0.0146884mA
+ 0.298ns 0.0133496mA
+ 0.3ns 0mA
I106 180 0 PWL 0 0
+ 8.56ns 0mA
+ 8.562ns 0.000796545mA
+ 8.564ns 0.00440489mA
+ 8.566ns 0.00801324mA
+ 8.568ns 0.0116216mA
+ 8.57ns 0.0152299mA
+ 8.572ns 0.01884mA
+ 8.574ns 0.0224483mA
+ 8.576ns 0.0260567mA
+ 8.578ns 0.029665mA
+ 8.58ns 0.0332734mA
+ 8.582ns 0.0368817mA
+ 8.584ns 0.0404901mA
+ 8.586ns 0.042387mA
+ 8.588ns 0.0377703mA
+ 8.59ns 0.0336562mA
+ 8.592ns 0.0299902mA
+ 8.594ns 0.0267234mA
+ 8.596ns 0.0238124mA
+ 8.598ns 0.0212184mA
+ 8.6ns 0.0189059mA
+ 8.602ns 0.0168463mA
+ 8.604ns 0.015011mA
+ 8.606ns 0.0133756mA
+ 8.608ns 0.0119183mA
+ 8.61ns 0mA
I107 182 0 PWL 0 0
+ 0.226ns 0mA
+ 0.228ns 0.00277231mA
+ 0.23ns 0.00767388mA
+ 0.232ns 0.0125755mA
+ 0.234ns 0.0174771mA
+ 0.236ns 0.0223787mA
+ 0.238ns 0.0272803mA
+ 0.24ns 0.0321819mA
+ 0.242ns 0.0370835mA
+ 0.244ns 0.0419851mA
+ 0.246ns 0.0468867mA
+ 0.248ns 0.0517883mA
+ 0.25ns 0.0549446mA
+ 0.252ns 0.0486613mA
+ 0.254ns 0.0430964mA
+ 0.256ns 0.0381677mA
+ 0.258ns 0.0338026mA
+ 0.26ns 0.0299366mA
+ 0.262ns 0.0265127mA
+ 0.264ns 0.0234803mA
+ 0.266ns 0.0207946mA
+ 0.268ns 0.0184161mA
+ 0.27ns 0.0163096mA
+ 0.272ns 0.0144439mA
+ 0.274ns 0mA
+ 5.364ns 0mA
+ 5.366ns 0.00350873mA
+ 5.368ns 0.00840998mA
+ 5.37ns 0.0133112mA
+ 5.372ns 0.0182136mA
+ 5.374ns 0.0231149mA
+ 5.376ns 0.0280161mA
+ 5.378ns 0.0329185mA
+ 5.38ns 0.0378198mA
+ 5.382ns 0.042721mA
+ 5.384ns 0.0476235mA
+ 5.386ns 0.0525247mA
+ 5.388ns 0.0539517mA
+ 5.39ns 0.0477823mA
+ 5.392ns 0.0423171mA
+ 5.394ns 0.0374779mA
+ 5.396ns 0.0331919mA
+ 5.398ns 0.0293952mA
+ 5.4ns 0.0260334mA
+ 5.402ns 0.023056mA
+ 5.404ns 0.0204184mA
+ 5.406ns 0.0180831mA
+ 5.408ns 0.0160148mA
+ 5.41ns 0.014183mA
+ 5.412ns 0mA
+ 8.986ns 0mA
+ 8.988ns 0.00448804mA
+ 8.99ns 0.00938929mA
+ 8.992ns 0.0142905mA
+ 8.994ns 0.0191941mA
+ 8.996ns 0.0240954mA
+ 8.998ns 0.0289966mA
+ 9ns 0.0338979mA
+ 9.002ns 0.0387991mA
+ 9.004ns 0.0437004mA
+ 9.006ns 0.0486039mA
+ 9.008ns 0.0535052mA
+ 9.01ns 0.0526569mA
+ 9.012ns 0.0466356mA
+ 9.014ns 0.0413026mA
+ 9.016ns 0.0365794mA
+ 9.018ns 0.0323962mA
+ 9.02ns 0.0286896mA
+ 9.022ns 0.0254085mA
+ 9.024ns 0.0225025mA
+ 9.026ns 0.0199289mA
+ 9.028ns 0.0176495mA
+ 9.03ns 0.0156308mA
+ 9.032ns 0mA
I108 184 0 PWL 0 0
+ 5.256ns 0mA
+ 5.258ns 0.000970058mA
+ 5.26ns 0.00666544mA
+ 5.262ns 0.0123595mA
+ 5.264ns 0.0180535mA
+ 5.266ns 0.0237489mA
+ 5.268ns 0.0294429mA
+ 5.27ns 0.0351369mA
+ 5.272ns 0.0408309mA
+ 5.274ns 0.0465263mA
+ 5.276ns 0.0462278mA
+ 5.278ns 0.0394334mA
+ 5.28ns 0.0336361mA
+ 5.282ns 0.0286921mA
+ 5.284ns 0.0244746mA
+ 5.286ns 0.0208761mA
+ 5.288ns 0.0178072mA
+ 5.29ns 0.0151894mA
+ 5.292ns 0.0129559mA
+ 5.294ns 0mA
+ 8.878ns 0mA
+ 8.88ns 0.00210913mA
+ 8.882ns 0.00780316mA
+ 8.884ns 0.0134972mA
+ 8.886ns 0.0191912mA
+ 8.888ns 0.0248879mA
+ 8.89ns 0.030582mA
+ 8.892ns 0.036276mA
+ 8.894ns 0.04197mA
+ 8.896ns 0.047664mA
+ 8.898ns 0.0447825mA
+ 8.9ns 0.0382005mA
+ 8.902ns 0.0325832mA
+ 8.904ns 0.0277939mA
+ 8.906ns 0.0237084mA
+ 8.908ns 0.0202233mA
+ 8.91ns 0.0172504mA
+ 8.912ns 0.0147144mA
+ 8.914ns 0.0125502mA
+ 8.916ns 0mA
I109 185 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00501155mA
+ 2.656ns 0.0153009mA
+ 2.658ns 0.0255889mA
+ 2.66ns 0.0358782mA
+ 2.662ns 0.0461663mA
+ 2.664ns 0.0564556mA
+ 2.666ns 0.0667449mA
+ 2.668ns 0.077033mA
+ 2.67ns 0.0873223mA
+ 2.672ns 0.0976104mA
+ 2.674ns 0.1079mA
+ 2.676ns 0.118189mA
+ 2.678ns 0.128477mA
+ 2.68ns 0.131466mA
+ 2.682ns 0.118348mA
+ 2.684ns 0.106537mA
+ 2.686ns 0.0959049mA
+ 2.688ns 0.0863345mA
+ 2.69ns 0.0777179mA
+ 2.692ns 0.0699611mA
+ 2.694ns 0.0629791mA
+ 2.696ns 0.0566931mA
+ 2.698ns 0.0510349mA
+ 2.7ns 0.0459408mA
+ 2.702ns 0.041355mA
+ 2.704ns 0.0372274mA
+ 2.706ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00501278mA
+ 7.656ns 0.0153009mA
+ 7.658ns 0.0255889mA
+ 7.66ns 0.035877mA
+ 7.662ns 0.0461675mA
+ 7.664ns 0.0564556mA
+ 7.666ns 0.0667437mA
+ 7.668ns 0.0770342mA
+ 7.67ns 0.0873223mA
+ 7.672ns 0.0976104mA
+ 7.674ns 0.107901mA
+ 7.676ns 0.118189mA
+ 7.678ns 0.128477mA
+ 7.68ns 0.131465mA
+ 7.682ns 0.118347mA
+ 7.684ns 0.106537mA
+ 7.686ns 0.0959061mA
+ 7.688ns 0.0863334mA
+ 7.69ns 0.0777179mA
+ 7.692ns 0.069962mA
+ 7.694ns 0.0629784mA
+ 7.696ns 0.0566931mA
+ 7.698ns 0.0510349mA
+ 7.7ns 0.0459402mA
+ 7.702ns 0.041355mA
+ 7.704ns 0.0372274mA
+ 7.706ns 0mA
I110 186 0 PWL 0 0
+ 0.378ns 0mA
+ 0.38ns 0.00342191mA
+ 0.382ns 0.0072802mA
+ 0.384ns 0.0111384mA
+ 0.386ns 0.0149967mA
+ 0.388ns 0.018855mA
+ 0.39ns 0.0227133mA
+ 0.392ns 0.0265716mA
+ 0.394ns 0.0304299mA
+ 0.396ns 0.0342881mA
+ 0.398ns 0.0381464mA
+ 0.4ns 0.0420047mA
+ 0.402ns 0.0458629mA
+ 0.404ns 0.0497212mA
+ 0.406ns 0.0535795mA
+ 0.408ns 0.0574378mA
+ 0.41ns 0.0612961mA
+ 0.412ns 0.0651544mA
+ 0.414ns 0.0690126mA
+ 0.416ns 0.0728709mA
+ 0.418ns 0.0767292mA
+ 0.42ns 0.0805874mA
+ 0.422ns 0.0844457mA
+ 0.424ns 0.088304mA
+ 0.426ns 0.0921623mA
+ 0.428ns 0.0960206mA
+ 0.43ns 0.0998788mA
+ 0.432ns 0.103737mA
+ 0.434ns 0.107595mA
+ 0.436ns 0.111454mA
+ 0.438ns 0.115312mA
+ 0.44ns 0.11917mA
+ 0.442ns 0.123029mA
+ 0.444ns 0.126887mA
+ 0.446ns 0.130745mA
+ 0.448ns 0.134603mA
+ 0.45ns 0.138462mA
+ 0.452ns 0.14232mA
+ 0.454ns 0.146178mA
+ 0.456ns 0.150036mA
+ 0.458ns 0.153895mA
+ 0.46ns 0.157753mA
+ 0.462ns 0.161611mA
+ 0.464ns 0.16547mA
+ 0.466ns 0.169328mA
+ 0.468ns 0.173186mA
+ 0.47ns 0.177044mA
+ 0.472ns 0.180903mA
+ 0.474ns 0.184761mA
+ 0.476ns 0.188619mA
+ 0.478ns 0.192477mA
+ 0.48ns 0.196336mA
+ 0.482ns 0.200194mA
+ 0.484ns 0.204052mA
+ 0.486ns 0.207911mA
+ 0.488ns 0.211769mA
+ 0.49ns 0.215627mA
+ 0.492ns 0.219485mA
+ 0.494ns 0.223344mA
+ 0.496ns 0.227202mA
+ 0.498ns 0.23106mA
+ 0.5ns 0.234919mA
+ 0.502ns 0.238777mA
+ 0.504ns 0.242635mA
+ 0.506ns 0.246493mA
+ 0.508ns 0.250352mA
+ 0.51ns 0.25421mA
+ 0.512ns 0.258068mA
+ 0.514ns 0.261926mA
+ 0.516ns 0.265785mA
+ 0.518ns 0.269643mA
+ 0.52ns 0.273501mA
+ 0.522ns 0.27736mA
+ 0.524ns 0.281218mA
+ 0.526ns 0.285076mA
+ 0.528ns 0.288934mA
+ 0.53ns 0.292793mA
+ 0.532ns 0.296651mA
+ 0.534ns 0.300509mA
+ 0.536ns 0.304368mA
+ 0.538ns 0.308226mA
+ 0.54ns 0.312084mA
+ 0.542ns 0.315942mA
+ 0.544ns 0.319801mA
+ 0.546ns 0.323659mA
+ 0.548ns 0.327517mA
+ 0.55ns 0.331375mA
+ 0.552ns 0.335234mA
+ 0.554ns 0.339092mA
+ 0.556ns 0.34295mA
+ 0.558ns 0.346809mA
+ 0.56ns 0.350667mA
+ 0.562ns 0.354525mA
+ 0.564ns 0.358383mA
+ 0.566ns 0.362242mA
+ 0.568ns 0.3661mA
+ 0.57ns 0.369958mA
+ 0.572ns 0.373817mA
+ 0.574ns 0.377675mA
+ 0.576ns 0.381533mA
+ 0.578ns 0.385391mA
+ 0.58ns 0.38925mA
+ 0.582ns 0.393108mA
+ 0.584ns 0.396966mA
+ 0.586ns 0.400824mA
+ 0.588ns 0.404683mA
+ 0.59ns 0.408541mA
+ 0.592ns 0.412399mA
+ 0.594ns 0.416258mA
+ 0.596ns 0.420116mA
+ 0.598ns 0.423974mA
+ 0.6ns 0.427832mA
+ 0.602ns 0.431691mA
+ 0.604ns 0.43233mA
+ 0.606ns 0.430829mA
+ 0.608ns 0.429332mA
+ 0.61ns 0.427841mA
+ 0.612ns 0.426355mA
+ 0.614ns 0.424874mA
+ 0.616ns 0.423398mA
+ 0.618ns 0.421927mA
+ 0.62ns 0.420462mA
+ 0.622ns 0.419001mA
+ 0.624ns 0.417546mA
+ 0.626ns 0.416096mA
+ 0.628ns 0.41465mA
+ 0.63ns 0.41321mA
+ 0.632ns 0.411775mA
+ 0.634ns 0.410344mA
+ 0.636ns 0.408919mA
+ 0.638ns 0.407499mA
+ 0.64ns 0.406083mA
+ 0.642ns 0.404673mA
+ 0.644ns 0.403267mA
+ 0.646ns 0.401866mA
+ 0.648ns 0.40047mA
+ 0.65ns 0.399079mA
+ 0.652ns 0.397693mA
+ 0.654ns 0.396311mA
+ 0.656ns 0.394935mA
+ 0.658ns 0.393563mA
+ 0.66ns 0.392196mA
+ 0.662ns 0.390834mA
+ 0.664ns 0.389476mA
+ 0.666ns 0.388123mA
+ 0.668ns 0.386775mA
+ 0.67ns 0.385431mA
+ 0.672ns 0.384093mA
+ 0.674ns 0.382758mA
+ 0.676ns 0.381429mA
+ 0.678ns 0.380104mA
+ 0.68ns 0.378784mA
+ 0.682ns 0.377468mA
+ 0.684ns 0.376157mA
+ 0.686ns 0.37485mA
+ 0.688ns 0.373548mA
+ 0.69ns 0.37225mA
+ 0.692ns 0.370957mA
+ 0.694ns 0.369669mA
+ 0.696ns 0.368385mA
+ 0.698ns 0.367105mA
+ 0.7ns 0.36583mA
+ 0.702ns 0.364559mA
+ 0.704ns 0.363293mA
+ 0.706ns 0.362031mA
+ 0.708ns 0.360773mA
+ 0.71ns 0.35952mA
+ 0.712ns 0.358271mA
+ 0.714ns 0.357027mA
+ 0.716ns 0.355786mA
+ 0.718ns 0.35455mA
+ 0.72ns 0.353319mA
+ 0.722ns 0.352092mA
+ 0.724ns 0.350869mA
+ 0.726ns 0.34965mA
+ 0.728ns 0.348435mA
+ 0.73ns 0.347225mA
+ 0.732ns 0.346019mA
+ 0.734ns 0.344817mA
+ 0.736ns 0.343619mA
+ 0.738ns 0.342425mA
+ 0.74ns 0.341236mA
+ 0.742ns 0.34005mA
+ 0.744ns 0.338869mA
+ 0.746ns 0.337692mA
+ 0.748ns 0.336519mA
+ 0.75ns 0.33535mA
+ 0.752ns 0.334185mA
+ 0.754ns 0.333024mA
+ 0.756ns 0.331867mA
+ 0.758ns 0.330715mA
+ 0.76ns 0.329566mA
+ 0.762ns 0.328421mA
+ 0.764ns 0.32728mA
+ 0.766ns 0.326143mA
+ 0.768ns 0.32501mA
+ 0.77ns 0.323881mA
+ 0.772ns 0.322756mA
+ 0.774ns 0.321635mA
+ 0.776ns 0.320518mA
+ 0.778ns 0.319404mA
+ 0.78ns 0.318295mA
+ 0.782ns 0.317189mA
+ 0.784ns 0.316087mA
+ 0.786ns 0.314989mA
+ 0.788ns 0.313895mA
+ 0.79ns 0.312805mA
+ 0.792ns 0.311718mA
+ 0.794ns 0.310635mA
+ 0.796ns 0.309556mA
+ 0.798ns 0.308481mA
+ 0.8ns 0.307409mA
+ 0.802ns 0.306341mA
+ 0.804ns 0.305277mA
+ 0.806ns 0.304217mA
+ 0.808ns 0.30316mA
+ 0.81ns 0.302107mA
+ 0.812ns 0.301057mA
+ 0.814ns 0.300011mA
+ 0.816ns 0.298969mA
+ 0.818ns 0.297931mA
+ 0.82ns 0.296896mA
+ 0.822ns 0.295864mA
+ 0.824ns 0.294837mA
+ 0.826ns 0.293812mA
+ 0.828ns 0.292792mA
+ 0.83ns 0.291775mA
+ 0.832ns 0.290761mA
+ 0.834ns 0.289751mA
+ 0.836ns 0.288744mA
+ 0.838ns 0.287741mA
+ 0.84ns 0.286742mA
+ 0.842ns 0.285746mA
+ 0.844ns 0.284753mA
+ 0.846ns 0.283764mA
+ 0.848ns 0.282778mA
+ 0.85ns 0.281796mA
+ 0.852ns 0.280817mA
+ 0.854ns 0.279841mA
+ 0.856ns 0.278869mA
+ 0.858ns 0.2779mA
+ 0.86ns 0.276935mA
+ 0.862ns 0.275973mA
+ 0.864ns 0.275014mA
+ 0.866ns 0.274059mA
+ 0.868ns 0.273107mA
+ 0.87ns 0.272158mA
+ 0.872ns 0.271213mA
+ 0.874ns 0.270271mA
+ 0.876ns 0.269332mA
+ 0.878ns 0.268396mA
+ 0.88ns 0.267464mA
+ 0.882ns 0.266534mA
+ 0.884ns 0.265609mA
+ 0.886ns 0.264686mA
+ 0.888ns 0.263766mA
+ 0.89ns 0.26285mA
+ 0.892ns 0.261937mA
+ 0.894ns 0.261027mA
+ 0.896ns 0.26012mA
+ 0.898ns 0.259217mA
+ 0.9ns 0.258316mA
+ 0.902ns 0.257419mA
+ 0.904ns 0.256524mA
+ 0.906ns 0.255633mA
+ 0.908ns 0.254745mA
+ 0.91ns 0.25386mA
+ 0.912ns 0.252978mA
+ 0.914ns 0.252099mA
+ 0.916ns 0.251224mA
+ 0.918ns 0.250351mA
+ 0.92ns 0.249481mA
+ 0.922ns 0.248615mA
+ 0.924ns 0.247751mA
+ 0.926ns 0.24689mA
+ 0.928ns 0.246033mA
+ 0.93ns 0.245178mA
+ 0.932ns 0.244326mA
+ 0.934ns 0.243477mA
+ 0.936ns 0.242631mA
+ 0.938ns 0.241789mA
+ 0.94ns 0.240949mA
+ 0.942ns 0.240111mA
+ 0.944ns 0.239277mA
+ 0.946ns 0.238446mA
+ 0.948ns 0.237618mA
+ 0.95ns 0.236792mA
+ 0.952ns 0.23597mA
+ 0.954ns 0.23515mA
+ 0.956ns 0.234333mA
+ 0.958ns 0.233519mA
+ 0.96ns 0.232708mA
+ 0.962ns 0.231899mA
+ 0.964ns 0.231094mA
+ 0.966ns 0.230291mA
+ 0.968ns 0.229491mA
+ 0.97ns 0.228693mA
+ 0.972ns 0.227899mA
+ 0.974ns 0.227107mA
+ 0.976ns 0.226318mA
+ 0.978ns 0.225532mA
+ 0.98ns 0.224748mA
+ 0.982ns 0.223968mA
+ 0.984ns 0.22319mA
+ 0.986ns 0.222414mA
+ 0.988ns 0.221642mA
+ 0.99ns 0.220872mA
+ 0.992ns 0.220104mA
+ 0.994ns 0.21934mA
+ 0.996ns 0.218578mA
+ 0.998ns 0.217818mA
+ 1ns 0.217061mA
+ 1.002ns 0.216307mA
+ 1.004ns 0.215556mA
+ 1.006ns 0.214807mA
+ 1.008ns 0.214061mA
+ 1.01ns 0.213317mA
+ 1.012ns 0.212576mA
+ 1.014ns 0.211838mA
+ 1.016ns 0.211102mA
+ 1.018ns 0.210368mA
+ 1.02ns 0.209637mA
+ 1.022ns 0.208909mA
+ 1.024ns 0.208183mA
+ 1.026ns 0.20746mA
+ 1.028ns 0.206739mA
+ 1.03ns 0.206021mA
+ 1.032ns 0.205305mA
+ 1.034ns 0.204592mA
+ 1.036ns 0.203881mA
+ 1.038ns 0.203173mA
+ 1.04ns 0.202467mA
+ 1.042ns 0.201764mA
+ 1.044ns 0.201063mA
+ 1.046ns 0.200364mA
+ 1.048ns 0.199668mA
+ 1.05ns 0.198974mA
+ 1.052ns 0.198283mA
+ 1.054ns 0.197594mA
+ 1.056ns 0.196908mA
+ 1.058ns 0.196224mA
+ 1.06ns 0.195542mA
+ 1.062ns 0.194863mA
+ 1.064ns 0.194186mA
+ 1.066ns 0.193511mA
+ 1.068ns 0.192839mA
+ 1.07ns 0.192169mA
+ 1.072ns 0.191501mA
+ 1.074ns 0.190836mA
+ 1.076ns 0.190173mA
+ 1.078ns 0.189512mA
+ 1.08ns 0.188854mA
+ 1.082ns 0.188198mA
+ 1.084ns 0.187544mA
+ 1.086ns 0.186892mA
+ 1.088ns 0.186243mA
+ 1.09ns 0.185596mA
+ 1.092ns 0.184951mA
+ 1.094ns 0.184308mA
+ 1.096ns 0.183668mA
+ 1.098ns 0.18303mA
+ 1.1ns 0.182394mA
+ 1.102ns 0.18176mA
+ 1.104ns 0.181129mA
+ 1.106ns 0.1805mA
+ 1.108ns 0.179873mA
+ 1.11ns 0.179248mA
+ 1.112ns 0.178625mA
+ 1.114ns 0mA
I111 187 0 PWL 0 0
+ 7.74ns 0mA
+ 7.742ns 0.00191763mA
+ 7.744ns 0.00553082mA
+ 7.746ns 0.00914487mA
+ 7.748ns 0.0127581mA
+ 7.75ns 0.0163712mA
+ 7.752ns 0.0199844mA
+ 7.754ns 0.0235985mA
+ 7.756ns 0.0272117mA
+ 7.758ns 0.0308249mA
+ 7.76ns 0.0344389mA
+ 7.762ns 0.0380521mA
+ 7.764ns 0.0416653mA
+ 7.766ns 0.03775mA
+ 7.768ns 0.0335084mA
+ 7.77ns 0.0297432mA
+ 7.772ns 0.0264003mA
+ 7.774ns 0.0234337mA
+ 7.776ns 0.0208003mA
+ 7.778ns 0.0184628mA
+ 7.78ns 0.0163875mA
+ 7.782ns 0.0145458mA
+ 7.784ns 0.0129111mA
+ 7.786ns 0.0114597mA
+ 7.788ns 0mA
I112 188 0 PWL 0 0
+ 5.328ns 0mA
+ 5.33ns 0.00102816mA
+ 5.332ns 0.00279074mA
+ 5.334ns 0.0045529mA
+ 5.336ns 0.00631506mA
+ 5.338ns 0.00807763mA
+ 5.34ns 0.00983979mA
+ 5.342ns 0.0116019mA
+ 5.344ns 0.0133641mA
+ 5.346ns 0.0151267mA
+ 5.348ns 0.0168888mA
+ 5.35ns 0.018651mA
+ 5.352ns 0.0204136mA
+ 5.354ns 0.0221757mA
+ 5.356ns 0.0239379mA
+ 5.358ns 0.0257005mA
+ 5.36ns 0.0274626mA
+ 5.362ns 0.0292248mA
+ 5.364ns 0.0309869mA
+ 5.366ns 0.0327495mA
+ 5.368ns 0.0345117mA
+ 5.37ns 0.0362738mA
+ 5.372ns 0.0380364mA
+ 5.374ns 0.0397986mA
+ 5.376ns 0.0415607mA
+ 5.378ns 0.0433233mA
+ 5.38ns 0.0421737mA
+ 5.382ns 0.0398885mA
+ 5.384ns 0.0377266mA
+ 5.386ns 0.0356823mA
+ 5.388ns 0.0337488mA
+ 5.39ns 0.03192mA
+ 5.392ns 0.0301899mA
+ 5.394ns 0.0285539mA
+ 5.396ns 0.0270065mA
+ 5.398ns 0.0255427mA
+ 5.4ns 0.0241585mA
+ 5.402ns 0.0228493mA
+ 5.404ns 0.0216107mA
+ 5.406ns 0.0204395mA
+ 5.408ns 0.0193318mA
+ 5.41ns 0.0182841mA
+ 5.412ns 0.017293mA
+ 5.414ns 0.0163557mA
+ 5.416ns 0.0154693mA
+ 5.418ns 0.0146307mA
+ 5.42ns 0.0138377mA
+ 5.422ns 0.0130877mA
+ 5.424ns 0.0123782mA
+ 5.426ns 0.0117073mA
+ 5.428ns 0.0110727mA
+ 5.43ns 0mA
I113 190 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00298509mA
+ 0.156ns 0.0140514mA
+ 0.158ns 0.0251179mA
+ 0.16ns 0.0361843mA
+ 0.162ns 0.0472507mA
+ 0.164ns 0.0583171mA
+ 0.166ns 0.0693836mA
+ 0.168ns 0.08045mA
+ 0.17ns 0.0915164mA
+ 0.172ns 0.102583mA
+ 0.174ns 0.113649mA
+ 0.176ns 0.124716mA
+ 0.178ns 0.130535mA
+ 0.18ns 0.116371mA
+ 0.182ns 0.103744mA
+ 0.184ns 0.0924859mA
+ 0.186ns 0.0824497mA
+ 0.188ns 0.0735022mA
+ 0.19ns 0.0655255mA
+ 0.192ns 0.0584144mA
+ 0.194ns 0.0520747mA
+ 0.196ns 0.046423mA
+ 0.198ns 0.0413845mA
+ 0.2ns 0.0368927mA
+ 0.202ns 0mA
I114 191 0 PWL 0 0
+ 0.238ns 0mA
+ 0.24ns 0.000543366mA
+ 0.242ns 0.00514293mA
+ 0.244ns 0.00974249mA
+ 0.246ns 0.014342mA
+ 0.248ns 0.0189416mA
+ 0.25ns 0.0235411mA
+ 0.252ns 0.0281407mA
+ 0.254ns 0.0327402mA
+ 0.256ns 0.0373398mA
+ 0.258ns 0.0419394mA
+ 0.26ns 0.0465389mA
+ 0.262ns 0.0511385mA
+ 0.264ns 0.0540997mA
+ 0.266ns 0.0481825mA
+ 0.268ns 0.0429122mA
+ 0.27ns 0.0382183mA
+ 0.272ns 0.0340378mA
+ 0.274ns 0.0303144mA
+ 0.276ns 0.0269983mA
+ 0.278ns 0.0240448mA
+ 0.28ns 0.0214144mA
+ 0.282ns 0.0190716mA
+ 0.284ns 0.0169851mA
+ 0.286ns 0.0151268mA
+ 0.288ns 0mA
I115 192 0 PWL 0 0
+ 2.876ns 0mA
+ 2.878ns 0.00309663mA
+ 2.88ns 0.00687988mA
+ 2.882ns 0.0106627mA
+ 2.884ns 0.0144459mA
+ 2.886ns 0.0182292mA
+ 2.888ns 0.022012mA
+ 2.89ns 0.0257952mA
+ 2.892ns 0.029578mA
+ 2.894ns 0.0333612mA
+ 2.896ns 0.0371445mA
+ 2.898ns 0.0409273mA
+ 2.9ns 0.0447105mA
+ 2.902ns 0.0484933mA
+ 2.904ns 0.0522766mA
+ 2.906ns 0.0560598mA
+ 2.908ns 0.0598426mA
+ 2.91ns 0.0636258mA
+ 2.912ns 0.0674086mA
+ 2.914ns 0.0711919mA
+ 2.916ns 0.0749751mA
+ 2.918ns 0.0787579mA
+ 2.92ns 0.0825412mA
+ 2.922ns 0.086324mA
+ 2.924ns 0.0901072mA
+ 2.926ns 0.0938904mA
+ 2.928ns 0.0976732mA
+ 2.93ns 0.101456mA
+ 2.932ns 0.10524mA
+ 2.934ns 0.109023mA
+ 2.936ns 0.112806mA
+ 2.938ns 0.116589mA
+ 2.94ns 0.120372mA
+ 2.942ns 0.124155mA
+ 2.944ns 0.127938mA
+ 2.946ns 0.131721mA
+ 2.948ns 0.135504mA
+ 2.95ns 0.139287mA
+ 2.952ns 0.14307mA
+ 2.954ns 0.146853mA
+ 2.956ns 0.150636mA
+ 2.958ns 0.154419mA
+ 2.96ns 0.158202mA
+ 2.962ns 0.161986mA
+ 2.964ns 0.165768mA
+ 2.966ns 0.169552mA
+ 2.968ns 0.173335mA
+ 2.97ns 0.177118mA
+ 2.972ns 0.180901mA
+ 2.974ns 0.184684mA
+ 2.976ns 0.188467mA
+ 2.978ns 0.19225mA
+ 2.98ns 0.196033mA
+ 2.982ns 0.199816mA
+ 2.984ns 0.203599mA
+ 2.986ns 0.207382mA
+ 2.988ns 0.211166mA
+ 2.99ns 0.214948mA
+ 2.992ns 0.218732mA
+ 2.994ns 0.222514mA
+ 2.996ns 0.226298mA
+ 2.998ns 0.230081mA
+ 3ns 0.233864mA
+ 3.002ns 0.237647mA
+ 3.004ns 0.24143mA
+ 3.006ns 0.245213mA
+ 3.008ns 0.248996mA
+ 3.01ns 0.252779mA
+ 3.012ns 0.256562mA
+ 3.014ns 0.260345mA
+ 3.016ns 0.264128mA
+ 3.018ns 0.267912mA
+ 3.02ns 0.271694mA
+ 3.022ns 0.275478mA
+ 3.024ns 0.279261mA
+ 3.026ns 0.283044mA
+ 3.028ns 0.286827mA
+ 3.03ns 0.29061mA
+ 3.032ns 0.294393mA
+ 3.034ns 0.298176mA
+ 3.036ns 0.301959mA
+ 3.038ns 0.305742mA
+ 3.04ns 0.309525mA
+ 3.042ns 0.313308mA
+ 3.044ns 0.317091mA
+ 3.046ns 0.320874mA
+ 3.048ns 0.324658mA
+ 3.05ns 0.32844mA
+ 3.052ns 0.332224mA
+ 3.054ns 0.336007mA
+ 3.056ns 0.33979mA
+ 3.058ns 0.343573mA
+ 3.06ns 0.347356mA
+ 3.062ns 0.351139mA
+ 3.064ns 0.354922mA
+ 3.066ns 0.358705mA
+ 3.068ns 0.362488mA
+ 3.07ns 0.366271mA
+ 3.072ns 0.370054mA
+ 3.074ns 0.373837mA
+ 3.076ns 0.37762mA
+ 3.078ns 0.381404mA
+ 3.08ns 0.385187mA
+ 3.082ns 0.38897mA
+ 3.084ns 0.392753mA
+ 3.086ns 0.396536mA
+ 3.088ns 0.400319mA
+ 3.09ns 0.404102mA
+ 3.092ns 0.407885mA
+ 3.094ns 0.411668mA
+ 3.096ns 0.415451mA
+ 3.098ns 0.419234mA
+ 3.1ns 0.423017mA
+ 3.102ns 0.4268mA
+ 3.104ns 0.430583mA
+ 3.106ns 0.434366mA
+ 3.108ns 0.432864mA
+ 3.11ns 0.431368mA
+ 3.112ns 0.429876mA
+ 3.114ns 0.42839mA
+ 3.116ns 0.426909mA
+ 3.118ns 0.425433mA
+ 3.12ns 0.423962mA
+ 3.122ns 0.422496mA
+ 3.124ns 0.421035mA
+ 3.126ns 0.419579mA
+ 3.128ns 0.418129mA
+ 3.13ns 0.416683mA
+ 3.132ns 0.415242mA
+ 3.134ns 0.413806mA
+ 3.136ns 0.412376mA
+ 3.138ns 0.41095mA
+ 3.14ns 0.409529mA
+ 3.142ns 0.408113mA
+ 3.144ns 0.406702mA
+ 3.146ns 0.405296mA
+ 3.148ns 0.403894mA
+ 3.15ns 0.402498mA
+ 3.152ns 0.401106mA
+ 3.154ns 0.399719mA
+ 3.156ns 0.398337mA
+ 3.158ns 0.39696mA
+ 3.16ns 0.395587mA
+ 3.162ns 0.39422mA
+ 3.164ns 0.392857mA
+ 3.166ns 0.391498mA
+ 3.168ns 0.390145mA
+ 3.17ns 0.388796mA
+ 3.172ns 0.387451mA
+ 3.174ns 0.386112mA
+ 3.176ns 0.384777mA
+ 3.178ns 0.383446mA
+ 3.18ns 0.38212mA
+ 3.182ns 0.380799mA
+ 3.184ns 0.379483mA
+ 3.186ns 0.37817mA
+ 3.188ns 0.376863mA
+ 3.19ns 0.37556mA
+ 3.192ns 0.374261mA
+ 3.194ns 0.372967mA
+ 3.196ns 0.371678mA
+ 3.198ns 0.370393mA
+ 3.2ns 0.369112mA
+ 3.202ns 0.367835mA
+ 3.204ns 0.366564mA
+ 3.206ns 0.365296mA
+ 3.208ns 0.364033mA
+ 3.21ns 0.362774mA
+ 3.212ns 0.36152mA
+ 3.214ns 0.36027mA
+ 3.216ns 0.359024mA
+ 3.218ns 0.357783mA
+ 3.22ns 0.356546mA
+ 3.222ns 0.355313mA
+ 3.224ns 0.354084mA
+ 3.226ns 0.35286mA
+ 3.228ns 0.35164mA
+ 3.23ns 0.350424mA
+ 3.232ns 0.349212mA
+ 3.234ns 0.348005mA
+ 3.236ns 0.346802mA
+ 3.238ns 0.345603mA
+ 3.24ns 0.344408mA
+ 3.242ns 0.343217mA
+ 3.244ns 0.34203mA
+ 3.246ns 0.340847mA
+ 3.248ns 0.339669mA
+ 3.25ns 0.338494mA
+ 3.252ns 0.337324mA
+ 3.254ns 0.336158mA
+ 3.256ns 0.334995mA
+ 3.258ns 0.333837mA
+ 3.26ns 0.332683mA
+ 3.262ns 0.331532mA
+ 3.264ns 0.330386mA
+ 3.266ns 0.329243mA
+ 3.268ns 0.328105mA
+ 3.27ns 0.326971mA
+ 3.272ns 0.32584mA
+ 3.274ns 0.324713mA
+ 3.276ns 0.32359mA
+ 3.278ns 0.322471mA
+ 3.28ns 0.321357mA
+ 3.282ns 0.320245mA
+ 3.284ns 0.319138mA
+ 3.286ns 0.318034mA
+ 3.288ns 0.316935mA
+ 3.29ns 0.315839mA
+ 3.292ns 0.314747mA
+ 3.294ns 0.313658mA
+ 3.296ns 0.312574mA
+ 3.298ns 0.311493mA
+ 3.3ns 0.310416mA
+ 3.302ns 0.309343mA
+ 3.304ns 0.308273mA
+ 3.306ns 0.307207mA
+ 3.308ns 0.306145mA
+ 3.31ns 0.305086mA
+ 3.312ns 0.304031mA
+ 3.314ns 0.30298mA
+ 3.316ns 0.301932mA
+ 3.318ns 0.300888mA
+ 3.32ns 0.299848mA
+ 3.322ns 0.298811mA
+ 3.324ns 0.297778mA
+ 3.326ns 0.296748mA
+ 3.328ns 0.295722mA
+ 3.33ns 0.294699mA
+ 3.332ns 0.29368mA
+ 3.334ns 0.292665mA
+ 3.336ns 0.291653mA
+ 3.338ns 0.290644mA
+ 3.34ns 0.289639mA
+ 3.342ns 0.288638mA
+ 3.344ns 0.28764mA
+ 3.346ns 0.286645mA
+ 3.348ns 0.285654mA
+ 3.35ns 0.284666mA
+ 3.352ns 0.283682mA
+ 3.354ns 0.282701mA
+ 3.356ns 0.281723mA
+ 3.358ns 0.280749mA
+ 3.36ns 0.279778mA
+ 3.362ns 0.278811mA
+ 3.364ns 0.277847mA
+ 3.366ns 0.276886mA
+ 3.368ns 0.275929mA
+ 3.37ns 0.274974mA
+ 3.372ns 0.274024mA
+ 3.374ns 0.273076mA
+ 3.376ns 0.272132mA
+ 3.378ns 0.271191mA
+ 3.38ns 0.270253mA
+ 3.382ns 0.269319mA
+ 3.384ns 0.268387mA
+ 3.386ns 0.267459mA
+ 3.388ns 0.266534mA
+ 3.39ns 0.265613mA
+ 3.392ns 0.264694mA
+ 3.394ns 0.263779mA
+ 3.396ns 0.262867mA
+ 3.398ns 0.261958mA
+ 3.4ns 0.261052mA
+ 3.402ns 0.260149mA
+ 3.404ns 0.25925mA
+ 3.406ns 0.258353mA
+ 3.408ns 0.25746mA
+ 3.41ns 0.25657mA
+ 3.412ns 0.255682mA
+ 3.414ns 0.254798mA
+ 3.416ns 0.253917mA
+ 3.418ns 0.253039mA
+ 3.42ns 0.252164mA
+ 3.422ns 0.251292mA
+ 3.424ns 0.250423mA
+ 3.426ns 0.249557mA
+ 3.428ns 0.248694mA
+ 3.43ns 0.247834mA
+ 3.432ns 0.246977mA
+ 3.434ns 0.246123mA
+ 3.436ns 0.245272mA
+ 3.438ns 0.244424mA
+ 3.44ns 0.243579mA
+ 3.442ns 0.242736mA
+ 3.444ns 0.241897mA
+ 3.446ns 0.241061mA
+ 3.448ns 0.240227mA
+ 3.45ns 0.239396mA
+ 3.452ns 0.238568mA
+ 3.454ns 0.237743mA
+ 3.456ns 0.236921mA
+ 3.458ns 0.236102mA
+ 3.46ns 0.235286mA
+ 3.462ns 0.234472mA
+ 3.464ns 0.233661mA
+ 3.466ns 0.232853mA
+ 3.468ns 0.232048mA
+ 3.47ns 0.231245mA
+ 3.472ns 0.230446mA
+ 3.474ns 0.229649mA
+ 3.476ns 0.228855mA
+ 3.478ns 0.228063mA
+ 3.48ns 0.227275mA
+ 3.482ns 0.226489mA
+ 3.484ns 0.225706mA
+ 3.486ns 0.224925mA
+ 3.488ns 0.224147mA
+ 3.49ns 0.223372mA
+ 3.492ns 0.2226mA
+ 3.494ns 0.22183mA
+ 3.496ns 0.221063mA
+ 3.498ns 0.220298mA
+ 3.5ns 0.219537mA
+ 3.502ns 0.218777mA
+ 3.504ns 0.218021mA
+ 3.506ns 0.217267mA
+ 3.508ns 0.216516mA
+ 3.51ns 0.215767mA
+ 3.512ns 0.215021mA
+ 3.514ns 0.214277mA
+ 3.516ns 0.213536mA
+ 3.518ns 0.212798mA
+ 3.52ns 0.212062mA
+ 3.522ns 0.211328mA
+ 3.524ns 0.210598mA
+ 3.526ns 0.209869mA
+ 3.528ns 0.209144mA
+ 3.53ns 0.20842mA
+ 3.532ns 0.2077mA
+ 3.534ns 0.206981mA
+ 3.536ns 0.206266mA
+ 3.538ns 0.205552mA
+ 3.54ns 0.204842mA
+ 3.542ns 0.204133mA
+ 3.544ns 0.203427mA
+ 3.546ns 0.202724mA
+ 3.548ns 0.202023mA
+ 3.55ns 0.201324mA
+ 3.552ns 0.200628mA
+ 3.554ns 0.199934mA
+ 3.556ns 0.199243mA
+ 3.558ns 0.198554mA
+ 3.56ns 0.197867mA
+ 3.562ns 0.197183mA
+ 3.564ns 0.196501mA
+ 3.566ns 0.195821mA
+ 3.568ns 0.195144mA
+ 3.57ns 0.194469mA
+ 3.572ns 0.193797mA
+ 3.574ns 0.193126mA
+ 3.576ns 0.192459mA
+ 3.578ns 0.191793mA
+ 3.58ns 0.19113mA
+ 3.582ns 0.190469mA
+ 3.584ns 0.18981mA
+ 3.586ns 0.189154mA
+ 3.588ns 0.1885mA
+ 3.59ns 0.187848mA
+ 3.592ns 0.187198mA
+ 3.594ns 0.186551mA
+ 3.596ns 0.185906mA
+ 3.598ns 0.185263mA
+ 3.6ns 0.184622mA
+ 3.602ns 0.183984mA
+ 3.604ns 0.183347mA
+ 3.606ns 0.182713mA
+ 3.608ns 0.182081mA
+ 3.61ns 0.181452mA
+ 3.612ns 0.180824mA
+ 3.614ns 0.180199mA
+ 3.616ns 0.179576mA
+ 3.618ns 0.178955mA
+ 3.62ns 0.178336mA
+ 3.622ns 0mA
I116 193 0 PWL 0 0
+ 0.522ns 0mA
+ 0.524ns 0.00639738mA
+ 0.526ns 0.0141389mA
+ 0.528ns 0.0218805mA
+ 0.53ns 0.0296222mA
+ 0.532ns 0.0373638mA
+ 0.534ns 0.0451056mA
+ 0.536ns 0.0528471mA
+ 0.538ns 0.0605889mA
+ 0.54ns 0.0683304mA
+ 0.542ns 0.0760722mA
+ 0.544ns 0.0838138mA
+ 0.546ns 0.0915553mA
+ 0.548ns 0.0992971mA
+ 0.55ns 0.107039mA
+ 0.552ns 0.11478mA
+ 0.554ns 0.122522mA
+ 0.556ns 0.130264mA
+ 0.558ns 0.138005mA
+ 0.56ns 0.145747mA
+ 0.562ns 0.153489mA
+ 0.564ns 0.16123mA
+ 0.566ns 0.168972mA
+ 0.568ns 0.176713mA
+ 0.57ns 0.184455mA
+ 0.572ns 0.192197mA
+ 0.574ns 0.199938mA
+ 0.576ns 0.20768mA
+ 0.578ns 0.215422mA
+ 0.58ns 0.223163mA
+ 0.582ns 0.230905mA
+ 0.584ns 0.238647mA
+ 0.586ns 0.246388mA
+ 0.588ns 0.25413mA
+ 0.59ns 0.261872mA
+ 0.592ns 0.269613mA
+ 0.594ns 0.277355mA
+ 0.596ns 0.285096mA
+ 0.598ns 0.292838mA
+ 0.6ns 0.30058mA
+ 0.602ns 0.308322mA
+ 0.604ns 0.316063mA
+ 0.606ns 0.323805mA
+ 0.608ns 0.331546mA
+ 0.61ns 0.339288mA
+ 0.612ns 0.34703mA
+ 0.614ns 0.354771mA
+ 0.616ns 0.362513mA
+ 0.618ns 0.370255mA
+ 0.62ns 0.377996mA
+ 0.622ns 0.385738mA
+ 0.624ns 0.39348mA
+ 0.626ns 0.401221mA
+ 0.628ns 0.408963mA
+ 0.63ns 0.416705mA
+ 0.632ns 0.424446mA
+ 0.634ns 0.432188mA
+ 0.636ns 0.43993mA
+ 0.638ns 0.447671mA
+ 0.64ns 0.455413mA
+ 0.642ns 0.463154mA
+ 0.644ns 0.470896mA
+ 0.646ns 0.478638mA
+ 0.648ns 0.486379mA
+ 0.65ns 0.494121mA
+ 0.652ns 0.501863mA
+ 0.654ns 0.509604mA
+ 0.656ns 0.517346mA
+ 0.658ns 0.525088mA
+ 0.66ns 0.532829mA
+ 0.662ns 0.540571mA
+ 0.664ns 0.548313mA
+ 0.666ns 0.547948mA
+ 0.668ns 0.545566mA
+ 0.67ns 0.543195mA
+ 0.672ns 0.540834mA
+ 0.674ns 0.538484mA
+ 0.676ns 0.536143mA
+ 0.678ns 0.533813mA
+ 0.68ns 0.531493mA
+ 0.682ns 0.529183mA
+ 0.684ns 0.526883mA
+ 0.686ns 0.524593mA
+ 0.688ns 0.522313mA
+ 0.69ns 0.520043mA
+ 0.692ns 0.517782mA
+ 0.694ns 0.515532mA
+ 0.696ns 0.513291mA
+ 0.698ns 0.51106mA
+ 0.7ns 0.508839mA
+ 0.702ns 0.506628mA
+ 0.704ns 0.504426mA
+ 0.706ns 0.502233mA
+ 0.708ns 0.50005mA
+ 0.71ns 0.497877mA
+ 0.712ns 0.495713mA
+ 0.714ns 0.493558mA
+ 0.716ns 0.491413mA
+ 0.718ns 0.489277mA
+ 0.72ns 0.487151mA
+ 0.722ns 0.485033mA
+ 0.724ns 0.482925mA
+ 0.726ns 0.480826mA
+ 0.728ns 0.478736mA
+ 0.73ns 0.476656mA
+ 0.732ns 0.474584mA
+ 0.734ns 0.472521mA
+ 0.736ns 0.470467mA
+ 0.738ns 0.468422mA
+ 0.74ns 0.466387mA
+ 0.742ns 0.464359mA
+ 0.744ns 0.462341mA
+ 0.746ns 0.460331mA
+ 0.748ns 0.458331mA
+ 0.75ns 0.456339mA
+ 0.752ns 0.454355mA
+ 0.754ns 0.45238mA
+ 0.756ns 0.450414mA
+ 0.758ns 0.448456mA
+ 0.76ns 0.446507mA
+ 0.762ns 0.444566mA
+ 0.764ns 0.442634mA
+ 0.766ns 0.44071mA
+ 0.768ns 0.438795mA
+ 0.77ns 0.436887mA
+ 0.772ns 0.434988mA
+ 0.774ns 0.433098mA
+ 0.776ns 0.431215mA
+ 0.778ns 0.429341mA
+ 0.78ns 0.427475mA
+ 0.782ns 0.425617mA
+ 0.784ns 0.423767mA
+ 0.786ns 0.421925mA
+ 0.788ns 0.420091mA
+ 0.79ns 0.418265mA
+ 0.792ns 0.416447mA
+ 0.794ns 0.414637mA
+ 0.796ns 0.412835mA
+ 0.798ns 0.41104mA
+ 0.8ns 0.409254mA
+ 0.802ns 0.407475mA
+ 0.804ns 0.405704mA
+ 0.806ns 0.40394mA
+ 0.808ns 0.402185mA
+ 0.81ns 0.400436mA
+ 0.812ns 0.398696mA
+ 0.814ns 0.396963mA
+ 0.816ns 0.395237mA
+ 0.818ns 0.39352mA
+ 0.82ns 0.391809mA
+ 0.822ns 0.390106mA
+ 0.824ns 0.38841mA
+ 0.826ns 0.386722mA
+ 0.828ns 0.385041mA
+ 0.83ns 0.383367mA
+ 0.832ns 0.381701mA
+ 0.834ns 0.380042mA
+ 0.836ns 0.37839mA
+ 0.838ns 0.376745mA
+ 0.84ns 0.375108mA
+ 0.842ns 0.373477mA
+ 0.844ns 0.371854mA
+ 0.846ns 0.370238mA
+ 0.848ns 0.368628mA
+ 0.85ns 0.367026mA
+ 0.852ns 0.365431mA
+ 0.854ns 0.363842mA
+ 0.856ns 0.362261mA
+ 0.858ns 0.360686mA
+ 0.86ns 0.359118mA
+ 0.862ns 0.357557mA
+ 0.864ns 0.356003mA
+ 0.866ns 0.354456mA
+ 0.868ns 0.352915mA
+ 0.87ns 0.351381mA
+ 0.872ns 0.349853mA
+ 0.874ns 0.348333mA
+ 0.876ns 0.346819mA
+ 0.878ns 0.345311mA
+ 0.88ns 0.34381mA
+ 0.882ns 0.342316mA
+ 0.884ns 0.340828mA
+ 0.886ns 0.339346mA
+ 0.888ns 0.337871mA
+ 0.89ns 0.336402mA
+ 0.892ns 0.33494mA
+ 0.894ns 0.333484mA
+ 0.896ns 0.332035mA
+ 0.898ns 0.330591mA
+ 0.9ns 0.329154mA
+ 0.902ns 0.327724mA
+ 0.904ns 0.326299mA
+ 0.906ns 0.324881mA
+ 0.908ns 0.323469mA
+ 0.91ns 0.322062mA
+ 0.912ns 0.320662mA
+ 0.914ns 0.319269mA
+ 0.916ns 0.317881mA
+ 0.918ns 0.316499mA
+ 0.92ns 0.315123mA
+ 0.922ns 0.313753mA
+ 0.924ns 0.31239mA
+ 0.926ns 0.311032mA
+ 0.928ns 0.30968mA
+ 0.93ns 0.308334mA
+ 0.932ns 0.306993mA
+ 0.934ns 0.305659mA
+ 0.936ns 0.30433mA
+ 0.938ns 0.303007mA
+ 0.94ns 0.30169mA
+ 0.942ns 0.300379mA
+ 0.944ns 0.299073mA
+ 0.946ns 0.297773mA
+ 0.948ns 0.296479mA
+ 0.95ns 0.29519mA
+ 0.952ns 0.293907mA
+ 0.954ns 0.292629mA
+ 0.956ns 0.291357mA
+ 0.958ns 0.29009mA
+ 0.96ns 0.288829mA
+ 0.962ns 0.287574mA
+ 0.964ns 0.286324mA
+ 0.966ns 0.285079mA
+ 0.968ns 0.28384mA
+ 0.97ns 0.282606mA
+ 0.972ns 0.281378mA
+ 0.974ns 0.280155mA
+ 0.976ns 0.278937mA
+ 0.978ns 0.277724mA
+ 0.98ns 0.276517mA
+ 0.982ns 0.275315mA
+ 0.984ns 0.274118mA
+ 0.986ns 0.272927mA
+ 0.988ns 0.27174mA
+ 0.99ns 0.270559mA
+ 0.992ns 0.269383mA
+ 0.994ns 0.268212mA
+ 0.996ns 0.267046mA
+ 0.998ns 0.265885mA
+ 1ns 0.264729mA
+ 1.002ns 0.263578mA
+ 1.004ns 0.262433mA
+ 1.006ns 0.261292mA
+ 1.008ns 0.260156mA
+ 1.01ns 0.259025mA
+ 1.012ns 0.257899mA
+ 1.014ns 0.256778mA
+ 1.016ns 0.255662mA
+ 1.018ns 0.25455mA
+ 1.02ns 0.253444mA
+ 1.022ns 0.252342mA
+ 1.024ns 0.251245mA
+ 1.026ns 0.250153mA
+ 1.028ns 0.249065mA
+ 1.03ns 0.247983mA
+ 1.032ns 0.246905mA
+ 1.034ns 0.245831mA
+ 1.036ns 0.244763mA
+ 1.038ns 0.243699mA
+ 1.04ns 0.242639mA
+ 1.042ns 0.241584mA
+ 1.044ns 0.240534mA
+ 1.046ns 0.239489mA
+ 1.048ns 0.238448mA
+ 1.05ns 0.237411mA
+ 1.052ns 0.236379mA
+ 1.054ns 0mA
+ 8.022ns 0mA
+ 8.024ns 0.00639738mA
+ 8.026ns 0.0141385mA
+ 8.028ns 0.0218795mA
+ 8.03ns 0.0296206mA
+ 8.032ns 0.0373617mA
+ 8.034ns 0.0451065mA
+ 8.036ns 0.0528476mA
+ 8.038ns 0.0605887mA
+ 8.04ns 0.0683297mA
+ 8.042ns 0.0760708mA
+ 8.044ns 0.0838119mA
+ 8.046ns 0.091553mA
+ 8.048ns 0.0992978mA
+ 8.05ns 0.107039mA
+ 8.052ns 0.11478mA
+ 8.054ns 0.122521mA
+ 8.056ns 0.130262mA
+ 8.058ns 0.138003mA
+ 8.06ns 0.145748mA
+ 8.062ns 0.153489mA
+ 8.064ns 0.16123mA
+ 8.066ns 0.168971mA
+ 8.068ns 0.176712mA
+ 8.07ns 0.184453mA
+ 8.072ns 0.192194mA
+ 8.074ns 0.199939mA
+ 8.076ns 0.20768mA
+ 8.078ns 0.215421mA
+ 8.08ns 0.223163mA
+ 8.082ns 0.230904mA
+ 8.084ns 0.238645mA
+ 8.086ns 0.246389mA
+ 8.088ns 0.254131mA
+ 8.09ns 0.261872mA
+ 8.092ns 0.269613mA
+ 8.094ns 0.277354mA
+ 8.096ns 0.285095mA
+ 8.098ns 0.292836mA
+ 8.1ns 0.300581mA
+ 8.102ns 0.308322mA
+ 8.104ns 0.316063mA
+ 8.106ns 0.323804mA
+ 8.108ns 0.331545mA
+ 8.11ns 0.339286mA
+ 8.112ns 0.347031mA
+ 8.114ns 0.354772mA
+ 8.116ns 0.362513mA
+ 8.118ns 0.370254mA
+ 8.12ns 0.377995mA
+ 8.122ns 0.385736mA
+ 8.124ns 0.393477mA
+ 8.126ns 0.401222mA
+ 8.128ns 0.408963mA
+ 8.13ns 0.416704mA
+ 8.132ns 0.424445mA
+ 8.134ns 0.432187mA
+ 8.136ns 0.439928mA
+ 8.138ns 0.447669mA
+ 8.14ns 0.455414mA
+ 8.142ns 0.463155mA
+ 8.144ns 0.470896mA
+ 8.146ns 0.478637mA
+ 8.148ns 0.486378mA
+ 8.15ns 0.494119mA
+ 8.152ns 0.501864mA
+ 8.154ns 0.509605mA
+ 8.156ns 0.517346mA
+ 8.158ns 0.525087mA
+ 8.16ns 0.532828mA
+ 8.162ns 0.540569mA
+ 8.164ns 0.54831mA
+ 8.166ns 0.547948mA
+ 8.168ns 0.545566mA
+ 8.17ns 0.543195mA
+ 8.172ns 0.540835mA
+ 8.174ns 0.538484mA
+ 8.176ns 0.536144mA
+ 8.178ns 0.533813mA
+ 8.18ns 0.531493mA
+ 8.182ns 0.529183mA
+ 8.184ns 0.526883mA
+ 8.186ns 0.524593mA
+ 8.188ns 0.522313mA
+ 8.19ns 0.520043mA
+ 8.192ns 0.517782mA
+ 8.194ns 0.515532mA
+ 8.196ns 0.513291mA
+ 8.198ns 0.511061mA
+ 8.2ns 0.50884mA
+ 8.202ns 0.506628mA
+ 8.204ns 0.504425mA
+ 8.206ns 0.502233mA
+ 8.208ns 0.50005mA
+ 8.21ns 0.497877mA
+ 8.212ns 0.495713mA
+ 8.214ns 0.493559mA
+ 8.216ns 0.491414mA
+ 8.218ns 0.489277mA
+ 8.22ns 0.487151mA
+ 8.222ns 0.485033mA
+ 8.224ns 0.482925mA
+ 8.226ns 0.480827mA
+ 8.228ns 0.478737mA
+ 8.23ns 0.476656mA
+ 8.232ns 0.474584mA
+ 8.234ns 0.472521mA
+ 8.236ns 0.470467mA
+ 8.238ns 0.468423mA
+ 8.24ns 0.466387mA
+ 8.242ns 0.46436mA
+ 8.244ns 0.462341mA
+ 8.246ns 0.460331mA
+ 8.248ns 0.458331mA
+ 8.25ns 0.456339mA
+ 8.252ns 0.454355mA
+ 8.254ns 0.452381mA
+ 8.256ns 0.450415mA
+ 8.258ns 0.448456mA
+ 8.26ns 0.446507mA
+ 8.262ns 0.444566mA
+ 8.264ns 0.442634mA
+ 8.266ns 0.440711mA
+ 8.268ns 0.438795mA
+ 8.27ns 0.436887mA
+ 8.272ns 0.434988mA
+ 8.274ns 0.433098mA
+ 8.276ns 0.431215mA
+ 8.278ns 0.429341mA
+ 8.28ns 0.427475mA
+ 8.282ns 0.425617mA
+ 8.284ns 0.423767mA
+ 8.286ns 0.421925mA
+ 8.288ns 0.420091mA
+ 8.29ns 0.418265mA
+ 8.292ns 0.416447mA
+ 8.294ns 0.414637mA
+ 8.296ns 0.412834mA
+ 8.298ns 0.41104mA
+ 8.3ns 0.409254mA
+ 8.302ns 0.407475mA
+ 8.304ns 0.405704mA
+ 8.306ns 0.403941mA
+ 8.308ns 0.402185mA
+ 8.31ns 0.400436mA
+ 8.312ns 0.398696mA
+ 8.314ns 0.396963mA
+ 8.316ns 0.395238mA
+ 8.318ns 0.39352mA
+ 8.32ns 0.391809mA
+ 8.322ns 0.390106mA
+ 8.324ns 0.38841mA
+ 8.326ns 0.386722mA
+ 8.328ns 0.385041mA
+ 8.33ns 0.383368mA
+ 8.332ns 0.381701mA
+ 8.334ns 0.380042mA
+ 8.336ns 0.37839mA
+ 8.338ns 0.376745mA
+ 8.34ns 0.375108mA
+ 8.342ns 0.373477mA
+ 8.344ns 0.371854mA
+ 8.346ns 0.370238mA
+ 8.348ns 0.368629mA
+ 8.35ns 0.367026mA
+ 8.352ns 0.365431mA
+ 8.354ns 0.363842mA
+ 8.356ns 0.362261mA
+ 8.358ns 0.360686mA
+ 8.36ns 0.359119mA
+ 8.362ns 0.357557mA
+ 8.364ns 0.356003mA
+ 8.366ns 0.354456mA
+ 8.368ns 0.352915mA
+ 8.37ns 0.351381mA
+ 8.372ns 0.349854mA
+ 8.374ns 0.348333mA
+ 8.376ns 0.346818mA
+ 8.378ns 0.345311mA
+ 8.38ns 0.34381mA
+ 8.382ns 0.342316mA
+ 8.384ns 0.340828mA
+ 8.386ns 0.339347mA
+ 8.388ns 0.337871mA
+ 8.39ns 0.336402mA
+ 8.392ns 0.33494mA
+ 8.394ns 0.333484mA
+ 8.396ns 0.332035mA
+ 8.398ns 0.330592mA
+ 8.4ns 0.329155mA
+ 8.402ns 0.327723mA
+ 8.404ns 0.326299mA
+ 8.406ns 0.324881mA
+ 8.408ns 0.323469mA
+ 8.41ns 0.322063mA
+ 8.412ns 0.320663mA
+ 8.414ns 0.319269mA
+ 8.416ns 0.317881mA
+ 8.418ns 0.316499mA
+ 8.42ns 0.315123mA
+ 8.422ns 0.313754mA
+ 8.424ns 0.31239mA
+ 8.426ns 0.311032mA
+ 8.428ns 0.30968mA
+ 8.43ns 0.308333mA
+ 8.432ns 0.306993mA
+ 8.434ns 0.305659mA
+ 8.436ns 0.30433mA
+ 8.438ns 0.303008mA
+ 8.44ns 0.301691mA
+ 8.442ns 0.300379mA
+ 8.444ns 0.299073mA
+ 8.446ns 0.297773mA
+ 8.448ns 0.296479mA
+ 8.45ns 0.29519mA
+ 8.452ns 0.293907mA
+ 8.454ns 0.292629mA
+ 8.456ns 0.291357mA
+ 8.458ns 0.29009mA
+ 8.46ns 0.28883mA
+ 8.462ns 0.287574mA
+ 8.464ns 0.286324mA
+ 8.466ns 0.28508mA
+ 8.468ns 0.28384mA
+ 8.47ns 0.282606mA
+ 8.472ns 0.281378mA
+ 8.474ns 0.280155mA
+ 8.476ns 0.278937mA
+ 8.478ns 0.277724mA
+ 8.48ns 0.276517mA
+ 8.482ns 0.275315mA
+ 8.484ns 0.274118mA
+ 8.486ns 0.272927mA
+ 8.488ns 0.27174mA
+ 8.49ns 0.270559mA
+ 8.492ns 0.269383mA
+ 8.494ns 0.268212mA
+ 8.496ns 0.267046mA
+ 8.498ns 0.265885mA
+ 8.5ns 0.264729mA
+ 8.502ns 0.263579mA
+ 8.504ns 0.262433mA
+ 8.506ns 0.261292mA
+ 8.508ns 0.260156mA
+ 8.51ns 0.259025mA
+ 8.512ns 0.257899mA
+ 8.514ns 0.256778mA
+ 8.516ns 0.255662mA
+ 8.518ns 0.254551mA
+ 8.52ns 0.253444mA
+ 8.522ns 0.252342mA
+ 8.524ns 0.251245mA
+ 8.526ns 0.250153mA
+ 8.528ns 0.249066mA
+ 8.53ns 0.247983mA
+ 8.532ns 0.246905mA
+ 8.534ns 0.245831mA
+ 8.536ns 0.244763mA
+ 8.538ns 0.243699mA
+ 8.54ns 0.242639mA
+ 8.542ns 0.241585mA
+ 8.544ns 0.240535mA
+ 8.546ns 0.239488mA
+ 8.548ns 0.238447mA
+ 8.55ns 0.237411mA
+ 8.552ns 0.236379mA
+ 8.554ns 0mA
I117 195 0 PWL 0 0
+ 8.012ns 0mA
+ 8.014ns 0.007511mA
+ 8.016ns 0.0151834mA
+ 8.018ns 0.0228559mA
+ 8.02ns 0.030532mA
+ 8.022ns 0.0382044mA
+ 8.024ns 0.0458769mA
+ 8.026ns 0.0535493mA
+ 8.028ns 0.0612218mA
+ 8.03ns 0.0688942mA
+ 8.032ns 0.0765667mA
+ 8.034ns 0.0842428mA
+ 8.036ns 0.0919152mA
+ 8.038ns 0.0995876mA
+ 8.04ns 0.10726mA
+ 8.042ns 0.114933mA
+ 8.044ns 0.122605mA
+ 8.046ns 0.130277mA
+ 8.048ns 0.137954mA
+ 8.05ns 0.145626mA
+ 8.052ns 0.153298mA
+ 8.054ns 0.160971mA
+ 8.056ns 0.168643mA
+ 8.058ns 0.176316mA
+ 8.06ns 0.183992mA
+ 8.062ns 0.191664mA
+ 8.064ns 0.199337mA
+ 8.066ns 0.207009mA
+ 8.068ns 0.214682mA
+ 8.07ns 0.222354mA
+ 8.072ns 0.230026mA
+ 8.074ns 0.237703mA
+ 8.076ns 0.245375mA
+ 8.078ns 0.253047mA
+ 8.08ns 0.26072mA
+ 8.082ns 0.268392mA
+ 8.084ns 0.276065mA
+ 8.086ns 0.283741mA
+ 8.088ns 0.291413mA
+ 8.09ns 0.299086mA
+ 8.092ns 0.306758mA
+ 8.094ns 0.314431mA
+ 8.096ns 0.322103mA
+ 8.098ns 0.329776mA
+ 8.1ns 0.337452mA
+ 8.102ns 0.345124mA
+ 8.104ns 0.352797mA
+ 8.106ns 0.360469mA
+ 8.108ns 0.368141mA
+ 8.11ns 0.375814mA
+ 8.112ns 0.38349mA
+ 8.114ns 0.391162mA
+ 8.116ns 0.398835mA
+ 8.118ns 0.406507mA
+ 8.12ns 0.41418mA
+ 8.122ns 0.421852mA
+ 8.124ns 0.429525mA
+ 8.126ns 0.437201mA
+ 8.128ns 0.444873mA
+ 8.13ns 0.452546mA
+ 8.132ns 0.460218mA
+ 8.134ns 0.467891mA
+ 8.136ns 0.475563mA
+ 8.138ns 0.483235mA
+ 8.14ns 0.490912mA
+ 8.142ns 0.498584mA
+ 8.144ns 0.506256mA
+ 8.146ns 0.513929mA
+ 8.148ns 0.521601mA
+ 8.15ns 0.529274mA
+ 8.152ns 0.53695mA
+ 8.154ns 0.544622mA
+ 8.156ns 0.55179mA
+ 8.158ns 0.549378mA
+ 8.16ns 0.546976mA
+ 8.162ns 0.544585mA
+ 8.164ns 0.542205mA
+ 8.166ns 0.539834mA
+ 8.168ns 0.537474mA
+ 8.17ns 0.535124mA
+ 8.172ns 0.532785mA
+ 8.174ns 0.530456mA
+ 8.176ns 0.528138mA
+ 8.178ns 0.525828mA
+ 8.18ns 0.523529mA
+ 8.182ns 0.521241mA
+ 8.184ns 0.518963mA
+ 8.186ns 0.516694mA
+ 8.188ns 0.514435mA
+ 8.19ns 0.512187mA
+ 8.192ns 0.509947mA
+ 8.194ns 0.507718mA
+ 8.196ns 0.505498mA
+ 8.198ns 0.503289mA
+ 8.2ns 0.501089mA
+ 8.202ns 0.498898mA
+ 8.204ns 0.496716mA
+ 8.206ns 0.494545mA
+ 8.208ns 0.492383mA
+ 8.21ns 0.490231mA
+ 8.212ns 0.488088mA
+ 8.214ns 0.485955mA
+ 8.216ns 0.48383mA
+ 8.218ns 0.481714mA
+ 8.22ns 0.479609mA
+ 8.222ns 0.477512mA
+ 8.224ns 0.475425mA
+ 8.226ns 0.473347mA
+ 8.228ns 0.471277mA
+ 8.23ns 0.469217mA
+ 8.232ns 0.467165mA
+ 8.234ns 0.465123mA
+ 8.236ns 0.46309mA
+ 8.238ns 0.461066mA
+ 8.24ns 0.45905mA
+ 8.242ns 0.457043mA
+ 8.244ns 0.455045mA
+ 8.246ns 0.453055mA
+ 8.248ns 0.451075mA
+ 8.25ns 0.449103mA
+ 8.252ns 0.44714mA
+ 8.254ns 0.445185mA
+ 8.256ns 0.443239mA
+ 8.258ns 0.441301mA
+ 8.26ns 0.439372mA
+ 8.262ns 0.437451mA
+ 8.264ns 0.435539mA
+ 8.266ns 0.433635mA
+ 8.268ns 0.431739mA
+ 8.27ns 0.429851mA
+ 8.272ns 0.427972mA
+ 8.274ns 0.426101mA
+ 8.276ns 0.424238mA
+ 8.278ns 0.422384mA
+ 8.28ns 0.420537mA
+ 8.282ns 0.418699mA
+ 8.284ns 0.416868mA
+ 8.286ns 0.415046mA
+ 8.288ns 0.413231mA
+ 8.29ns 0.411425mA
+ 8.292ns 0.409626mA
+ 8.294ns 0.407836mA
+ 8.296ns 0.406052mA
+ 8.298ns 0.404277mA
+ 8.3ns 0.40251mA
+ 8.302ns 0.40075mA
+ 8.304ns 0.398998mA
+ 8.306ns 0.397254mA
+ 8.308ns 0.395517mA
+ 8.31ns 0.393787mA
+ 8.312ns 0.392066mA
+ 8.314ns 0.390352mA
+ 8.316ns 0.388646mA
+ 8.318ns 0.386947mA
+ 8.32ns 0.385255mA
+ 8.322ns 0.383571mA
+ 8.324ns 0.381893mA
+ 8.326ns 0.380224mA
+ 8.328ns 0.378562mA
+ 8.33ns 0.376907mA
+ 8.332ns 0.375259mA
+ 8.334ns 0.373619mA
+ 8.336ns 0.371985mA
+ 8.338ns 0.370358mA
+ 8.34ns 0.368739mA
+ 8.342ns 0.367127mA
+ 8.344ns 0.365523mA
+ 8.346ns 0.363925mA
+ 8.348ns 0.362334mA
+ 8.35ns 0.360749mA
+ 8.352ns 0.359172mA
+ 8.354ns 0.357602mA
+ 8.356ns 0.356038mA
+ 8.358ns 0.354482mA
+ 8.36ns 0.352932mA
+ 8.362ns 0.351389mA
+ 8.364ns 0.349853mA
+ 8.366ns 0.348323mA
+ 8.368ns 0.3468mA
+ 8.37ns 0.345284mA
+ 8.372ns 0.343775mA
+ 8.374ns 0.342272mA
+ 8.376ns 0.340775mA
+ 8.378ns 0.339285mA
+ 8.38ns 0.337802mA
+ 8.382ns 0.336325mA
+ 8.384ns 0.334855mA
+ 8.386ns 0.333391mA
+ 8.388ns 0.331933mA
+ 8.39ns 0.330482mA
+ 8.392ns 0.329037mA
+ 8.394ns 0.327598mA
+ 8.396ns 0.326166mA
+ 8.398ns 0.32474mA
+ 8.4ns 0.323321mA
+ 8.402ns 0.321907mA
+ 8.404ns 0.320499mA
+ 8.406ns 0.319098mA
+ 8.408ns 0.317703mA
+ 8.41ns 0.316314mA
+ 8.412ns 0.314931mA
+ 8.414ns 0.313555mA
+ 8.416ns 0.312183mA
+ 8.418ns 0.310818mA
+ 8.42ns 0.30946mA
+ 8.422ns 0.308107mA
+ 8.424ns 0.30676mA
+ 8.426ns 0.305419mA
+ 8.428ns 0.304083mA
+ 8.43ns 0.302753mA
+ 8.432ns 0.30143mA
+ 8.434ns 0.300112mA
+ 8.436ns 0.2988mA
+ 8.438ns 0.297494mA
+ 8.44ns 0.296193mA
+ 8.442ns 0.294898mA
+ 8.444ns 0.293608mA
+ 8.446ns 0.292325mA
+ 8.448ns 0.291047mA
+ 8.45ns 0.289774mA
+ 8.452ns 0.288507mA
+ 8.454ns 0.287246mA
+ 8.456ns 0.28599mA
+ 8.458ns 0.284739mA
+ 8.46ns 0.283495mA
+ 8.462ns 0.282255mA
+ 8.464ns 0.281021mA
+ 8.466ns 0.279793mA
+ 8.468ns 0.278569mA
+ 8.47ns 0.277351mA
+ 8.472ns 0.276138mA
+ 8.474ns 0.274931mA
+ 8.476ns 0.273729mA
+ 8.478ns 0.272532mA
+ 8.48ns 0.27134mA
+ 8.482ns 0.270154mA
+ 8.484ns 0.268973mA
+ 8.486ns 0.267797mA
+ 8.488ns 0.266626mA
+ 8.49ns 0.265461mA
+ 8.492ns 0.2643mA
+ 8.494ns 0.263144mA
+ 8.496ns 0.261994mA
+ 8.498ns 0.260848mA
+ 8.5ns 0.259708mA
+ 8.502ns 0.258572mA
+ 8.504ns 0.257442mA
+ 8.506ns 0.256316mA
+ 8.508ns 0.255195mA
+ 8.51ns 0.254079mA
+ 8.512ns 0.252969mA
+ 8.514ns 0.251863mA
+ 8.516ns 0.250762mA
+ 8.518ns 0.249665mA
+ 8.52ns 0.248573mA
+ 8.522ns 0.247486mA
+ 8.524ns 0.246404mA
+ 8.526ns 0.245327mA
+ 8.528ns 0.244255mA
+ 8.53ns 0.243187mA
+ 8.532ns 0.242123mA
+ 8.534ns 0.241064mA
+ 8.536ns 0.24001mA
+ 8.538ns 0.238961mA
+ 8.54ns 0.237916mA
+ 8.542ns 0.236876mA
+ 8.544ns 0.23584mA
+ 8.546ns 0mA
I118 196 0 PWL 0 0
+ 0.902ns 0mA
+ 0.904ns 0.000327489mA
+ 0.906ns 0.00636515mA
+ 0.908ns 0.012403mA
+ 0.91ns 0.0184407mA
+ 0.912ns 0.0244785mA
+ 0.914ns 0.0305162mA
+ 0.916ns 0.036554mA
+ 0.918ns 0.0425917mA
+ 0.92ns 0.0486293mA
+ 0.922ns 0.0546672mA
+ 0.924ns 0.0607049mA
+ 0.926ns 0.0667427mA
+ 0.928ns 0.0727804mA
+ 0.93ns 0.0788182mA
+ 0.932ns 0.0848559mA
+ 0.934ns 0.0908935mA
+ 0.936ns 0.0969314mA
+ 0.938ns 0.102969mA
+ 0.94ns 0.109007mA
+ 0.942ns 0.115045mA
+ 0.944ns 0.121082mA
+ 0.946ns 0.12712mA
+ 0.948ns 0.133158mA
+ 0.95ns 0.139196mA
+ 0.952ns 0.145233mA
+ 0.954ns 0.151271mA
+ 0.956ns 0.157309mA
+ 0.958ns 0.163347mA
+ 0.96ns 0.169384mA
+ 0.962ns 0.175422mA
+ 0.964ns 0.18146mA
+ 0.966ns 0.187497mA
+ 0.968ns 0.193535mA
+ 0.97ns 0.199573mA
+ 0.972ns 0.205611mA
+ 0.974ns 0.211648mA
+ 0.976ns 0.217686mA
+ 0.978ns 0.223724mA
+ 0.98ns 0.229762mA
+ 0.982ns 0.235799mA
+ 0.984ns 0.241837mA
+ 0.986ns 0.247875mA
+ 0.988ns 0.253913mA
+ 0.99ns 0.25995mA
+ 0.992ns 0.265988mA
+ 0.994ns 0.272026mA
+ 0.996ns 0.278064mA
+ 0.998ns 0.284101mA
+ 1ns 0.290139mA
+ 1.002ns 0.296177mA
+ 1.004ns 0.302215mA
+ 1.006ns 0.308252mA
+ 1.008ns 0.31429mA
+ 1.01ns 0.320328mA
+ 1.012ns 0.326366mA
+ 1.014ns 0.332403mA
+ 1.016ns 0.338441mA
+ 1.018ns 0.344479mA
+ 1.02ns 0.350517mA
+ 1.022ns 0.356554mA
+ 1.024ns 0.362592mA
+ 1.026ns 0.36863mA
+ 1.028ns 0.374667mA
+ 1.03ns 0.380705mA
+ 1.032ns 0.386743mA
+ 1.034ns 0.392781mA
+ 1.036ns 0.398818mA
+ 1.038ns 0.404856mA
+ 1.04ns 0.410894mA
+ 1.042ns 0.416932mA
+ 1.044ns 0.422969mA
+ 1.046ns 0.429007mA
+ 1.048ns 0.435045mA
+ 1.05ns 0.441083mA
+ 1.052ns 0.44712mA
+ 1.054ns 0.453158mA
+ 1.056ns 0.459196mA
+ 1.058ns 0.465234mA
+ 1.06ns 0.471271mA
+ 1.062ns 0.477309mA
+ 1.064ns 0.483347mA
+ 1.066ns 0.489385mA
+ 1.068ns 0.495422mA
+ 1.07ns 0.50146mA
+ 1.072ns 0.507498mA
+ 1.074ns 0.513535mA
+ 1.076ns 0.519574mA
+ 1.078ns 0.525194mA
+ 1.08ns 0.52291mA
+ 1.082ns 0.520636mA
+ 1.084ns 0.518371mA
+ 1.086ns 0.516117mA
+ 1.088ns 0.513872mA
+ 1.09ns 0.511637mA
+ 1.092ns 0.509412mA
+ 1.094ns 0.507196mA
+ 1.096ns 0.50499mA
+ 1.098ns 0.502794mA
+ 1.1ns 0.500607mA
+ 1.102ns 0.49843mA
+ 1.104ns 0.496262mA
+ 1.106ns 0.494103mA
+ 1.108ns 0.491954mA
+ 1.11ns 0.489814mA
+ 1.112ns 0.487684mA
+ 1.114ns 0.485563mA
+ 1.116ns 0.483451mA
+ 1.118ns 0.481348mA
+ 1.12ns 0.479255mA
+ 1.122ns 0.47717mA
+ 1.124ns 0.475095mA
+ 1.126ns 0.473028mA
+ 1.128ns 0.470971mA
+ 1.13ns 0.468923mA
+ 1.132ns 0.466883mA
+ 1.134ns 0.464852mA
+ 1.136ns 0.46283mA
+ 1.138ns 0.460817mA
+ 1.14ns 0.458813mA
+ 1.142ns 0.456817mA
+ 1.144ns 0.45483mA
+ 1.146ns 0.452852mA
+ 1.148ns 0.450883mA
+ 1.15ns 0.448921mA
+ 1.152ns 0.446969mA
+ 1.154ns 0.445025mA
+ 1.156ns 0.443089mA
+ 1.158ns 0.441162mA
+ 1.16ns 0.439243mA
+ 1.162ns 0.437333mA
+ 1.164ns 0.43543mA
+ 1.166ns 0.433536mA
+ 1.168ns 0.431651mA
+ 1.17ns 0.429773mA
+ 1.172ns 0.427904mA
+ 1.174ns 0.426043mA
+ 1.176ns 0.42419mA
+ 1.178ns 0.422345mA
+ 1.18ns 0.420508mA
+ 1.182ns 0.418679mA
+ 1.184ns 0.416858mA
+ 1.186ns 0.415044mA
+ 1.188ns 0.413239mA
+ 1.19ns 0.411442mA
+ 1.192ns 0.409652mA
+ 1.194ns 0.40787mA
+ 1.196ns 0.406096mA
+ 1.198ns 0.40433mA
+ 1.2ns 0.402571mA
+ 1.202ns 0.40082mA
+ 1.204ns 0.399077mA
+ 1.206ns 0.397341mA
+ 1.208ns 0.395613mA
+ 1.21ns 0.393892mA
+ 1.212ns 0.392179mA
+ 1.214ns 0.390473mA
+ 1.216ns 0.388774mA
+ 1.218ns 0.387083mA
+ 1.22ns 0.3854mA
+ 1.222ns 0.383723mA
+ 1.224ns 0.382054mA
+ 1.226ns 0.380392mA
+ 1.228ns 0.378738mA
+ 1.23ns 0.37709mA
+ 1.232ns 0.37545mA
+ 1.234ns 0.373817mA
+ 1.236ns 0.372191mA
+ 1.238ns 0.370572mA
+ 1.24ns 0.36896mA
+ 1.242ns 0.367355mA
+ 1.244ns 0.365757mA
+ 1.246ns 0.364167mA
+ 1.248ns 0.362583mA
+ 1.25ns 0.361005mA
+ 1.252ns 0.359435mA
+ 1.254ns 0.357872mA
+ 1.256ns 0.356315mA
+ 1.258ns 0.354765mA
+ 1.26ns 0.353222mA
+ 1.262ns 0.351686mA
+ 1.264ns 0.350156mA
+ 1.266ns 0.348633mA
+ 1.268ns 0.347116mA
+ 1.27ns 0.345606mA
+ 1.272ns 0.344103mA
+ 1.274ns 0.342606mA
+ 1.276ns 0.341116mA
+ 1.278ns 0.339632mA
+ 1.28ns 0.338155mA
+ 1.282ns 0.336684mA
+ 1.284ns 0.33522mA
+ 1.286ns 0.333761mA
+ 1.288ns 0.33231mA
+ 1.29ns 0.330864mA
+ 1.292ns 0.329425mA
+ 1.294ns 0.327992mA
+ 1.296ns 0.326565mA
+ 1.298ns 0.325145mA
+ 1.3ns 0.32373mA
+ 1.302ns 0.322322mA
+ 1.304ns 0.32092mA
+ 1.306ns 0.319524mA
+ 1.308ns 0.318134mA
+ 1.31ns 0.316751mA
+ 1.312ns 0.315373mA
+ 1.314ns 0.314001mA
+ 1.316ns 0.312635mA
+ 1.318ns 0.311275mA
+ 1.32ns 0.309921mA
+ 1.322ns 0.308573mA
+ 1.324ns 0.307231mA
+ 1.326ns 0.305894mA
+ 1.328ns 0.304564mA
+ 1.33ns 0.303239mA
+ 1.332ns 0.30192mA
+ 1.334ns 0.300606mA
+ 1.336ns 0.299299mA
+ 1.338ns 0.297997mA
+ 1.34ns 0.296701mA
+ 1.342ns 0.29541mA
+ 1.344ns 0.294125mA
+ 1.346ns 0.292846mA
+ 1.348ns 0.291572mA
+ 1.35ns 0.290303mA
+ 1.352ns 0.289041mA
+ 1.354ns 0.287783mA
+ 1.356ns 0.286531mA
+ 1.358ns 0.285285mA
+ 1.36ns 0.284044mA
+ 1.362ns 0.282808mA
+ 1.364ns 0.281578mA
+ 1.366ns 0.280353mA
+ 1.368ns 0.279134mA
+ 1.37ns 0.27792mA
+ 1.372ns 0.276711mA
+ 1.374ns 0.275507mA
+ 1.376ns 0.274309mA
+ 1.378ns 0.273115mA
+ 1.38ns 0.271927mA
+ 1.382ns 0.270744mA
+ 1.384ns 0.269567mA
+ 1.386ns 0.268394mA
+ 1.388ns 0.267226mA
+ 1.39ns 0.266064mA
+ 1.392ns 0.264907mA
+ 1.394ns 0.263754mA
+ 1.396ns 0.262607mA
+ 1.398ns 0.261464mA
+ 1.4ns 0.260327mA
+ 1.402ns 0.259195mA
+ 1.404ns 0.258067mA
+ 1.406ns 0.256945mA
+ 1.408ns 0.255827mA
+ 1.41ns 0.254714mA
+ 1.412ns 0.253606mA
+ 1.414ns 0.252503mA
+ 1.416ns 0.251404mA
+ 1.418ns 0.250311mA
+ 1.42ns 0.249222mA
+ 1.422ns 0.248138mA
+ 1.424ns 0.247058mA
+ 1.426ns 0.245983mA
+ 1.428ns 0.244913mA
+ 1.43ns 0.243848mA
+ 1.432ns 0.242787mA
+ 1.434ns 0.241731mA
+ 1.436ns 0.240679mA
+ 1.438ns 0.239632mA
+ 1.44ns 0.23859mA
+ 1.442ns 0.237552mA
+ 1.444ns 0.236519mA
+ 1.446ns 0.23549mA
+ 1.448ns 0.234465mA
+ 1.45ns 0.233445mA
+ 1.452ns 0.23243mA
+ 1.454ns 0.231419mA
+ 1.456ns 0.230412mA
+ 1.458ns 0.22941mA
+ 1.46ns 0.228412mA
+ 1.462ns 0.227418mA
+ 1.464ns 0.226429mA
+ 1.466ns 0.225444mA
+ 1.468ns 0.224463mA
+ 1.47ns 0.223487mA
+ 1.472ns 0.222514mA
+ 1.474ns 0.221546mA
+ 1.476ns 0.220583mA
+ 1.478ns 0.219623mA
+ 1.48ns 0.218668mA
+ 1.482ns 0.217716mA
+ 1.484ns 0mA
I119 197 0 PWL 0 0
+ 0.508ns 0mA
+ 0.51ns 0.00119452mA
+ 0.512ns 0.00887136mA
+ 0.514ns 0.0165482mA
+ 0.516ns 0.0242253mA
+ 0.518ns 0.0319021mA
+ 0.52ns 0.0395792mA
+ 0.522ns 0.047256mA
+ 0.524ns 0.0549331mA
+ 0.526ns 0.0626099mA
+ 0.528ns 0.0702868mA
+ 0.53ns 0.0779638mA
+ 0.532ns 0.0856407mA
+ 0.534ns 0.0933177mA
+ 0.536ns 0.100995mA
+ 0.538ns 0.108672mA
+ 0.54ns 0.116348mA
+ 0.542ns 0.124026mA
+ 0.544ns 0.131702mA
+ 0.546ns 0.139379mA
+ 0.548ns 0.147056mA
+ 0.55ns 0.154733mA
+ 0.552ns 0.16241mA
+ 0.554ns 0.170087mA
+ 0.556ns 0.177764mA
+ 0.558ns 0.185441mA
+ 0.56ns 0.193118mA
+ 0.562ns 0.200795mA
+ 0.564ns 0.208472mA
+ 0.566ns 0.216149mA
+ 0.568ns 0.223826mA
+ 0.57ns 0.231503mA
+ 0.572ns 0.23918mA
+ 0.574ns 0.246856mA
+ 0.576ns 0.254533mA
+ 0.578ns 0.26221mA
+ 0.58ns 0.269887mA
+ 0.582ns 0.277564mA
+ 0.584ns 0.285241mA
+ 0.586ns 0.292918mA
+ 0.588ns 0.300595mA
+ 0.59ns 0.308272mA
+ 0.592ns 0.315949mA
+ 0.594ns 0.323626mA
+ 0.596ns 0.331303mA
+ 0.598ns 0.33898mA
+ 0.6ns 0.346657mA
+ 0.602ns 0.354334mA
+ 0.604ns 0.362011mA
+ 0.606ns 0.369687mA
+ 0.608ns 0.377364mA
+ 0.61ns 0.385041mA
+ 0.612ns 0.392718mA
+ 0.614ns 0.400395mA
+ 0.616ns 0.408072mA
+ 0.618ns 0.415749mA
+ 0.62ns 0.423426mA
+ 0.622ns 0.431103mA
+ 0.624ns 0.43878mA
+ 0.626ns 0.446457mA
+ 0.628ns 0.454134mA
+ 0.63ns 0.461811mA
+ 0.632ns 0.469488mA
+ 0.634ns 0.477165mA
+ 0.636ns 0.484842mA
+ 0.638ns 0.492518mA
+ 0.64ns 0.500196mA
+ 0.642ns 0.507872mA
+ 0.644ns 0.515549mA
+ 0.646ns 0.523226mA
+ 0.648ns 0.530903mA
+ 0.65ns 0.53858mA
+ 0.652ns 0.546257mA
+ 0.654ns 0.55141mA
+ 0.656ns 0.548999mA
+ 0.658ns 0.546599mA
+ 0.66ns 0.544209mA
+ 0.662ns 0.54183mA
+ 0.664ns 0.539461mA
+ 0.666ns 0.537102mA
+ 0.668ns 0.534754mA
+ 0.67ns 0.532416mA
+ 0.672ns 0.530088mA
+ 0.674ns 0.52777mA
+ 0.676ns 0.525463mA
+ 0.678ns 0.523166mA
+ 0.68ns 0.520878mA
+ 0.682ns 0.518601mA
+ 0.684ns 0.516333mA
+ 0.686ns 0.514076mA
+ 0.688ns 0.511828mA
+ 0.69ns 0.50959mA
+ 0.692ns 0.507362mA
+ 0.694ns 0.505144mA
+ 0.696ns 0.502935mA
+ 0.698ns 0.500737mA
+ 0.7ns 0.498547mA
+ 0.702ns 0.496367mA
+ 0.704ns 0.494197mA
+ 0.706ns 0.492036mA
+ 0.708ns 0.489885mA
+ 0.71ns 0.487743mA
+ 0.712ns 0.485611mA
+ 0.714ns 0.483487mA
+ 0.716ns 0.481374mA
+ 0.718ns 0.479269mA
+ 0.72ns 0.477173mA
+ 0.722ns 0.475087mA
+ 0.724ns 0.47301mA
+ 0.726ns 0.470942mA
+ 0.728ns 0.468883mA
+ 0.73ns 0.466832mA
+ 0.732ns 0.464791mA
+ 0.734ns 0.462759mA
+ 0.736ns 0.460736mA
+ 0.738ns 0.458721mA
+ 0.74ns 0.456716mA
+ 0.742ns 0.454719mA
+ 0.744ns 0.452731mA
+ 0.746ns 0.450751mA
+ 0.748ns 0.44878mA
+ 0.75ns 0.446818mA
+ 0.752ns 0.444864mA
+ 0.754ns 0.442919mA
+ 0.756ns 0.440983mA
+ 0.758ns 0.439054mA
+ 0.76ns 0.437135mA
+ 0.762ns 0.435223mA
+ 0.764ns 0.43332mA
+ 0.766ns 0.431426mA
+ 0.768ns 0.42954mA
+ 0.77ns 0.427661mA
+ 0.772ns 0.425792mA
+ 0.774ns 0.42393mA
+ 0.776ns 0.422076mA
+ 0.778ns 0.420231mA
+ 0.78ns 0.418393mA
+ 0.782ns 0.416564mA
+ 0.784ns 0.414742mA
+ 0.786ns 0.412929mA
+ 0.788ns 0.411123mA
+ 0.79ns 0.409326mA
+ 0.792ns 0.407536mA
+ 0.794ns 0.405754mA
+ 0.796ns 0.40398mA
+ 0.798ns 0.402214mA
+ 0.8ns 0.400455mA
+ 0.802ns 0.398704mA
+ 0.804ns 0.396961mA
+ 0.806ns 0.395225mA
+ 0.808ns 0.393497mA
+ 0.81ns 0.391776mA
+ 0.812ns 0.390063mA
+ 0.814ns 0.388358mA
+ 0.816ns 0.38666mA
+ 0.818ns 0.384969mA
+ 0.82ns 0.383286mA
+ 0.822ns 0.38161mA
+ 0.824ns 0.379941mA
+ 0.826ns 0.37828mA
+ 0.828ns 0.376626mA
+ 0.83ns 0.374979mA
+ 0.832ns 0.373339mA
+ 0.834ns 0.371707mA
+ 0.836ns 0.370082mA
+ 0.838ns 0.368463mA
+ 0.84ns 0.366852mA
+ 0.842ns 0.365248mA
+ 0.844ns 0.363651mA
+ 0.846ns 0.362061mA
+ 0.848ns 0.360478mA
+ 0.85ns 0.358902mA
+ 0.852ns 0.357332mA
+ 0.854ns 0.35577mA
+ 0.856ns 0.354214mA
+ 0.858ns 0.352665mA
+ 0.86ns 0.351123mA
+ 0.862ns 0.349588mA
+ 0.864ns 0.348059mA
+ 0.866ns 0.346538mA
+ 0.868ns 0.345022mA
+ 0.87ns 0.343514mA
+ 0.872ns 0.342012mA
+ 0.874ns 0.340516mA
+ 0.876ns 0.339027mA
+ 0.878ns 0.337545mA
+ 0.88ns 0.336069mA
+ 0.882ns 0.334599mA
+ 0.884ns 0.333136mA
+ 0.886ns 0.331679mA
+ 0.888ns 0.330229mA
+ 0.89ns 0.328785mA
+ 0.892ns 0.327347mA
+ 0.894ns 0.325916mA
+ 0.896ns 0.324491mA
+ 0.898ns 0.323072mA
+ 0.9ns 0.321659mA
+ 0.902ns 0.320253mA
+ 0.904ns 0.318852mA
+ 0.906ns 0.317458mA
+ 0.908ns 0.31607mA
+ 0.91ns 0.314688mA
+ 0.912ns 0.313312mA
+ 0.914ns 0.311942mA
+ 0.916ns 0.310578mA
+ 0.918ns 0.30922mA
+ 0.92ns 0.307868mA
+ 0.922ns 0.306521mA
+ 0.924ns 0.305181mA
+ 0.926ns 0.303847mA
+ 0.928ns 0.302518mA
+ 0.93ns 0.301195mA
+ 0.932ns 0.299878mA
+ 0.934ns 0.298567mA
+ 0.936ns 0.297261mA
+ 0.938ns 0.295961mA
+ 0.94ns 0.294667mA
+ 0.942ns 0.293379mA
+ 0.944ns 0.292096mA
+ 0.946ns 0.290818mA
+ 0.948ns 0.289547mA
+ 0.95ns 0.288281mA
+ 0.952ns 0.28702mA
+ 0.954ns 0.285765mA
+ 0.956ns 0.284515mA
+ 0.958ns 0.283271mA
+ 0.96ns 0.282032mA
+ 0.962ns 0.280799mA
+ 0.964ns 0.279571mA
+ 0.966ns 0.278349mA
+ 0.968ns 0.277132mA
+ 0.97ns 0.27592mA
+ 0.972ns 0.274713mA
+ 0.974ns 0.273512mA
+ 0.976ns 0.272316mA
+ 0.978ns 0.271125mA
+ 0.98ns 0.269939mA
+ 0.982ns 0.268759mA
+ 0.984ns 0.267584mA
+ 0.986ns 0.266414mA
+ 0.988ns 0.265249mA
+ 0.99ns 0.264089mA
+ 0.992ns 0.262934mA
+ 0.994ns 0.261784mA
+ 0.996ns 0.260639mA
+ 0.998ns 0.2595mA
+ 1ns 0.258365mA
+ 1.002ns 0.257235mA
+ 1.004ns 0.25611mA
+ 1.006ns 0.25499mA
+ 1.008ns 0.253875mA
+ 1.01ns 0.252765mA
+ 1.012ns 0.25166mA
+ 1.014ns 0.250559mA
+ 1.016ns 0.249463mA
+ 1.018ns 0.248373mA
+ 1.02ns 0.247286mA
+ 1.022ns 0.246205mA
+ 1.024ns 0.245128mA
+ 1.026ns 0.244056mA
+ 1.028ns 0.242989mA
+ 1.03ns 0.241927mA
+ 1.032ns 0.240869mA
+ 1.034ns 0.239815mA
+ 1.036ns 0.238767mA
+ 1.038ns 0.237722mA
+ 1.04ns 0.236683mA
+ 1.042ns 0mA
I120 198 0 PWL 0 0
+ 3.128ns 0mA
+ 3.13ns 0.000820597mA
+ 3.132ns 0.00241238mA
+ 3.134ns 0.00400435mA
+ 3.136ns 0.00559632mA
+ 3.138ns 0.00718811mA
+ 3.14ns 0.00878008mA
+ 3.142ns 0.0103719mA
+ 3.144ns 0.0119638mA
+ 3.146ns 0.0135558mA
+ 3.148ns 0.0151476mA
+ 3.15ns 0.0167396mA
+ 3.152ns 0.0183313mA
+ 3.154ns 0.0199233mA
+ 3.156ns 0.019602mA
+ 3.158ns 0.0191889mA
+ 3.16ns 0.0187844mA
+ 3.162ns 0.0183884mA
+ 3.164ns 0.0180008mA
+ 3.166ns 0.0176213mA
+ 3.168ns 0.0172499mA
+ 3.17ns 0.0168863mA
+ 3.172ns 0.0165303mA
+ 3.174ns 0.0161819mA
+ 3.176ns 0.0158408mA
+ 3.178ns 0.0155069mA
+ 3.18ns 0.01518mA
+ 3.182ns 0.0148599mA
+ 3.184ns 0.0145467mA
+ 3.186ns 0.0142401mA
+ 3.188ns 0.0139399mA
+ 3.19ns 0.013646mA
+ 3.192ns 0.0133583mA
+ 3.194ns 0.0130767mA
+ 3.196ns 0.0128011mA
+ 3.198ns 0.0125312mA
+ 3.2ns 0.012267mA
+ 3.202ns 0.0120084mA
+ 3.204ns 0.0117553mA
+ 3.206ns 0.0115075mA
+ 3.208ns 0.0112649mA
+ 3.21ns 0.0110274mA
+ 3.212ns 0.0107949mA
+ 3.214ns 0.0105673mA
+ 3.216ns 0.0103445mA
+ 3.218ns 0.0101265mA
+ 3.22ns 0.00991298mA
+ 3.222ns 0.00970398mA
+ 3.224ns 0.00949941mA
+ 3.226ns 0.00929913mA
+ 3.228ns 0.00910307mA
+ 3.23ns 0.00891117mA
+ 3.232ns 0mA
I121 199 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00582691mA
+ 2.656ns 0.0160902mA
+ 2.658ns 0.0263522mA
+ 2.66ns 0.0366155mA
+ 2.662ns 0.0468775mA
+ 2.664ns 0.0571408mA
+ 2.666ns 0.0674041mA
+ 2.668ns 0.0776661mA
+ 2.67ns 0.0879294mA
+ 2.672ns 0.0981914mA
+ 2.674ns 0.108455mA
+ 2.676ns 0.118718mA
+ 2.678ns 0.12898mA
+ 2.68ns 0.125998mA
+ 2.682ns 0.11327mA
+ 2.684ns 0.101827mA
+ 2.686ns 0.0915391mA
+ 2.688ns 0.0822917mA
+ 2.69ns 0.0739774mA
+ 2.692ns 0.0665028mA
+ 2.694ns 0.0597841mA
+ 2.696ns 0.0537434mA
+ 2.698ns 0.0483135mA
+ 2.7ns 0.0434315mA
+ 2.702ns 0.0390427mA
+ 2.704ns 0.0350978mA
+ 2.706ns 0mA
I122 202 0 PWL 0 0
+ 7.754ns 0mA
+ 7.756ns 0.00157751mA
+ 7.758ns 0.00320073mA
+ 7.76ns 0.00482433mA
+ 7.762ns 0.00644755mA
+ 7.764ns 0.00807076mA
+ 7.766ns 0.00969436mA
+ 7.768ns 0.0113176mA
+ 7.77ns 0.0129408mA
+ 7.772ns 0.0145644mA
+ 7.774ns 0.0161876mA
+ 7.776ns 0.0178108mA
+ 7.778ns 0.019434mA
+ 7.78ns 0.0210576mA
+ 7.782ns 0.0226809mA
+ 7.784ns 0.0243041mA
+ 7.786ns 0.0259277mA
+ 7.788ns 0.0275509mA
+ 7.79ns 0.0291741mA
+ 7.792ns 0.0307977mA
+ 7.794ns 0.0324209mA
+ 7.796ns 0.0340441mA
+ 7.798ns 0.0356673mA
+ 7.8ns 0.0372909mA
+ 7.802ns 0.0389142mA
+ 7.804ns 0.0405374mA
+ 7.806ns 0.042161mA
+ 7.808ns 0.0437842mA
+ 7.81ns 0.0454074mA
+ 7.812ns 0.047031mA
+ 7.814ns 0.0486542mA
+ 7.816ns 0.0502774mA
+ 7.818ns 0.051901mA
+ 7.82ns 0.0535243mA
+ 7.822ns 0.0524586mA
+ 7.824ns 0.0503179mA
+ 7.826ns 0.0482641mA
+ 7.828ns 0.0462945mA
+ 7.83ns 0.0444053mA
+ 7.832ns 0.0425927mA
+ 7.834ns 0.0408546mA
+ 7.836ns 0.0391873mA
+ 7.838ns 0.0375877mA
+ 7.84ns 0.0360537mA
+ 7.842ns 0.0345823mA
+ 7.844ns 0.033171mA
+ 7.846ns 0.0318169mA
+ 7.848ns 0.0305184mA
+ 7.85ns 0.0292728mA
+ 7.852ns 0.0280779mA
+ 7.854ns 0.0269319mA
+ 7.856ns 0.0258327mA
+ 7.858ns 0.0247781mA
+ 7.86ns 0.0237668mA
+ 7.862ns 0.0227968mA
+ 7.864ns 0.0218661mA
+ 7.866ns 0.0209736mA
+ 7.868ns 0.0201175mA
+ 7.87ns 0.0192964mA
+ 7.872ns 0.0185086mA
+ 7.874ns 0.0177531mA
+ 7.876ns 0.0170285mA
+ 7.878ns 0.0163333mA
+ 7.88ns 0.0156666mA
+ 7.882ns 0.0150271mA
+ 7.884ns 0.0144135mA
+ 7.886ns 0.0138252mA
+ 7.888ns 0mA
I123 209 0 PWL 0 0
+ 5.198ns 0mA
+ 5.2ns 0.000538859mA
+ 5.202ns 0.00542215mA
+ 5.204ns 0.0103054mA
+ 5.206ns 0.0151887mA
+ 5.208ns 0.0200732mA
+ 5.21ns 0.0249565mA
+ 5.212ns 0.0298398mA
+ 5.214ns 0.0347242mA
+ 5.216ns 0.0396075mA
+ 5.218ns 0.0444908mA
+ 5.22ns 0.0493753mA
+ 5.222ns 0.0542586mA
+ 5.224ns 0.0591419mA
+ 5.226ns 0.0640252mA
+ 5.228ns 0.0689096mA
+ 5.23ns 0.0737929mA
+ 5.232ns 0.0786762mA
+ 5.234ns 0.0835607mA
+ 5.236ns 0.088444mA
+ 5.238ns 0.0933273mA
+ 5.24ns 0.0982117mA
+ 5.242ns 0.103095mA
+ 5.244ns 0.107978mA
+ 5.246ns 0.112863mA
+ 5.248ns 0.117746mA
+ 5.25ns 0.122629mA
+ 5.252ns 0.127513mA
+ 5.254ns 0.126909mA
+ 5.256ns 0.124012mA
+ 5.258ns 0.121181mA
+ 5.26ns 0.118415mA
+ 5.262ns 0.115712mA
+ 5.264ns 0.113071mA
+ 5.266ns 0.110489mA
+ 5.268ns 0.107967mA
+ 5.27ns 0.105503mA
+ 5.272ns 0.103095mA
+ 5.274ns 0.100741mA
+ 5.276ns 0.0984412mA
+ 5.278ns 0.0961942mA
+ 5.28ns 0.0939979mA
+ 5.282ns 0.0918522mA
+ 5.284ns 0.0897555mA
+ 5.286ns 0.0877062mA
+ 5.288ns 0.0857041mA
+ 5.29ns 0.0837477mA
+ 5.292ns 0.0818356mA
+ 5.294ns 0.0799675mA
+ 5.296ns 0.078142mA
+ 5.298ns 0.0763582mA
+ 5.3ns 0.0746147mA
+ 5.302ns 0.0729114mA
+ 5.304ns 0.071247mA
+ 5.306ns 0.0696202mA
+ 5.308ns 0.0680308mA
+ 5.31ns 0.0664778mA
+ 5.312ns 0.0649599mA
+ 5.314ns 0.0634769mA
+ 5.316ns 0.0620278mA
+ 5.318ns 0.0606118mA
+ 5.32ns 0.0592277mA
+ 5.322ns 0.0578756mA
+ 5.324ns 0.0565544mA
+ 5.326ns 0.0552629mA
+ 5.328ns 0.0540013mA
+ 5.33ns 0.0527685mA
+ 5.332ns 0.0515635mA
+ 5.334ns 0.0503863mA
+ 5.336ns 0.049236mA
+ 5.338ns 0.0481117mA
+ 5.34ns 0mA
I124 213 0 PWL 0 0
+ 0.248ns 0mA
+ 0.25ns 0.00459233mA
+ 0.252ns 0.00957219mA
+ 0.254ns 0.014552mA
+ 0.256ns 0.0195319mA
+ 0.258ns 0.0245117mA
+ 0.26ns 0.0294916mA
+ 0.262ns 0.0344714mA
+ 0.264ns 0.0394512mA
+ 0.266ns 0.0444311mA
+ 0.268ns 0.0494109mA
+ 0.27ns 0.0543908mA
+ 0.272ns 0.0593706mA
+ 0.274ns 0.0643505mA
+ 0.276ns 0.0693303mA
+ 0.278ns 0.0743102mA
+ 0.28ns 0.07929mA
+ 0.282ns 0.0842698mA
+ 0.284ns 0.0892497mA
+ 0.286ns 0.0942295mA
+ 0.288ns 0.0992094mA
+ 0.29ns 0.0965631mA
+ 0.292ns 0.0901803mA
+ 0.294ns 0.0842194mA
+ 0.296ns 0.0786523mA
+ 0.298ns 0.0734532mA
+ 0.3ns 0.0685977mA
+ 0.302ns 0.064063mA
+ 0.304ns 0.0598281mA
+ 0.306ns 0.055873mA
+ 0.308ns 0.0521793mA
+ 0.31ns 0.0487298mA
+ 0.312ns 0.0455083mA
+ 0.314ns 0.0424997mA
+ 0.316ns 0.0396899mA
+ 0.318ns 0.0370659mA
+ 0.32ns 0.0346153mA
+ 0.322ns 0.0323267mA
+ 0.324ns 0.0301894mA
+ 0.326ns 0.0281933mA
+ 0.328ns 0.0263292mA
+ 0.33ns 0mA
I125 217 0 PWL 0 0
+ 2.868ns 0mA
+ 2.87ns 0.00793966mA
+ 2.872ns 0.0269056mA
+ 2.874ns 0.0458739mA
+ 2.876ns 0.0648399mA
+ 2.878ns 0.0838081mA
+ 2.88ns 0.0875532mA
+ 2.882ns 0.0848501mA
+ 2.884ns 0.0822301mA
+ 2.886ns 0.0796909mA
+ 2.888ns 0.0772305mA
+ 2.89ns 0.0748457mA
+ 2.892ns 0.0725348mA
+ 2.894ns 0.0702949mA
+ 2.896ns 0.0681242mA
+ 2.898ns 0.0660208mA
+ 2.9ns 0.0639821mA
+ 2.902ns 0.0620065mA
+ 2.904ns 0.0600917mA
+ 2.906ns 0.058236mA
+ 2.908ns 0.0564379mA
+ 2.91ns 0.054695mA
+ 2.912ns 0.0530061mA
+ 2.914ns 0.0513692mA
+ 2.916ns 0.0497828mA
+ 2.918ns 0.0482456mA
+ 2.92ns 0.0467556mA
+ 2.922ns 0.0453119mA
+ 2.924ns 0.0439125mA
+ 2.926ns 0.0425564mA
+ 2.928ns 0mA
I126 221 0 PWL 0 0
+ 5.348ns 0mA
+ 5.35ns 0.00295298mA
+ 5.352ns 0.00727059mA
+ 5.354ns 0.0115872mA
+ 5.356ns 0.0159037mA
+ 5.358ns 0.0202214mA
+ 5.36ns 0.0245379mA
+ 5.362ns 0.0288545mA
+ 5.364ns 0.0331711mA
+ 5.366ns 0.0374887mA
+ 5.368ns 0.0418053mA
+ 5.37ns 0.0461219mA
+ 5.372ns 0.0504395mA
+ 5.374ns 0.054756mA
+ 5.376ns 0.0590726mA
+ 5.378ns 0.0633902mA
+ 5.38ns 0.0677068mA
+ 5.382ns 0.0720234mA
+ 5.384ns 0.076341mA
+ 5.386ns 0.0806576mA
+ 5.388ns 0.0849742mA
+ 5.39ns 0.0892907mA
+ 5.392ns 0.0936083mA
+ 5.394ns 0.0979249mA
+ 5.396ns 0.102242mA
+ 5.398ns 0.106559mA
+ 5.4ns 0.110876mA
+ 5.402ns 0.115192mA
+ 5.404ns 0.11951mA
+ 5.406ns 0.123826mA
+ 5.408ns 0.128143mA
+ 5.41ns 0.13246mA
+ 5.412ns 0.136777mA
+ 5.414ns 0.141094mA
+ 5.416ns 0.14541mA
+ 5.418ns 0.149728mA
+ 5.42ns 0.154045mA
+ 5.422ns 0.152543mA
+ 5.424ns 0.150757mA
+ 5.426ns 0.148993mA
+ 5.428ns 0.147248mA
+ 5.43ns 0.145524mA
+ 5.432ns 0.143821mA
+ 5.434ns 0.142137mA
+ 5.436ns 0.140473mA
+ 5.438ns 0.138829mA
+ 5.44ns 0.137203mA
+ 5.442ns 0.135597mA
+ 5.444ns 0.13401mA
+ 5.446ns 0.132441mA
+ 5.448ns 0.13089mA
+ 5.45ns 0.129358mA
+ 5.452ns 0.127844mA
+ 5.454ns 0.126347mA
+ 5.456ns 0.124868mA
+ 5.458ns 0.123406mA
+ 5.46ns 0.121961mA
+ 5.462ns 0.120533mA
+ 5.464ns 0.119122mA
+ 5.466ns 0.117728mA
+ 5.468ns 0.116349mA
+ 5.47ns 0.114987mA
+ 5.472ns 0.113641mA
+ 5.474ns 0.11231mA
+ 5.476ns 0.110996mA
+ 5.478ns 0.109696mA
+ 5.48ns 0.108412mA
+ 5.482ns 0.107143mA
+ 5.484ns 0.105888mA
+ 5.486ns 0.104648mA
+ 5.488ns 0.103423mA
+ 5.49ns 0.102212mA
+ 5.492ns 0.101016mA
+ 5.494ns 0.099833mA
+ 5.496ns 0.0986639mA
+ 5.498ns 0.0975089mA
+ 5.5ns 0.0963673mA
+ 5.502ns 0.0952391mA
+ 5.504ns 0.0941239mA
+ 5.506ns 0.0930219mA
+ 5.508ns 0.0919329mA
+ 5.51ns 0.0908563mA
+ 5.512ns 0.0897927mA
+ 5.514ns 0.0887414mA
+ 5.516ns 0.0877022mA
+ 5.518ns 0.0866755mA
+ 5.52ns 0.0856607mA
+ 5.522ns 0.0846578mA
+ 5.524ns 0.0836665mA
+ 5.526ns 0.0826869mA
+ 5.528ns 0.0817189mA
+ 5.53ns 0.0807619mA
+ 5.532ns 0.0798163mA
+ 5.534ns 0.0788819mA
+ 5.536ns 0.0779581mA
+ 5.538ns 0.0770454mA
+ 5.54ns 0.0761434mA
+ 5.542ns 0.0752517mA
+ 5.544ns 0.0743706mA
+ 5.546ns 0.0734999mA
+ 5.548ns 0.0726394mA
+ 5.55ns 0.0717887mA
+ 5.552ns 0.0709482mA
+ 5.554ns 0.0701175mA
+ 5.556ns 0.0692964mA
+ 5.558ns 0.0684851mA
+ 5.56ns 0.0676832mA
+ 5.562ns 0.0668906mA
+ 5.564ns 0.0661074mA
+ 5.566ns 0.0653334mA
+ 5.568ns 0.0645685mA
+ 5.57ns 0.0638123mA
+ 5.572ns 0.0630652mA
+ 5.574ns 0mA
I127 223 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00989241mA
+ 0.156ns 0.0207223mA
+ 0.158ns 0.0315523mA
+ 0.16ns 0.0423822mA
+ 0.162ns 0.0532121mA
+ 0.164ns 0.0640421mA
+ 0.166ns 0.0748721mA
+ 0.168ns 0.085702mA
+ 0.17ns 0.0965319mA
+ 0.172ns 0.107362mA
+ 0.174ns 0.0981519mA
+ 0.176ns 0.0855786mA
+ 0.178ns 0.0746157mA
+ 0.18ns 0.0650568mA
+ 0.182ns 0.0567222mA
+ 0.184ns 0.0494552mA
+ 0.186ns 0.043119mA
+ 0.188ns 0.0375944mA
+ 0.19ns 0.0327775mA
+ 0.192ns 0.0285777mA
+ 0.194ns 0mA
+ 5.152ns 0mA
+ 5.154ns 0.00989386mA
+ 5.156ns 0.020723mA
+ 5.158ns 0.0315522mA
+ 5.16ns 0.0423813mA
+ 5.162ns 0.0532131mA
+ 5.164ns 0.0640422mA
+ 5.166ns 0.0748714mA
+ 5.168ns 0.0857032mA
+ 5.17ns 0.0965323mA
+ 5.172ns 0.107361mA
+ 5.174ns 0.0981502mA
+ 5.176ns 0.085578mA
+ 5.178ns 0.0746159mA
+ 5.18ns 0.0650576mA
+ 5.182ns 0.0567217mA
+ 5.184ns 0.0494552mA
+ 5.186ns 0.0431194mA
+ 5.188ns 0.0375939mA
+ 5.19ns 0.0327774mA
+ 5.192ns 0.0285779mA
+ 5.194ns 0mA
I128 226 0 PWL 0 0
+ 0.316ns 0mA
+ 0.318ns 0.00155086mA
+ 0.32ns 0.00510237mA
+ 0.322ns 0.00865389mA
+ 0.324ns 0.0122054mA
+ 0.326ns 0.0157569mA
+ 0.328ns 0.0193084mA
+ 0.33ns 0.0228599mA
+ 0.332ns 0.0264114mA
+ 0.334ns 0.0299629mA
+ 0.336ns 0.0335144mA
+ 0.338ns 0.037066mA
+ 0.34ns 0.0406174mA
+ 0.342ns 0.0441689mA
+ 0.344ns 0.043959mA
+ 0.346ns 0.0395081mA
+ 0.348ns 0.0355078mA
+ 0.35ns 0.0319125mA
+ 0.352ns 0.0286811mA
+ 0.354ns 0.0257769mA
+ 0.356ns 0.0231667mA
+ 0.358ns 0.0208207mA
+ 0.36ns 0.0187122mA
+ 0.362ns 0.0168172mA
+ 0.364ns 0.0151141mA
+ 0.366ns 0.0135834mA
+ 0.368ns 0.0122077mA
+ 0.37ns 0mA
+ 7.958ns 0mA
+ 7.96ns 0.000486022mA
+ 7.962ns 0.00403727mA
+ 7.964ns 0.00758937mA
+ 7.966ns 0.0111406mA
+ 7.968ns 0.0146919mA
+ 7.97ns 0.018244mA
+ 7.972ns 0.0217952mA
+ 7.974ns 0.0253465mA
+ 7.976ns 0.0288986mA
+ 7.978ns 0.0324498mA
+ 7.98ns 0.0360011mA
+ 7.982ns 0.0395523mA
+ 7.984ns 0.0431044mA
+ 7.986ns 0.0453886mA
+ 7.988ns 0.0407934mA
+ 7.99ns 0.0366623mA
+ 7.992ns 0.0329504mA
+ 7.994ns 0.0296141mA
+ 7.996ns 0.026615mA
+ 7.998ns 0.0239201mA
+ 8ns 0.021498mA
+ 8.002ns 0.0193211mA
+ 8.004ns 0.0173646mA
+ 8.006ns 0.0156062mA
+ 8.008ns 0.0140251mA
+ 8.01ns 0.0126048mA
+ 8.012ns 0mA
I129 231 0 PWL 0 0
+ 8.878ns 0mA
+ 8.88ns 0.00217938mA
+ 8.882ns 0.005826mA
+ 8.884ns 0.00947261mA
+ 8.886ns 0.0131192mA
+ 8.888ns 0.0167676mA
+ 8.89ns 0.0204142mA
+ 8.892ns 0.0240608mA
+ 8.894ns 0.0277074mA
+ 8.896ns 0.031354mA
+ 8.898ns 0.0350007mA
+ 8.9ns 0.0386473mA
+ 8.902ns 0.0422956mA
+ 8.904ns 0.0459422mA
+ 8.906ns 0.0436269mA
+ 8.908ns 0.0391811mA
+ 8.91ns 0.0351882mA
+ 8.912ns 0.0316022mA
+ 8.914ns 0.02838mA
+ 8.916ns 0.0254877mA
+ 8.918ns 0.02289mA
+ 8.92ns 0.020557mA
+ 8.922ns 0.0184618mA
+ 8.924ns 0.0165801mA
+ 8.926ns 0.0148901mA
+ 8.928ns 0.0133716mA
+ 8.93ns 0.0120086mA
+ 8.932ns 0mA
I130 234 0 PWL 0 0
+ 5.24ns 0mA
+ 5.242ns 0.00343164mA
+ 5.244ns 0.00801061mA
+ 5.246ns 0.0125907mA
+ 5.248ns 0.0171696mA
+ 5.25ns 0.0217486mA
+ 5.252ns 0.0263276mA
+ 5.254ns 0.0309076mA
+ 5.256ns 0.0354866mA
+ 5.258ns 0.0400656mA
+ 5.26ns 0.0446457mA
+ 5.262ns 0.0492246mA
+ 5.264ns 0.0538036mA
+ 5.266ns 0.0545994mA
+ 5.268ns 0.0488241mA
+ 5.27ns 0.0436595mA
+ 5.272ns 0.0390411mA
+ 5.274ns 0.0349102mA
+ 5.276ns 0.0312172mA
+ 5.278ns 0.0279147mA
+ 5.28ns 0.0249609mA
+ 5.282ns 0.0223201mA
+ 5.284ns 0.0199587mA
+ 5.286ns 0.0178466mA
+ 5.288ns 0.0159583mA
+ 5.29ns 0.0142698mA
+ 5.292ns 0mA
I131 236 0 PWL 0 0
+ 3.156ns 0mA
+ 3.158ns 0.00156976mA
+ 3.16ns 0.00516252mA
+ 3.162ns 0.00875486mA
+ 3.164ns 0.0123476mA
+ 3.166ns 0.0159404mA
+ 3.168ns 0.0195327mA
+ 3.17ns 0.0231255mA
+ 3.172ns 0.0267182mA
+ 3.174ns 0.0303106mA
+ 3.176ns 0.0339033mA
+ 3.178ns 0.0374957mA
+ 3.18ns 0.0410884mA
+ 3.182ns 0.0408795mA
+ 3.184ns 0.0364151mA
+ 3.186ns 0.0324377mA
+ 3.188ns 0.028895mA
+ 3.19ns 0.0257388mA
+ 3.192ns 0.0229273mA
+ 3.194ns 0.0204231mA
+ 3.196ns 0.0181921mA
+ 3.198ns 0.016205mA
+ 3.2ns 0.0144347mA
+ 3.202ns 0.0128577mA
+ 3.204ns 0.0114532mA
+ 3.206ns 0mA
I132 241 0 PWL 0 0
+ 2.826ns 0mA
+ 2.828ns 0.000517101mA
+ 2.83ns 0.0024197mA
+ 2.832ns 0.00432252mA
+ 2.834ns 0.00622535mA
+ 2.836ns 0.00812794mA
+ 2.838ns 0.0100308mA
+ 2.84ns 0.0119336mA
+ 2.842ns 0.0138362mA
+ 2.844ns 0.015739mA
+ 2.846ns 0.0176416mA
+ 2.848ns 0.0195444mA
+ 2.85ns 0.0214473mA
+ 2.852ns 0.0233499mA
+ 2.854ns 0.0252527mA
+ 2.856ns 0.0271553mA
+ 2.858ns 0.0290581mA
+ 2.86ns 0.0309609mA
+ 2.862ns 0.0328635mA
+ 2.864ns 0.0347663mA
+ 2.866ns 0.0366689mA
+ 2.868ns 0.0385718mA
+ 2.87ns 0.0404746mA
+ 2.872ns 0.0419239mA
+ 2.874ns 0.0393827mA
+ 2.876ns 0.0369958mA
+ 2.878ns 0.0347533mA
+ 2.88ns 0.0326466mA
+ 2.882ns 0.0306679mA
+ 2.884ns 0.0288089mA
+ 2.886ns 0.0270625mA
+ 2.888ns 0.0254221mA
+ 2.89ns 0.023881mA
+ 2.892ns 0.0224335mA
+ 2.894ns 0.0210735mA
+ 2.896ns 0.0197959mA
+ 2.898ns 0.0185959mA
+ 2.9ns 0.0174685mA
+ 2.902ns 0.0164096mA
+ 2.904ns 0.0154147mA
+ 2.906ns 0.0144802mA
+ 2.908ns 0.0136023mA
+ 2.91ns 0.0127776mA
+ 2.912ns 0.012003mA
+ 2.914ns 0.0112752mA
+ 2.916ns 0.0105916mA
+ 2.918ns 0mA
I133 242 0 PWL 0 0
+ 0.246ns 0mA
+ 0.248ns 0.00103606mA
+ 0.25ns 0.0048112mA
+ 0.252ns 0.00858638mA
+ 0.254ns 0.0123615mA
+ 0.256ns 0.0161367mA
+ 0.258ns 0.0199119mA
+ 0.26ns 0.0236871mA
+ 0.262ns 0.0274622mA
+ 0.264ns 0.0312373mA
+ 0.266ns 0.0350125mA
+ 0.268ns 0.0387877mA
+ 0.27ns 0.0403309mA
+ 0.272ns 0.0355652mA
+ 0.274ns 0.0313625mA
+ 0.276ns 0.0276564mA
+ 0.278ns 0.024388mA
+ 0.28ns 0.0215059mA
+ 0.282ns 0.0189643mA
+ 0.284ns 0.016723mA
+ 0.286ns 0.0147465mA
+ 0.288ns 0.0130036mA
+ 0.29ns 0.0114666mA
+ 0.292ns 0mA
+ 5.944ns 0mA
+ 5.946ns 0.00197998mA
+ 5.948ns 0.00575487mA
+ 5.95ns 0.00953066mA
+ 5.952ns 0.0133055mA
+ 5.954ns 0.0170804mA
+ 5.956ns 0.0208562mA
+ 5.958ns 0.0246311mA
+ 5.96ns 0.028406mA
+ 5.962ns 0.0321809mA
+ 5.964ns 0.0359567mA
+ 5.966ns 0.0397316mA
+ 5.968ns 0.039083mA
+ 5.97ns 0.034464mA
+ 5.972ns 0.0303917mA
+ 5.974ns 0.0268005mA
+ 5.976ns 0.0236328mA
+ 5.978ns 0.0208401mA
+ 5.98ns 0.0183773mA
+ 5.982ns 0.0162055mA
+ 5.984ns 0.0142899mA
+ 5.986ns 0.012601mA
+ 5.988ns 0.0111117mA
+ 5.99ns 0mA
I134 243 0 PWL 0 0
+ 2.75ns 0mA
+ 2.752ns 0.00154808mA
+ 2.754ns 0.00598584mA
+ 2.756ns 0.0104241mA
+ 2.758ns 0.0148624mA
+ 2.76ns 0.0193002mA
+ 2.762ns 0.0237385mA
+ 2.764ns 0.0281762mA
+ 2.766ns 0.0326145mA
+ 2.768ns 0.0370528mA
+ 2.77ns 0.0414906mA
+ 2.772ns 0.0459289mA
+ 2.774ns 0.0441517mA
+ 2.776ns 0.0388088mA
+ 2.778ns 0.0341124mA
+ 2.78ns 0.0299846mA
+ 2.782ns 0.0263558mA
+ 2.784ns 0.0231665mA
+ 2.786ns 0.0203627mA
+ 2.788ns 0.0178981mA
+ 2.79ns 0.015732mA
+ 2.792ns 0.0138278mA
+ 2.794ns 0.0121541mA
+ 2.796ns 0mA
+ 8.878ns 0mA
+ 8.88ns 0.00154861mA
+ 8.882ns 0.00598637mA
+ 8.884ns 0.0104241mA
+ 8.886ns 0.0148619mA
+ 8.888ns 0.0193018mA
+ 8.89ns 0.0237395mA
+ 8.892ns 0.0281773mA
+ 8.894ns 0.0326151mA
+ 8.896ns 0.0370528mA
+ 8.898ns 0.0414906mA
+ 8.9ns 0.0459284mA
+ 8.902ns 0.0441496mA
+ 8.904ns 0.0388076mA
+ 8.906ns 0.0341119mA
+ 8.908ns 0.0299842mA
+ 8.91ns 0.0263558mA
+ 8.912ns 0.0231665mA
+ 8.914ns 0.0203617mA
+ 8.916ns 0.0178976mA
+ 8.918ns 0.0157316mA
+ 8.92ns 0.0138276mA
+ 8.922ns 0.0121541mA
+ 8.924ns 0mA
I135 244 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00428644mA
+ 0.156ns 0.0148901mA
+ 0.158ns 0.0254939mA
+ 0.16ns 0.0360976mA
+ 0.162ns 0.0467013mA
+ 0.164ns 0.057305mA
+ 0.166ns 0.0679088mA
+ 0.168ns 0.0785125mA
+ 0.17ns 0.0891162mA
+ 0.172ns 0.0997199mA
+ 0.174ns 0.110324mA
+ 0.176ns 0.120927mA
+ 0.178ns 0.131531mA
+ 0.18ns 0.124805mA
+ 0.182ns 0.111903mA
+ 0.184ns 0.100334mA
+ 0.186ns 0.0899608mA
+ 0.188ns 0.0806598mA
+ 0.19ns 0.0723203mA
+ 0.192ns 0.0648428mA
+ 0.194ns 0.0581383mA
+ 0.196ns 0.0521268mA
+ 0.198ns 0.0467368mA
+ 0.2ns 0.0419041mA
+ 0.202ns 0.0375709mA
+ 0.204ns 0.0336857mA
+ 0.206ns 0mA
I136 245 0 PWL 0 0
+ 8.01ns 0mA
+ 8.012ns 0.00603547mA
+ 8.014ns 0.0137048mA
+ 8.016ns 0.0213742mA
+ 8.018ns 0.0290436mA
+ 8.02ns 0.0367166mA
+ 8.022ns 0.044386mA
+ 8.024ns 0.0520554mA
+ 8.026ns 0.0597247mA
+ 8.028ns 0.0673941mA
+ 8.03ns 0.0750635mA
+ 8.032ns 0.0827328mA
+ 8.034ns 0.0904059mA
+ 8.036ns 0.0980752mA
+ 8.038ns 0.105745mA
+ 8.04ns 0.113414mA
+ 8.042ns 0.121083mA
+ 8.044ns 0.128753mA
+ 8.046ns 0.136422mA
+ 8.048ns 0.144095mA
+ 8.05ns 0.151764mA
+ 8.052ns 0.159434mA
+ 8.054ns 0.167103mA
+ 8.056ns 0.174773mA
+ 8.058ns 0.182442mA
+ 8.06ns 0.190115mA
+ 8.062ns 0.197784mA
+ 8.064ns 0.205454mA
+ 8.066ns 0.213123mA
+ 8.068ns 0.220792mA
+ 8.07ns 0.228462mA
+ 8.072ns 0.236131mA
+ 8.074ns 0.243804mA
+ 8.076ns 0.251474mA
+ 8.078ns 0.259143mA
+ 8.08ns 0.266812mA
+ 8.082ns 0.274482mA
+ 8.084ns 0.282151mA
+ 8.086ns 0.289824mA
+ 8.088ns 0.297493mA
+ 8.09ns 0.305163mA
+ 8.092ns 0.312832mA
+ 8.094ns 0.320502mA
+ 8.096ns 0.328171mA
+ 8.098ns 0.33584mA
+ 8.1ns 0.343513mA
+ 8.102ns 0.351183mA
+ 8.104ns 0.358852mA
+ 8.106ns 0.366521mA
+ 8.108ns 0.374191mA
+ 8.11ns 0.38186mA
+ 8.112ns 0.389533mA
+ 8.114ns 0.397203mA
+ 8.116ns 0.404872mA
+ 8.118ns 0.412541mA
+ 8.12ns 0.420211mA
+ 8.122ns 0.42788mA
+ 8.124ns 0.435549mA
+ 8.126ns 0.443223mA
+ 8.128ns 0.450892mA
+ 8.13ns 0.458561mA
+ 8.132ns 0.466231mA
+ 8.134ns 0.4739mA
+ 8.136ns 0.481569mA
+ 8.138ns 0.489239mA
+ 8.14ns 0.496912mA
+ 8.142ns 0.504581mA
+ 8.144ns 0.51225mA
+ 8.146ns 0.51992mA
+ 8.148ns 0.527589mA
+ 8.15ns 0.535259mA
+ 8.152ns 0.542932mA
+ 8.154ns 0.550601mA
+ 8.156ns 0.549699mA
+ 8.158ns 0.547297mA
+ 8.16ns 0.544905mA
+ 8.162ns 0.542524mA
+ 8.164ns 0.540154mA
+ 8.166ns 0.537792mA
+ 8.168ns 0.535442mA
+ 8.17ns 0.533102mA
+ 8.172ns 0.530773mA
+ 8.174ns 0.528453mA
+ 8.176ns 0.526144mA
+ 8.178ns 0.523844mA
+ 8.18ns 0.521555mA
+ 8.182ns 0.519276mA
+ 8.184ns 0.517007mA
+ 8.186ns 0.514748mA
+ 8.188ns 0.512498mA
+ 8.19ns 0.510259mA
+ 8.192ns 0.508028mA
+ 8.194ns 0.505808mA
+ 8.196ns 0.503598mA
+ 8.198ns 0.501397mA
+ 8.2ns 0.499206mA
+ 8.202ns 0.497025mA
+ 8.204ns 0.494852mA
+ 8.206ns 0.492689mA
+ 8.208ns 0.490536mA
+ 8.21ns 0.488393mA
+ 8.212ns 0.486259mA
+ 8.214ns 0.484134mA
+ 8.216ns 0.482018mA
+ 8.218ns 0.479911mA
+ 8.22ns 0.477814mA
+ 8.222ns 0.475726mA
+ 8.224ns 0.473647mA
+ 8.226ns 0.471577mA
+ 8.228ns 0.469516mA
+ 8.23ns 0.467465mA
+ 8.232ns 0.465421mA
+ 8.234ns 0.463387mA
+ 8.236ns 0.461362mA
+ 8.238ns 0.459346mA
+ 8.24ns 0.457339mA
+ 8.242ns 0.45534mA
+ 8.244ns 0.453349mA
+ 8.246ns 0.451368mA
+ 8.248ns 0.449396mA
+ 8.25ns 0.447432mA
+ 8.252ns 0.445477mA
+ 8.254ns 0.44353mA
+ 8.256ns 0.441592mA
+ 8.258ns 0.439661mA
+ 8.26ns 0.43774mA
+ 8.262ns 0.435827mA
+ 8.264ns 0.433923mA
+ 8.266ns 0.432026mA
+ 8.268ns 0.430138mA
+ 8.27ns 0.428258mA
+ 8.272ns 0.426386mA
+ 8.274ns 0.424523mA
+ 8.276ns 0.422668mA
+ 8.278ns 0.420821mA
+ 8.28ns 0.418982mA
+ 8.282ns 0.417151mA
+ 8.284ns 0.415327mA
+ 8.286ns 0.413512mA
+ 8.288ns 0.411705mA
+ 8.29ns 0.409906mA
+ 8.292ns 0.408115mA
+ 8.294ns 0.406331mA
+ 8.296ns 0.404555mA
+ 8.298ns 0.402787mA
+ 8.3ns 0.401027mA
+ 8.302ns 0.399274mA
+ 8.304ns 0.397529mA
+ 8.306ns 0.395792mA
+ 8.308ns 0.394062mA
+ 8.31ns 0.392339mA
+ 8.312ns 0.390625mA
+ 8.314ns 0.388918mA
+ 8.316ns 0.387218mA
+ 8.318ns 0.385526mA
+ 8.32ns 0.383841mA
+ 8.322ns 0.382164mA
+ 8.324ns 0.380493mA
+ 8.326ns 0.37883mA
+ 8.328ns 0.377175mA
+ 8.33ns 0.375526mA
+ 8.332ns 0.373885mA
+ 8.334ns 0.372251mA
+ 8.336ns 0.370624mA
+ 8.338ns 0.369004mA
+ 8.34ns 0.367392mA
+ 8.342ns 0.365786mA
+ 8.344ns 0.364188mA
+ 8.346ns 0.362596mA
+ 8.348ns 0.361011mA
+ 8.35ns 0.359433mA
+ 8.352ns 0.357862mA
+ 8.354ns 0.356298mA
+ 8.356ns 0.354741mA
+ 8.358ns 0.353191mA
+ 8.36ns 0.351647mA
+ 8.362ns 0.35011mA
+ 8.364ns 0.34858mA
+ 8.366ns 0.347057mA
+ 8.368ns 0.34554mA
+ 8.37ns 0.34403mA
+ 8.372ns 0.342526mA
+ 8.374ns 0.341029mA
+ 8.376ns 0.339538mA
+ 8.378ns 0.338054mA
+ 8.38ns 0.336577mA
+ 8.382ns 0.335106mA
+ 8.384ns 0.333642mA
+ 8.386ns 0.332184mA
+ 8.388ns 0.330731mA
+ 8.39ns 0.329286mA
+ 8.392ns 0.327847mA
+ 8.394ns 0.326414mA
+ 8.396ns 0.324987mA
+ 8.398ns 0.323567mA
+ 8.4ns 0.322153mA
+ 8.402ns 0.320744mA
+ 8.404ns 0.319343mA
+ 8.406ns 0.317947mA
+ 8.408ns 0.316558mA
+ 8.41ns 0.315174mA
+ 8.412ns 0.313797mA
+ 8.414ns 0.312425mA
+ 8.416ns 0.311059mA
+ 8.418ns 0.3097mA
+ 8.42ns 0.308346mA
+ 8.422ns 0.306999mA
+ 8.424ns 0.305657mA
+ 8.426ns 0.304321mA
+ 8.428ns 0.302991mA
+ 8.43ns 0.301667mA
+ 8.432ns 0.300348mA
+ 8.434ns 0.299036mA
+ 8.436ns 0.297729mA
+ 8.438ns 0.296427mA
+ 8.44ns 0.295132mA
+ 8.442ns 0.293842mA
+ 8.444ns 0.292557mA
+ 8.446ns 0.291279mA
+ 8.448ns 0.290006mA
+ 8.45ns 0.288738mA
+ 8.452ns 0.287476mA
+ 8.454ns 0.286219mA
+ 8.456ns 0.284969mA
+ 8.458ns 0.283723mA
+ 8.46ns 0.282483mA
+ 8.462ns 0.281249mA
+ 8.464ns 0.280019mA
+ 8.466ns 0.278796mA
+ 8.468ns 0.277577mA
+ 8.47ns 0.276363mA
+ 8.472ns 0.275156mA
+ 8.474ns 0.273953mA
+ 8.476ns 0.272756mA
+ 8.478ns 0.271564mA
+ 8.48ns 0.270376mA
+ 8.482ns 0.269195mA
+ 8.484ns 0.268018mA
+ 8.486ns 0.266847mA
+ 8.488ns 0.26568mA
+ 8.49ns 0.264519mA
+ 8.492ns 0.263363mA
+ 8.494ns 0.262212mA
+ 8.496ns 0.261066mA
+ 8.498ns 0.259925mA
+ 8.5ns 0.258789mA
+ 8.502ns 0.257658mA
+ 8.504ns 0.256532mA
+ 8.506ns 0.25541mA
+ 8.508ns 0.254294mA
+ 8.51ns 0.253182mA
+ 8.512ns 0.252076mA
+ 8.514ns 0.250974mA
+ 8.516ns 0.249877mA
+ 8.518ns 0.248785mA
+ 8.52ns 0.247697mA
+ 8.522ns 0.246615mA
+ 8.524ns 0.245537mA
+ 8.526ns 0.244464mA
+ 8.528ns 0.243395mA
+ 8.53ns 0.242331mA
+ 8.532ns 0.241272mA
+ 8.534ns 0.240217mA
+ 8.536ns 0.239167mA
+ 8.538ns 0.238122mA
+ 8.54ns 0.237081mA
+ 8.542ns 0.236045mA
+ 8.544ns 0mA
I137 249 0 PWL 0 0
+ 0.374ns 0mA
+ 0.376ns 0.00357767mA
+ 0.378ns 0.00742454mA
+ 0.38ns 0.0112714mA
+ 0.382ns 0.0151183mA
+ 0.384ns 0.0189651mA
+ 0.386ns 0.0228119mA
+ 0.388ns 0.0266588mA
+ 0.39ns 0.0305056mA
+ 0.392ns 0.0343525mA
+ 0.394ns 0.0381994mA
+ 0.396ns 0.0420462mA
+ 0.398ns 0.0458931mA
+ 0.4ns 0.0497399mA
+ 0.402ns 0.0535868mA
+ 0.404ns 0.0574336mA
+ 0.406ns 0.0612805mA
+ 0.408ns 0.0651273mA
+ 0.41ns 0.0689742mA
+ 0.412ns 0.0728211mA
+ 0.414ns 0.0766679mA
+ 0.416ns 0.0805147mA
+ 0.418ns 0.0843616mA
+ 0.42ns 0.0882085mA
+ 0.422ns 0.0920553mA
+ 0.424ns 0.0959022mA
+ 0.426ns 0.099749mA
+ 0.428ns 0.103596mA
+ 0.43ns 0.107443mA
+ 0.432ns 0.11129mA
+ 0.434ns 0.115136mA
+ 0.436ns 0.118983mA
+ 0.438ns 0.12283mA
+ 0.44ns 0.126677mA
+ 0.442ns 0.130524mA
+ 0.444ns 0.134371mA
+ 0.446ns 0.138218mA
+ 0.448ns 0.142064mA
+ 0.45ns 0.145911mA
+ 0.452ns 0.149758mA
+ 0.454ns 0.153605mA
+ 0.456ns 0.157452mA
+ 0.458ns 0.161299mA
+ 0.46ns 0.165146mA
+ 0.462ns 0.168992mA
+ 0.464ns 0.172839mA
+ 0.466ns 0.176686mA
+ 0.468ns 0.180533mA
+ 0.47ns 0.18438mA
+ 0.472ns 0.188227mA
+ 0.474ns 0.192074mA
+ 0.476ns 0.19592mA
+ 0.478ns 0.199767mA
+ 0.48ns 0.203614mA
+ 0.482ns 0.207461mA
+ 0.484ns 0.211308mA
+ 0.486ns 0.215155mA
+ 0.488ns 0.219002mA
+ 0.49ns 0.222848mA
+ 0.492ns 0.226695mA
+ 0.494ns 0.230542mA
+ 0.496ns 0.234389mA
+ 0.498ns 0.238236mA
+ 0.5ns 0.242083mA
+ 0.502ns 0.245929mA
+ 0.504ns 0.249776mA
+ 0.506ns 0.253623mA
+ 0.508ns 0.25747mA
+ 0.51ns 0.261317mA
+ 0.512ns 0.265164mA
+ 0.514ns 0.269011mA
+ 0.516ns 0.272857mA
+ 0.518ns 0.276704mA
+ 0.52ns 0.280551mA
+ 0.522ns 0.284398mA
+ 0.524ns 0.288245mA
+ 0.526ns 0.292092mA
+ 0.528ns 0.295938mA
+ 0.53ns 0.299785mA
+ 0.532ns 0.303632mA
+ 0.534ns 0.307479mA
+ 0.536ns 0.311326mA
+ 0.538ns 0.315173mA
+ 0.54ns 0.31902mA
+ 0.542ns 0.322867mA
+ 0.544ns 0.326713mA
+ 0.546ns 0.33056mA
+ 0.548ns 0.334407mA
+ 0.55ns 0.338254mA
+ 0.552ns 0.342101mA
+ 0.554ns 0.345948mA
+ 0.556ns 0.349795mA
+ 0.558ns 0.353641mA
+ 0.56ns 0.357488mA
+ 0.562ns 0.361335mA
+ 0.564ns 0.365182mA
+ 0.566ns 0.369029mA
+ 0.568ns 0.372876mA
+ 0.57ns 0.376723mA
+ 0.572ns 0.380569mA
+ 0.574ns 0.384416mA
+ 0.576ns 0.388263mA
+ 0.578ns 0.39211mA
+ 0.58ns 0.395957mA
+ 0.582ns 0.399804mA
+ 0.584ns 0.40365mA
+ 0.586ns 0.407497mA
+ 0.588ns 0.411344mA
+ 0.59ns 0.415191mA
+ 0.592ns 0.419038mA
+ 0.594ns 0.422885mA
+ 0.596ns 0.426732mA
+ 0.598ns 0.430578mA
+ 0.6ns 0.433351mA
+ 0.602ns 0.43183mA
+ 0.604ns 0.430314mA
+ 0.606ns 0.428803mA
+ 0.608ns 0.427298mA
+ 0.61ns 0.425798mA
+ 0.612ns 0.424303mA
+ 0.614ns 0.422813mA
+ 0.616ns 0.421329mA
+ 0.618ns 0.41985mA
+ 0.62ns 0.418376mA
+ 0.622ns 0.416907mA
+ 0.624ns 0.415444mA
+ 0.626ns 0.413985mA
+ 0.628ns 0.412532mA
+ 0.63ns 0.411084mA
+ 0.632ns 0.409641mA
+ 0.634ns 0.408203mA
+ 0.636ns 0.40677mA
+ 0.638ns 0.405342mA
+ 0.64ns 0.403919mA
+ 0.642ns 0.402501mA
+ 0.644ns 0.401088mA
+ 0.646ns 0.39968mA
+ 0.648ns 0.398277mA
+ 0.65ns 0.396879mA
+ 0.652ns 0.395485mA
+ 0.654ns 0.394097mA
+ 0.656ns 0.392713mA
+ 0.658ns 0.391335mA
+ 0.66ns 0.389961mA
+ 0.662ns 0.388592mA
+ 0.664ns 0.387228mA
+ 0.666ns 0.385868mA
+ 0.668ns 0.384514mA
+ 0.67ns 0.383164mA
+ 0.672ns 0.381819mA
+ 0.674ns 0.380478mA
+ 0.676ns 0.379143mA
+ 0.678ns 0.377812mA
+ 0.68ns 0.376485mA
+ 0.682ns 0.375164mA
+ 0.684ns 0.373847mA
+ 0.686ns 0.372534mA
+ 0.688ns 0.371226mA
+ 0.69ns 0.369923mA
+ 0.692ns 0.368624mA
+ 0.694ns 0.36733mA
+ 0.696ns 0.366041mA
+ 0.698ns 0.364756mA
+ 0.7ns 0.363475mA
+ 0.702ns 0.362199mA
+ 0.704ns 0.360928mA
+ 0.706ns 0.359661mA
+ 0.708ns 0.358398mA
+ 0.71ns 0.35714mA
+ 0.712ns 0.355886mA
+ 0.714ns 0.354637mA
+ 0.716ns 0.353392mA
+ 0.718ns 0.352151mA
+ 0.72ns 0.350915mA
+ 0.722ns 0.349683mA
+ 0.724ns 0.348455mA
+ 0.726ns 0.347232mA
+ 0.728ns 0.346013mA
+ 0.73ns 0.344798mA
+ 0.732ns 0.343588mA
+ 0.734ns 0.342381mA
+ 0.736ns 0.341179mA
+ 0.738ns 0.339982mA
+ 0.74ns 0.338788mA
+ 0.742ns 0.337599mA
+ 0.744ns 0.336413mA
+ 0.746ns 0.335232mA
+ 0.748ns 0.334055mA
+ 0.75ns 0.332883mA
+ 0.752ns 0.331714mA
+ 0.754ns 0.33055mA
+ 0.756ns 0.329389mA
+ 0.758ns 0.328233mA
+ 0.76ns 0.32708mA
+ 0.762ns 0.325932mA
+ 0.764ns 0.324788mA
+ 0.766ns 0.323647mA
+ 0.768ns 0.322511mA
+ 0.77ns 0.321379mA
+ 0.772ns 0.320251mA
+ 0.774ns 0.319126mA
+ 0.776ns 0.318006mA
+ 0.778ns 0.31689mA
+ 0.78ns 0.315777mA
+ 0.782ns 0.314668mA
+ 0.784ns 0.313564mA
+ 0.786ns 0.312463mA
+ 0.788ns 0.311366mA
+ 0.79ns 0.310273mA
+ 0.792ns 0.309184mA
+ 0.794ns 0.308098mA
+ 0.796ns 0.307016mA
+ 0.798ns 0.305939mA
+ 0.8ns 0.304864mA
+ 0.802ns 0.303794mA
+ 0.804ns 0.302728mA
+ 0.806ns 0.301665mA
+ 0.808ns 0.300606mA
+ 0.81ns 0.29955mA
+ 0.812ns 0.298499mA
+ 0.814ns 0.297451mA
+ 0.816ns 0.296406mA
+ 0.818ns 0.295366mA
+ 0.82ns 0.294329mA
+ 0.822ns 0.293295mA
+ 0.824ns 0.292266mA
+ 0.826ns 0.29124mA
+ 0.828ns 0.290217mA
+ 0.83ns 0.289198mA
+ 0.832ns 0.288183mA
+ 0.834ns 0.287171mA
+ 0.836ns 0.286163mA
+ 0.838ns 0.285158mA
+ 0.84ns 0.284157mA
+ 0.842ns 0.28316mA
+ 0.844ns 0.282165mA
+ 0.846ns 0.281175mA
+ 0.848ns 0.280188mA
+ 0.85ns 0.279204mA
+ 0.852ns 0.278224mA
+ 0.854ns 0.277247mA
+ 0.856ns 0.276273mA
+ 0.858ns 0.275304mA
+ 0.86ns 0.274337mA
+ 0.862ns 0.273374mA
+ 0.864ns 0.272414mA
+ 0.866ns 0.271458mA
+ 0.868ns 0.270505mA
+ 0.87ns 0.269555mA
+ 0.872ns 0.268608mA
+ 0.874ns 0.267665mA
+ 0.876ns 0.266726mA
+ 0.878ns 0.265789mA
+ 0.88ns 0.264856mA
+ 0.882ns 0.263926mA
+ 0.884ns 0.263mA
+ 0.886ns 0.262076mA
+ 0.888ns 0.261156mA
+ 0.89ns 0.260239mA
+ 0.892ns 0.259326mA
+ 0.894ns 0.258415mA
+ 0.896ns 0.257508mA
+ 0.898ns 0.256604mA
+ 0.9ns 0.255703mA
+ 0.902ns 0.254805mA
+ 0.904ns 0.25391mA
+ 0.906ns 0.253019mA
+ 0.908ns 0.252131mA
+ 0.91ns 0.251245mA
+ 0.912ns 0.250363mA
+ 0.914ns 0.249484mA
+ 0.916ns 0.248608mA
+ 0.918ns 0.247735mA
+ 0.92ns 0.246866mA
+ 0.922ns 0.245999mA
+ 0.924ns 0.245135mA
+ 0.926ns 0.244275mA
+ 0.928ns 0.243417mA
+ 0.93ns 0.242562mA
+ 0.932ns 0.241711mA
+ 0.934ns 0.240862mA
+ 0.936ns 0.240016mA
+ 0.938ns 0.239174mA
+ 0.94ns 0.238334mA
+ 0.942ns 0.237497mA
+ 0.944ns 0.236663mA
+ 0.946ns 0.235832mA
+ 0.948ns 0.235004mA
+ 0.95ns 0.234179mA
+ 0.952ns 0.233357mA
+ 0.954ns 0.232538mA
+ 0.956ns 0.231721mA
+ 0.958ns 0.230908mA
+ 0.96ns 0.230097mA
+ 0.962ns 0.229289mA
+ 0.964ns 0.228484mA
+ 0.966ns 0.227682mA
+ 0.968ns 0.226883mA
+ 0.97ns 0.226086mA
+ 0.972ns 0.225292mA
+ 0.974ns 0.224501mA
+ 0.976ns 0.223713mA
+ 0.978ns 0.222927mA
+ 0.98ns 0.222145mA
+ 0.982ns 0.221365mA
+ 0.984ns 0.220588mA
+ 0.986ns 0.219813mA
+ 0.988ns 0.219041mA
+ 0.99ns 0.218272mA
+ 0.992ns 0.217506mA
+ 0.994ns 0.216742mA
+ 0.996ns 0.215981mA
+ 0.998ns 0.215223mA
+ 1ns 0.214467mA
+ 1.002ns 0.213714mA
+ 1.004ns 0.212964mA
+ 1.006ns 0.212216mA
+ 1.008ns 0.211471mA
+ 1.01ns 0.210728mA
+ 1.012ns 0.209989mA
+ 1.014ns 0.209251mA
+ 1.016ns 0.208517mA
+ 1.018ns 0.207784mA
+ 1.02ns 0.207055mA
+ 1.022ns 0.206328mA
+ 1.024ns 0.205603mA
+ 1.026ns 0.204882mA
+ 1.028ns 0.204162mA
+ 1.03ns 0.203445mA
+ 1.032ns 0.202731mA
+ 1.034ns 0.202019mA
+ 1.036ns 0.20131mA
+ 1.038ns 0.200603mA
+ 1.04ns 0.199899mA
+ 1.042ns 0.199197mA
+ 1.044ns 0.198497mA
+ 1.046ns 0.197801mA
+ 1.048ns 0.197106mA
+ 1.05ns 0.196414mA
+ 1.052ns 0.195724mA
+ 1.054ns 0.195037mA
+ 1.056ns 0.194352mA
+ 1.058ns 0.19367mA
+ 1.06ns 0.19299mA
+ 1.062ns 0.192312mA
+ 1.064ns 0.191637mA
+ 1.066ns 0.190964mA
+ 1.068ns 0.190294mA
+ 1.07ns 0.189625mA
+ 1.072ns 0.18896mA
+ 1.074ns 0.188296mA
+ 1.076ns 0.187635mA
+ 1.078ns 0.186976mA
+ 1.08ns 0.18632mA
+ 1.082ns 0.185665mA
+ 1.084ns 0.185014mA
+ 1.086ns 0.184364mA
+ 1.088ns 0.183717mA
+ 1.09ns 0.183072mA
+ 1.092ns 0.182429mA
+ 1.094ns 0.181788mA
+ 1.096ns 0.18115mA
+ 1.098ns 0.180514mA
+ 1.1ns 0.17988mA
+ 1.102ns 0.179248mA
+ 1.104ns 0.178619mA
+ 1.106ns 0.177992mA
+ 1.108ns 0mA
+ 5.374ns 0mA
+ 5.376ns 0.00357773mA
+ 5.378ns 0.00742522mA
+ 5.38ns 0.0112718mA
+ 5.382ns 0.0151184mA
+ 5.384ns 0.0189659mA
+ 5.386ns 0.0228124mA
+ 5.388ns 0.026659mA
+ 5.39ns 0.0305056mA
+ 5.392ns 0.0343531mA
+ 5.394ns 0.0381997mA
+ 5.396ns 0.0420462mA
+ 5.398ns 0.0458937mA
+ 5.4ns 0.0497403mA
+ 5.402ns 0.0535869mA
+ 5.404ns 0.0574344mA
+ 5.406ns 0.0612809mA
+ 5.408ns 0.0651275mA
+ 5.41ns 0.0689741mA
+ 5.412ns 0.0728216mA
+ 5.414ns 0.0766682mA
+ 5.416ns 0.0805147mA
+ 5.418ns 0.0843622mA
+ 5.42ns 0.0882088mA
+ 5.422ns 0.0920554mA
+ 5.424ns 0.0959029mA
+ 5.426ns 0.0997494mA
+ 5.428ns 0.103596mA
+ 5.43ns 0.107443mA
+ 5.432ns 0.11129mA
+ 5.434ns 0.115137mA
+ 5.436ns 0.118983mA
+ 5.438ns 0.122831mA
+ 5.44ns 0.126677mA
+ 5.442ns 0.130524mA
+ 5.444ns 0.134371mA
+ 5.446ns 0.138218mA
+ 5.448ns 0.142065mA
+ 5.45ns 0.145912mA
+ 5.452ns 0.149759mA
+ 5.454ns 0.153605mA
+ 5.456ns 0.157452mA
+ 5.458ns 0.161299mA
+ 5.46ns 0.165146mA
+ 5.462ns 0.168992mA
+ 5.464ns 0.17284mA
+ 5.466ns 0.176686mA
+ 5.468ns 0.180533mA
+ 5.47ns 0.18438mA
+ 5.472ns 0.188227mA
+ 5.474ns 0.192074mA
+ 5.476ns 0.19592mA
+ 5.478ns 0.199768mA
+ 5.48ns 0.203614mA
+ 5.482ns 0.207461mA
+ 5.484ns 0.211308mA
+ 5.486ns 0.215155mA
+ 5.488ns 0.219002mA
+ 5.49ns 0.222849mA
+ 5.492ns 0.226696mA
+ 5.494ns 0.230542mA
+ 5.496ns 0.23439mA
+ 5.498ns 0.238236mA
+ 5.5ns 0.242083mA
+ 5.502ns 0.245929mA
+ 5.504ns 0.249777mA
+ 5.506ns 0.253623mA
+ 5.508ns 0.25747mA
+ 5.51ns 0.261317mA
+ 5.512ns 0.265164mA
+ 5.514ns 0.269011mA
+ 5.516ns 0.272858mA
+ 5.518ns 0.276705mA
+ 5.52ns 0.280551mA
+ 5.522ns 0.284398mA
+ 5.524ns 0.288245mA
+ 5.526ns 0.292092mA
+ 5.528ns 0.295938mA
+ 5.53ns 0.299786mA
+ 5.532ns 0.303633mA
+ 5.534ns 0.307479mA
+ 5.536ns 0.311327mA
+ 5.538ns 0.315173mA
+ 5.54ns 0.31902mA
+ 5.542ns 0.322867mA
+ 5.544ns 0.326714mA
+ 5.546ns 0.33056mA
+ 5.548ns 0.334407mA
+ 5.55ns 0.338254mA
+ 5.552ns 0.342101mA
+ 5.554ns 0.345948mA
+ 5.556ns 0.349795mA
+ 5.558ns 0.353642mA
+ 5.56ns 0.357488mA
+ 5.562ns 0.361336mA
+ 5.564ns 0.365182mA
+ 5.566ns 0.369029mA
+ 5.568ns 0.372875mA
+ 5.57ns 0.376723mA
+ 5.572ns 0.38057mA
+ 5.574ns 0.384416mA
+ 5.576ns 0.388264mA
+ 5.578ns 0.39211mA
+ 5.58ns 0.395957mA
+ 5.582ns 0.399804mA
+ 5.584ns 0.403651mA
+ 5.586ns 0.407497mA
+ 5.588ns 0.411345mA
+ 5.59ns 0.415191mA
+ 5.592ns 0.419038mA
+ 5.594ns 0.422885mA
+ 5.596ns 0.426732mA
+ 5.598ns 0.430579mA
+ 5.6ns 0.433351mA
+ 5.602ns 0.431829mA
+ 5.604ns 0.430313mA
+ 5.606ns 0.428803mA
+ 5.608ns 0.427297mA
+ 5.61ns 0.425798mA
+ 5.612ns 0.424303mA
+ 5.614ns 0.422813mA
+ 5.616ns 0.421329mA
+ 5.618ns 0.41985mA
+ 5.62ns 0.418376mA
+ 5.622ns 0.416907mA
+ 5.624ns 0.415444mA
+ 5.626ns 0.413985mA
+ 5.628ns 0.412532mA
+ 5.63ns 0.411084mA
+ 5.632ns 0.409641mA
+ 5.634ns 0.408202mA
+ 5.636ns 0.40677mA
+ 5.638ns 0.405342mA
+ 5.64ns 0.403919mA
+ 5.642ns 0.402501mA
+ 5.644ns 0.401088mA
+ 5.646ns 0.39968mA
+ 5.648ns 0.398277mA
+ 5.65ns 0.396878mA
+ 5.652ns 0.395485mA
+ 5.654ns 0.394097mA
+ 5.656ns 0.392713mA
+ 5.658ns 0.391335mA
+ 5.66ns 0.389961mA
+ 5.662ns 0.388592mA
+ 5.664ns 0.387228mA
+ 5.666ns 0.385868mA
+ 5.668ns 0.384514mA
+ 5.67ns 0.383164mA
+ 5.672ns 0.381819mA
+ 5.674ns 0.380478mA
+ 5.676ns 0.379143mA
+ 5.678ns 0.377812mA
+ 5.68ns 0.376485mA
+ 5.682ns 0.375163mA
+ 5.684ns 0.373847mA
+ 5.686ns 0.372534mA
+ 5.688ns 0.371226mA
+ 5.69ns 0.369923mA
+ 5.692ns 0.368624mA
+ 5.694ns 0.36733mA
+ 5.696ns 0.366041mA
+ 5.698ns 0.364756mA
+ 5.7ns 0.363475mA
+ 5.702ns 0.362199mA
+ 5.704ns 0.360928mA
+ 5.706ns 0.359661mA
+ 5.708ns 0.358398mA
+ 5.71ns 0.35714mA
+ 5.712ns 0.355886mA
+ 5.714ns 0.354636mA
+ 5.716ns 0.353391mA
+ 5.718ns 0.352151mA
+ 5.72ns 0.350914mA
+ 5.722ns 0.349683mA
+ 5.724ns 0.348455mA
+ 5.726ns 0.347232mA
+ 5.728ns 0.346013mA
+ 5.73ns 0.344798mA
+ 5.732ns 0.343588mA
+ 5.734ns 0.342381mA
+ 5.736ns 0.341179mA
+ 5.738ns 0.339982mA
+ 5.74ns 0.338788mA
+ 5.742ns 0.337599mA
+ 5.744ns 0.336413mA
+ 5.746ns 0.335232mA
+ 5.748ns 0.334055mA
+ 5.75ns 0.332883mA
+ 5.752ns 0.331714mA
+ 5.754ns 0.330549mA
+ 5.756ns 0.329389mA
+ 5.758ns 0.328233mA
+ 5.76ns 0.32708mA
+ 5.762ns 0.325932mA
+ 5.764ns 0.324788mA
+ 5.766ns 0.323647mA
+ 5.768ns 0.322511mA
+ 5.77ns 0.321379mA
+ 5.772ns 0.320251mA
+ 5.774ns 0.319126mA
+ 5.776ns 0.318006mA
+ 5.778ns 0.31689mA
+ 5.78ns 0.315777mA
+ 5.782ns 0.314668mA
+ 5.784ns 0.313564mA
+ 5.786ns 0.312463mA
+ 5.788ns 0.311366mA
+ 5.79ns 0.310273mA
+ 5.792ns 0.309183mA
+ 5.794ns 0.308098mA
+ 5.796ns 0.307016mA
+ 5.798ns 0.305939mA
+ 5.8ns 0.304864mA
+ 5.802ns 0.303794mA
+ 5.804ns 0.302728mA
+ 5.806ns 0.301665mA
+ 5.808ns 0.300606mA
+ 5.81ns 0.29955mA
+ 5.812ns 0.298498mA
+ 5.814ns 0.297451mA
+ 5.816ns 0.296406mA
+ 5.818ns 0.295366mA
+ 5.82ns 0.294329mA
+ 5.822ns 0.293295mA
+ 5.824ns 0.292266mA
+ 5.826ns 0.29124mA
+ 5.828ns 0.290217mA
+ 5.83ns 0.289198mA
+ 5.832ns 0.288183mA
+ 5.834ns 0.287171mA
+ 5.836ns 0.286163mA
+ 5.838ns 0.285158mA
+ 5.84ns 0.284157mA
+ 5.842ns 0.283159mA
+ 5.844ns 0.282165mA
+ 5.846ns 0.281175mA
+ 5.848ns 0.280188mA
+ 5.85ns 0.279204mA
+ 5.852ns 0.278224mA
+ 5.854ns 0.277247mA
+ 5.856ns 0.276273mA
+ 5.858ns 0.275303mA
+ 5.86ns 0.274337mA
+ 5.862ns 0.273374mA
+ 5.864ns 0.272414mA
+ 5.866ns 0.271457mA
+ 5.868ns 0.270505mA
+ 5.87ns 0.269555mA
+ 5.872ns 0.268608mA
+ 5.874ns 0.267665mA
+ 5.876ns 0.266726mA
+ 5.878ns 0.265789mA
+ 5.88ns 0.264856mA
+ 5.882ns 0.263926mA
+ 5.884ns 0.262999mA
+ 5.886ns 0.262076mA
+ 5.888ns 0.261156mA
+ 5.89ns 0.260239mA
+ 5.892ns 0.259325mA
+ 5.894ns 0.258415mA
+ 5.896ns 0.257508mA
+ 5.898ns 0.256604mA
+ 5.9ns 0.255703mA
+ 5.902ns 0.254805mA
+ 5.904ns 0.25391mA
+ 5.906ns 0.253019mA
+ 5.908ns 0.252131mA
+ 5.91ns 0.251245mA
+ 5.912ns 0.250363mA
+ 5.914ns 0.249484mA
+ 5.916ns 0.248608mA
+ 5.918ns 0.247735mA
+ 5.92ns 0.246866mA
+ 5.922ns 0.245999mA
+ 5.924ns 0.245135mA
+ 5.926ns 0.244275mA
+ 5.928ns 0.243417mA
+ 5.93ns 0.242562mA
+ 5.932ns 0.241711mA
+ 5.934ns 0.240862mA
+ 5.936ns 0.240016mA
+ 5.938ns 0.239174mA
+ 5.94ns 0.238334mA
+ 5.942ns 0.237497mA
+ 5.944ns 0.236663mA
+ 5.946ns 0.235832mA
+ 5.948ns 0.235004mA
+ 5.95ns 0.234179mA
+ 5.952ns 0.233357mA
+ 5.954ns 0.232538mA
+ 5.956ns 0.231721mA
+ 5.958ns 0.230908mA
+ 5.96ns 0.230097mA
+ 5.962ns 0.229289mA
+ 5.964ns 0.228484mA
+ 5.966ns 0.227682mA
+ 5.968ns 0.226883mA
+ 5.97ns 0.226086mA
+ 5.972ns 0.225292mA
+ 5.974ns 0.224501mA
+ 5.976ns 0.223713mA
+ 5.978ns 0.222927mA
+ 5.98ns 0.222145mA
+ 5.982ns 0.221365mA
+ 5.984ns 0.220587mA
+ 5.986ns 0.219813mA
+ 5.988ns 0.219041mA
+ 5.99ns 0.218272mA
+ 5.992ns 0.217506mA
+ 5.994ns 0.216742mA
+ 5.996ns 0.215981mA
+ 5.998ns 0.215223mA
+ 6ns 0.214467mA
+ 6.002ns 0.213714mA
+ 6.004ns 0.212964mA
+ 6.006ns 0.212216mA
+ 6.008ns 0.211471mA
+ 6.01ns 0.210728mA
+ 6.012ns 0.209988mA
+ 6.014ns 0.209251mA
+ 6.016ns 0.208517mA
+ 6.018ns 0.207784mA
+ 6.02ns 0.207055mA
+ 6.022ns 0.206328mA
+ 6.024ns 0.205603mA
+ 6.026ns 0.204882mA
+ 6.028ns 0.204162mA
+ 6.03ns 0.203445mA
+ 6.032ns 0.202731mA
+ 6.034ns 0.202019mA
+ 6.036ns 0.20131mA
+ 6.038ns 0.200603mA
+ 6.04ns 0.199899mA
+ 6.042ns 0.199197mA
+ 6.044ns 0.198497mA
+ 6.046ns 0.1978mA
+ 6.048ns 0.197106mA
+ 6.05ns 0.196414mA
+ 6.052ns 0.195724mA
+ 6.054ns 0.195037mA
+ 6.056ns 0.194352mA
+ 6.058ns 0.19367mA
+ 6.06ns 0.19299mA
+ 6.062ns 0.192312mA
+ 6.064ns 0.191637mA
+ 6.066ns 0.190964mA
+ 6.068ns 0.190294mA
+ 6.07ns 0.189625mA
+ 6.072ns 0.18896mA
+ 6.074ns 0.188296mA
+ 6.076ns 0.187635mA
+ 6.078ns 0.186976mA
+ 6.08ns 0.18632mA
+ 6.082ns 0.185666mA
+ 6.084ns 0.185014mA
+ 6.086ns 0.184364mA
+ 6.088ns 0.183717mA
+ 6.09ns 0.183071mA
+ 6.092ns 0.182429mA
+ 6.094ns 0.181788mA
+ 6.096ns 0.18115mA
+ 6.098ns 0.180514mA
+ 6.1ns 0.17988mA
+ 6.102ns 0.179248mA
+ 6.104ns 0.178619mA
+ 6.106ns 0.177992mA
+ 6.108ns 0mA
I138 250 0 PWL 0 0
+ 0.154ns 0mA
+ 0.156ns 0.0105321mA
+ 0.158ns 0.0220805mA
+ 0.16ns 0.033629mA
+ 0.162ns 0.0451775mA
+ 0.164ns 0.056726mA
+ 0.166ns 0.0682744mA
+ 0.168ns 0.0798229mA
+ 0.17ns 0.0913714mA
+ 0.172ns 0.10292mA
+ 0.174ns 0.114468mA
+ 0.176ns 0.126017mA
+ 0.178ns 0.137565mA
+ 0.18ns 0.126333mA
+ 0.182ns 0.112616mA
+ 0.184ns 0.100388mA
+ 0.186ns 0.0894879mA
+ 0.188ns 0.0797708mA
+ 0.19ns 0.0711087mA
+ 0.192ns 0.063387mA
+ 0.194ns 0.0565036mA
+ 0.196ns 0.0503675mA
+ 0.198ns 0.0448976mA
+ 0.2ns 0.0400217mA
+ 0.202ns 0.0356751mA
+ 0.204ns 0mA
I139 251 0 PWL 0 0
+ 0.234ns 0mA
+ 0.236ns 0.00239751mA
+ 0.238ns 0.00745084mA
+ 0.24ns 0.0125042mA
+ 0.242ns 0.0175576mA
+ 0.244ns 0.022611mA
+ 0.246ns 0.0276643mA
+ 0.248ns 0.0327177mA
+ 0.25ns 0.037771mA
+ 0.252ns 0.0428244mA
+ 0.254ns 0.0478777mA
+ 0.256ns 0.0529309mA
+ 0.258ns 0.0463692mA
+ 0.26ns 0.0406207mA
+ 0.262ns 0.0355847mA
+ 0.264ns 0.031173mA
+ 0.266ns 0.0273081mA
+ 0.268ns 0.0239222mA
+ 0.27ns 0.0209561mA
+ 0.272ns 0.0183577mA
+ 0.274ns 0.0160813mA
+ 0.276ns 0.0140872mA
+ 0.278ns 0mA
+ 7.93ns 0mA
+ 7.932ns 0.000123983mA
+ 7.934ns 0.00517698mA
+ 7.936ns 0.01023mA
+ 7.938ns 0.0152842mA
+ 7.94ns 0.0203372mA
+ 7.942ns 0.0253902mA
+ 7.944ns 0.0304444mA
+ 7.946ns 0.0354974mA
+ 7.948ns 0.0405504mA
+ 7.95ns 0.0456046mA
+ 7.952ns 0.0506576mA
+ 7.954ns 0.0492147mA
+ 7.956ns 0.0431126mA
+ 7.958ns 0.0377681mA
+ 7.96ns 0.0330861mA
+ 7.962ns 0.0289843mA
+ 7.964ns 0.0253901mA
+ 7.966ns 0.0222422mA
+ 7.968ns 0.0194846mA
+ 7.97ns 0.0170682mA
+ 7.972ns 0.0149519mA
+ 7.974ns 0mA
I140 269 0 PWL 0 0
+ 4.998ns 0mA
+ 5ns 0.000136967mA
+ 5.002ns 0.00175469mA
+ 5.004ns 0.00337279mA
+ 5.006ns 0.00499051mA
+ 5.008ns 0.00660823mA
+ 5.01ns 0.00822633mA
+ 5.012ns 0.00984405mA
+ 5.014ns 0.0114618mA
+ 5.016ns 0.0130799mA
+ 5.018ns 0.0146976mA
+ 5.02ns 0.0163153mA
+ 5.022ns 0.017933mA
+ 5.024ns 0.0195511mA
+ 5.026ns 0.0211688mA
+ 5.028ns 0.0227866mA
+ 5.03ns 0.0244047mA
+ 5.032ns 0.0260224mA
+ 5.034ns 0.0276401mA
+ 5.036ns 0.0292582mA
+ 5.038ns 0.0308759mA
+ 5.04ns 0.0324936mA
+ 5.042ns 0.0341114mA
+ 5.044ns 0.0357295mA
+ 5.046ns 0.0373472mA
+ 5.048ns 0.0389649mA
+ 5.05ns 0.040583mA
+ 5.052ns 0.0422007mA
+ 5.054ns 0.0438184mA
+ 5.056ns 0.0454365mA
+ 5.058ns 0.0470543mA
+ 5.06ns 0.048672mA
+ 5.062ns 0.0502901mA
+ 5.064ns 0.0519078mA
+ 5.066ns 0.0535255mA
+ 5.068ns 0.0551432mA
+ 5.07ns 0.0567613mA
+ 5.072ns 0.0583791mA
+ 5.074ns 0.0599968mA
+ 5.076ns 0.0616149mA
+ 5.078ns 0.0632326mA
+ 5.08ns 0.0648503mA
+ 5.082ns 0.0664684mA
+ 5.084ns 0.0680861mA
+ 5.086ns 0.0697039mA
+ 5.088ns 0.0713216mA
+ 5.09ns 0.0729397mA
+ 5.092ns 0.0745574mA
+ 5.094ns 0.0761751mA
+ 5.096ns 0.0777932mA
+ 5.098ns 0.0794109mA
+ 5.1ns 0.0810287mA
+ 5.102ns 0.0826468mA
+ 5.104ns 0.0842645mA
+ 5.106ns 0.0858822mA
+ 5.108ns 0.0875003mA
+ 5.11ns 0.089118mA
+ 5.112ns 0.0907357mA
+ 5.114ns 0.0923535mA
+ 5.116ns 0.0939716mA
+ 5.118ns 0.0944584mA
+ 5.12ns 0.0923403mA
+ 5.122ns 0.0902692mA
+ 5.124ns 0.088245mA
+ 5.126ns 0.0862662mA
+ 5.128ns 0.0843313mA
+ 5.13ns 0.0824403mA
+ 5.132ns 0.0805916mA
+ 5.134ns 0.0787844mA
+ 5.136ns 0.0770172mA
+ 5.138ns 0.0752902mA
+ 5.14ns 0.0736018mA
+ 5.142ns 0.0719509mA
+ 5.144ns 0.0703374mA
+ 5.146ns 0.06876mA
+ 5.148ns 0.0672177mA
+ 5.15ns 0.0657103mA
+ 5.152ns 0.0642367mA
+ 5.154ns 0.0627958mA
+ 5.156ns 0.0613876mA
+ 5.158ns 0.0600109mA
+ 5.16ns 0.0586651mA
+ 5.162ns 0.0573492mA
+ 5.164ns 0.056063mA
+ 5.166ns 0.0548058mA
+ 5.168ns 0.0535764mA
+ 5.17ns 0.0523748mA
+ 5.172ns 0.0512002mA
+ 5.174ns 0.0500517mA
+ 5.176ns 0.0489292mA
+ 5.178ns 0.0478318mA
+ 5.18ns 0.0467591mA
+ 5.182ns 0.0457102mA
+ 5.184ns 0.044685mA
+ 5.186ns 0.0436828mA
+ 5.188ns 0.0427029mA
+ 5.19ns 0.0417451mA
+ 5.192ns 0.0408089mA
+ 5.194ns 0.0398934mA
+ 5.196ns 0.0389987mA
+ 5.198ns 0.038124mA
+ 5.2ns 0.0372687mA
+ 5.202ns 0.0364328mA
+ 5.204ns 0.0356157mA
+ 5.206ns 0.0348169mA
+ 5.208ns 0.0340358mA
+ 5.21ns 0.0332724mA
+ 5.212ns 0.0325261mA
+ 5.214ns 0.0317964mA
+ 5.216ns 0.0310832mA
+ 5.218ns 0.030386mA
+ 5.22ns 0.0297043mA
+ 5.222ns 0.0290381mA
+ 5.224ns 0.0283867mA
+ 5.226ns 0.02775mA
+ 5.228ns 0.0271274mA
+ 5.23ns 0.026519mA
+ 5.232ns 0.0259241mA
+ 5.234ns 0.0253425mA
+ 5.236ns 0.024774mA
+ 5.238ns 0mA
I141 274 0 PWL 0 0
+ 2.74ns 0mA
+ 2.742ns 0.00199327mA
+ 2.744ns 0.00627894mA
+ 2.746ns 0.0105651mA
+ 2.748ns 0.0148513mA
+ 2.75ns 0.019137mA
+ 2.752ns 0.0234232mA
+ 2.754ns 0.0277088mA
+ 2.756ns 0.031995mA
+ 2.758ns 0.0362812mA
+ 2.76ns 0.0405668mA
+ 2.762ns 0.044853mA
+ 2.764ns 0.0491387mA
+ 2.766ns 0.0534249mA
+ 2.768ns 0.0507047mA
+ 2.77ns 0.0454868mA
+ 2.772ns 0.0408052mA
+ 2.774ns 0.0366058mA
+ 2.776ns 0.032838mA
+ 2.778ns 0.029458mA
+ 2.78ns 0.0264262mA
+ 2.782ns 0.023706mA
+ 2.784ns 0.021266mA
+ 2.786ns 0.0190769mA
+ 2.788ns 0.017113mA
+ 2.79ns 0.0153515mA
+ 2.792ns 0.0137711mA
+ 2.794ns 0mA
I142 275 0 PWL 0 0
+ 7.872ns 0mA
+ 7.874ns 0.0056009mA
+ 7.876ns 0.0115489mA
+ 7.878ns 0.0174983mA
+ 7.88ns 0.0234463mA
+ 7.882ns 0.0293942mA
+ 7.884ns 0.0353436mA
+ 7.886ns 0.0412916mA
+ 7.888ns 0.0472396mA
+ 7.89ns 0.0531876mA
+ 7.892ns 0.059137mA
+ 7.894ns 0.065085mA
+ 7.896ns 0.0593274mA
+ 7.898ns 0.0523556mA
+ 7.9ns 0.0462043mA
+ 7.902ns 0.0407755mA
+ 7.904ns 0.0359834mA
+ 7.906ns 0.0317553mA
+ 7.908ns 0.0280239mA
+ 7.91ns 0.0247301mA
+ 7.912ns 0.021824mA
+ 7.914ns 0.0192594mA
+ 7.916ns 0.0169961mA
+ 7.918ns 0mA
+ 9.126ns 0mA
+ 9.128ns 0.00351896mA
+ 9.13ns 0.00946694mA
+ 9.132ns 0.0154149mA
+ 9.134ns 0.0213629mA
+ 9.136ns 0.0273109mA
+ 9.138ns 0.0332617mA
+ 9.14ns 0.0392097mA
+ 9.142ns 0.0451577mA
+ 9.144ns 0.0511056mA
+ 9.146ns 0.0570536mA
+ 9.148ns 0.0630016mA
+ 9.15ns 0.0619822mA
+ 9.152ns 0.0546968mA
+ 9.154ns 0.0482705mA
+ 9.156ns 0.042599mA
+ 9.158ns 0.0375938mA
+ 9.16ns 0.0331765mA
+ 9.162ns 0.0292781mA
+ 9.164ns 0.0258362mA
+ 9.166ns 0.0228002mA
+ 9.168ns 0.0201209mA
+ 9.17ns 0.0177563mA
+ 9.172ns 0mA
I143 276 0 PWL 0 0
+ 0.238ns 0mA
+ 0.24ns 0.00363754mA
+ 0.242ns 0.00772127mA
+ 0.244ns 0.011805mA
+ 0.246ns 0.0158887mA
+ 0.248ns 0.0199724mA
+ 0.25ns 0.0240561mA
+ 0.252ns 0.0281398mA
+ 0.254ns 0.0322236mA
+ 0.256ns 0.0363073mA
+ 0.258ns 0.040391mA
+ 0.26ns 0.0444747mA
+ 0.262ns 0.0485585mA
+ 0.264ns 0.0483197mA
+ 0.266ns 0.0432244mA
+ 0.268ns 0.0386662mA
+ 0.27ns 0.0345886mA
+ 0.272ns 0.030941mA
+ 0.274ns 0.0276779mA
+ 0.276ns 0.0247589mA
+ 0.278ns 0.0221476mA
+ 0.28ns 0.0198118mA
+ 0.282ns 0.0177222mA
+ 0.284ns 0.0158529mA
+ 0.286ns 0.0141808mA
+ 0.288ns 0mA
I144 277 0 PWL 0 0
+ 8.644ns 0mA
+ 8.646ns 0.0013464mA
+ 8.648ns 0.00620954mA
+ 8.65ns 0.0110727mA
+ 8.652ns 0.0159381mA
+ 8.654ns 0.0208012mA
+ 8.656ns 0.0256644mA
+ 8.658ns 0.0305275mA
+ 8.66ns 0.0353906mA
+ 8.662ns 0.0402538mA
+ 8.664ns 0.0451169mA
+ 8.666ns 0.0409999mA
+ 8.668ns 0.0354206mA
+ 8.67ns 0.0306003mA
+ 8.672ns 0.0264359mA
+ 8.674ns 0.0228381mA
+ 8.676ns 0.0197299mA
+ 8.678ns 0.0170433mA
+ 8.68ns 0.0147236mA
+ 8.682ns 0.0127195mA
+ 8.684ns 0mA
I145 278 0 PWL 0 0
+ 7.636ns 0mA
+ 7.638ns 0.00354541mA
+ 7.64ns 0.00795384mA
+ 7.642ns 0.0123633mA
+ 7.644ns 0.0167718mA
+ 7.646ns 0.0211802mA
+ 7.648ns 0.0255897mA
+ 7.65ns 0.0299981mA
+ 7.652ns 0.0344065mA
+ 7.654ns 0.038816mA
+ 7.656ns 0.0432245mA
+ 7.658ns 0.0476329mA
+ 7.66ns 0.0520413mA
+ 7.662ns 0.0564508mA
+ 7.664ns 0.0608592mA
+ 7.666ns 0.0652677mA
+ 7.668ns 0.0696772mA
+ 7.67ns 0.0740856mA
+ 7.672ns 0.078494mA
+ 7.674ns 0.0829035mA
+ 7.676ns 0.0873119mA
+ 7.678ns 0.0917204mA
+ 7.68ns 0.0961298mA
+ 7.682ns 0.100538mA
+ 7.684ns 0.104947mA
+ 7.686ns 0.109355mA
+ 7.688ns 0.111402mA
+ 7.69ns 0.10801mA
+ 7.692ns 0.104721mA
+ 7.694ns 0.101531mA
+ 7.696ns 0.0984391mA
+ 7.698ns 0.0954414mA
+ 7.7ns 0.0925343mA
+ 7.702ns 0.0897163mA
+ 7.704ns 0.0869842mA
+ 7.706ns 0.0843352mA
+ 7.708ns 0.0817662mA
+ 7.71ns 0.0792761mA
+ 7.712ns 0.0768618mA
+ 7.714ns 0.0745205mA
+ 7.716ns 0.072251mA
+ 7.718ns 0.0700506mA
+ 7.72ns 0.0679167mA
+ 7.722ns 0.0658483mA
+ 7.724ns 0.0638428mA
+ 7.726ns 0.061898mA
+ 7.728ns 0.0600128mA
+ 7.73ns 0.058185mA
+ 7.732ns 0.0564129mA
+ 7.734ns 0.0546944mA
+ 7.736ns 0.0530285mA
+ 7.738ns 0.0514134mA
+ 7.74ns 0.0498472mA
+ 7.742ns 0.0483289mA
+ 7.744ns 0.0468569mA
+ 7.746ns 0.0454294mA
+ 7.748ns 0.0440457mA
+ 7.75ns 0.0427042mA
+ 7.752ns 0.0414034mA
+ 7.754ns 0.040142mA
+ 7.756ns 0.0389193mA
+ 7.758ns 0mA
I146 279 0 PWL 0 0
+ 0.136ns 0mA
+ 0.138ns 0.00239333mA
+ 0.14ns 0.00683723mA
+ 0.142ns 0.0112812mA
+ 0.144ns 0.0157251mA
+ 0.146ns 0.020169mA
+ 0.148ns 0.024613mA
+ 0.15ns 0.0290569mA
+ 0.152ns 0.0335008mA
+ 0.154ns 0.0379448mA
+ 0.156ns 0.0423887mA
+ 0.158ns 0.0468326mA
+ 0.16ns 0.0512765mA
+ 0.162ns 0.0557204mA
+ 0.164ns 0.0601644mA
+ 0.166ns 0.0646083mA
+ 0.168ns 0.0690523mA
+ 0.17ns 0.0734962mA
+ 0.172ns 0.0779401mA
+ 0.174ns 0.082384mA
+ 0.176ns 0.086828mA
+ 0.178ns 0.0912719mA
+ 0.18ns 0.0957158mA
+ 0.182ns 0.10016mA
+ 0.184ns 0.104604mA
+ 0.186ns 0.109048mA
+ 0.188ns 0.113492mA
+ 0.19ns 0.113625mA
+ 0.192ns 0.110308mA
+ 0.194ns 0.107087mA
+ 0.196ns 0.103961mA
+ 0.198ns 0.100926mA
+ 0.2ns 0.0979797mA
+ 0.202ns 0.0951193mA
+ 0.204ns 0.0923423mA
+ 0.206ns 0.0896464mA
+ 0.208ns 0.0870293mA
+ 0.21ns 0.0844885mA
+ 0.212ns 0.0820218mA
+ 0.214ns 0.0796272mA
+ 0.216ns 0.0773024mA
+ 0.218ns 0.0750455mA
+ 0.22ns 0.0728545mA
+ 0.222ns 0.0707274mA
+ 0.224ns 0.0686625mA
+ 0.226ns 0.0666578mA
+ 0.228ns 0.0647116mA
+ 0.23ns 0.0628222mA
+ 0.232ns 0.060988mA
+ 0.234ns 0.0592073mA
+ 0.236ns 0.0574786mA
+ 0.238ns 0.0558003mA
+ 0.24ns 0.0541711mA
+ 0.242ns 0.0525894mA
+ 0.244ns 0.0510539mA
+ 0.246ns 0.0495632mA
+ 0.248ns 0.048116mA
+ 0.25ns 0.0467111mA
+ 0.252ns 0.0453471mA
+ 0.254ns 0.044023mA
+ 0.256ns 0.0427376mA
+ 0.258ns 0.0414896mA
+ 0.26ns 0.0402781mA
+ 0.262ns 0mA
+ 7.636ns 0mA
+ 7.638ns 0.00239333mA
+ 7.64ns 0.00683694mA
+ 7.642ns 0.0112816mA
+ 7.644ns 0.0157252mA
+ 7.646ns 0.0201688mA
+ 7.648ns 0.0246135mA
+ 7.65ns 0.0290571mA
+ 7.652ns 0.0335007mA
+ 7.654ns 0.0379454mA
+ 7.656ns 0.042389mA
+ 7.658ns 0.0468326mA
+ 7.66ns 0.0512762mA
+ 7.662ns 0.0557208mA
+ 7.664ns 0.0601645mA
+ 7.666ns 0.0646081mA
+ 7.668ns 0.0690527mA
+ 7.67ns 0.0734963mA
+ 7.672ns 0.0779399mA
+ 7.674ns 0.0823846mA
+ 7.676ns 0.0868282mA
+ 7.678ns 0.0912718mA
+ 7.68ns 0.0957165mA
+ 7.682ns 0.10016mA
+ 7.684ns 0.104604mA
+ 7.686ns 0.109047mA
+ 7.688ns 0.113492mA
+ 7.69ns 0.113624mA
+ 7.692ns 0.110308mA
+ 7.694ns 0.107087mA
+ 7.696ns 0.103961mA
+ 7.698ns 0.100926mA
+ 7.7ns 0.0979793mA
+ 7.702ns 0.0951191mA
+ 7.704ns 0.0923423mA
+ 7.706ns 0.0896467mA
+ 7.708ns 0.087029mA
+ 7.71ns 0.0844884mA
+ 7.712ns 0.0820219mA
+ 7.714ns 0.0796269mA
+ 7.716ns 0.0773023mA
+ 7.718ns 0.0750456mA
+ 7.72ns 0.0728542mA
+ 7.722ns 0.0707273mA
+ 7.724ns 0.0686625mA
+ 7.726ns 0.0666575mA
+ 7.728ns 0.0647114mA
+ 7.73ns 0.0628222mA
+ 7.732ns 0.0609881mA
+ 7.734ns 0.0592071mA
+ 7.736ns 0.0574785mA
+ 7.738ns 0.0558004mA
+ 7.74ns 0.0541709mA
+ 7.742ns 0.0525893mA
+ 7.744ns 0.0510539mA
+ 7.746ns 0.049563mA
+ 7.748ns 0.0481159mA
+ 7.75ns 0.0467111mA
+ 7.752ns 0.0453472mA
+ 7.754ns 0.0440229mA
+ 7.756ns 0.0427375mA
+ 7.758ns 0.0414897mA
+ 7.76ns 0.040278mA
+ 7.762ns 0mA
I147 283 0 PWL 0 0
+ 8.582ns 0mA
+ 8.584ns 0.000469606mA
+ 8.586ns 0.00242248mA
+ 8.588ns 0.00437443mA
+ 8.59ns 0.00632638mA
+ 8.592ns 0.00827832mA
+ 8.594ns 0.0102303mA
+ 8.596ns 0.0121822mA
+ 8.598ns 0.0141342mA
+ 8.6ns 0.016087mA
+ 8.602ns 0.018039mA
+ 8.604ns 0.0199909mA
+ 8.606ns 0.0219429mA
+ 8.608ns 0.0238948mA
+ 8.61ns 0.0258468mA
+ 8.612ns 0.0277997mA
+ 8.614ns 0.0297516mA
+ 8.616ns 0.0317035mA
+ 8.618ns 0.0336555mA
+ 8.62ns 0.0356074mA
+ 8.622ns 0.0375594mA
+ 8.624ns 0.0395113mA
+ 8.626ns 0.041462mA
+ 8.628ns 0.0388425mA
+ 8.63ns 0.0363884mA
+ 8.632ns 0.0340894mA
+ 8.634ns 0.0319356mA
+ 8.636ns 0.0299178mA
+ 8.638ns 0.0280266mA
+ 8.64ns 0.0262558mA
+ 8.642ns 0.0245968mA
+ 8.644ns 0.0230426mA
+ 8.646ns 0.0215866mA
+ 8.648ns 0.0202226mA
+ 8.65ns 0.0189448mA
+ 8.652ns 0.0177471mA
+ 8.654ns 0.0166256mA
+ 8.656ns 0.015575mA
+ 8.658ns 0.0145908mA
+ 8.66ns 0.0136687mA
+ 8.662ns 0.012805mA
+ 8.664ns 0.0119957mA
+ 8.666ns 0.0112373mA
+ 8.668ns 0.0105271mA
+ 8.67ns 0mA
I148 284 0 PWL 0 0
+ 0.256ns 0mA
+ 0.258ns 0.00254916mA
+ 0.26ns 0.00644242mA
+ 0.262ns 0.0103357mA
+ 0.264ns 0.0142289mA
+ 0.266ns 0.0181221mA
+ 0.268ns 0.0220154mA
+ 0.27ns 0.0259086mA
+ 0.272ns 0.0298019mA
+ 0.274ns 0.0336952mA
+ 0.276ns 0.0375884mA
+ 0.278ns 0.0369263mA
+ 0.28ns 0.0322141mA
+ 0.282ns 0.028103mA
+ 0.284ns 0.0245165mA
+ 0.286ns 0.0213876mA
+ 0.288ns 0.0186579mA
+ 0.29ns 0.0162766mA
+ 0.292ns 0.0141991mA
+ 0.294ns 0.0123867mA
+ 0.296ns 0.0108056mA
+ 0.298ns 0mA
I149 285 0 PWL 0 0
+ 0.316ns 0mA
+ 0.318ns 0.00338614mA
+ 0.32ns 0.0071714mA
+ 0.322ns 0.0109567mA
+ 0.324ns 0.0147419mA
+ 0.326ns 0.0185271mA
+ 0.328ns 0.0223124mA
+ 0.33ns 0.0260977mA
+ 0.332ns 0.0298829mA
+ 0.334ns 0.0336682mA
+ 0.336ns 0.0374535mA
+ 0.338ns 0.0412387mA
+ 0.34ns 0.045024mA
+ 0.342ns 0.0456827mA
+ 0.344ns 0.0409032mA
+ 0.346ns 0.0366236mA
+ 0.348ns 0.0327916mA
+ 0.35ns 0.0293605mA
+ 0.352ns 0.0262884mA
+ 0.354ns 0.0235377mA
+ 0.356ns 0.0210746mA
+ 0.358ns 0.0188693mA
+ 0.36ns 0.0168947mA
+ 0.362ns 0.0151267mA
+ 0.364ns 0.0135437mA
+ 0.366ns 0.0121263mA
+ 0.368ns 0mA
I150 286 0 PWL 0 0
+ 2.736ns 0mA
+ 2.738ns 0.00122232mA
+ 2.74ns 0.00504752mA
+ 2.742ns 0.00887272mA
+ 2.744ns 0.0126975mA
+ 2.746ns 0.0165227mA
+ 2.748ns 0.0203479mA
+ 2.75ns 0.0241726mA
+ 2.752ns 0.0279978mA
+ 2.754ns 0.0318226mA
+ 2.756ns 0.0356478mA
+ 2.758ns 0.039473mA
+ 2.76ns 0.0388163mA
+ 2.762ns 0.0341479mA
+ 2.764ns 0.0300413mA
+ 2.766ns 0.0264281mA
+ 2.768ns 0.0232493mA
+ 2.77ns 0.0204531mA
+ 2.772ns 0.0179929mA
+ 2.774ns 0.0158288mA
+ 2.776ns 0.0139247mA
+ 2.778ns 0.0122496mA
+ 2.78ns 0.0107761mA
+ 2.782ns 0mA
+ 7.736ns 0mA
+ 7.738ns 0.00122232mA
+ 7.74ns 0.00504798mA
+ 7.742ns 0.00887272mA
+ 7.744ns 0.0126975mA
+ 7.746ns 0.0165231mA
+ 7.748ns 0.0203479mA
+ 7.75ns 0.0241726mA
+ 7.752ns 0.0279974mA
+ 7.754ns 0.031823mA
+ 7.756ns 0.0356478mA
+ 7.758ns 0.0394725mA
+ 7.76ns 0.0388157mA
+ 7.762ns 0.0341479mA
+ 7.764ns 0.0300413mA
+ 7.766ns 0.0264277mA
+ 7.768ns 0.0232493mA
+ 7.77ns 0.0204531mA
+ 7.772ns 0.0179926mA
+ 7.774ns 0.0158285mA
+ 7.776ns 0.0139247mA
+ 7.778ns 0.0122497mA
+ 7.78ns 0.0107759mA
+ 7.782ns 0mA
I151 287 0 PWL 0 0
+ 5.25ns 0mA
+ 5.252ns 0.000586719mA
+ 5.254ns 0.00538637mA
+ 5.256ns 0.0101849mA
+ 5.258ns 0.0149834mA
+ 5.26ns 0.019783mA
+ 5.262ns 0.0245816mA
+ 5.264ns 0.0293801mA
+ 5.266ns 0.0341797mA
+ 5.268ns 0.0389782mA
+ 5.27ns 0.0437767mA
+ 5.272ns 0.0468682mA
+ 5.274ns 0.0407844mA
+ 5.276ns 0.0354913mA
+ 5.278ns 0.030885mA
+ 5.28ns 0.0268755mA
+ 5.282ns 0.0233872mA
+ 5.284ns 0.0203516mA
+ 5.286ns 0.0177093mA
+ 5.288ns 0.0154105mA
+ 5.29ns 0.01341mA
+ 5.292ns 0mA
+ 8.88ns 0mA
+ 8.882ns 0.00466671mA
+ 8.884ns 0.00946522mA
+ 8.886ns 0.0142637mA
+ 8.888ns 0.0190645mA
+ 8.89ns 0.023863mA
+ 8.892ns 0.0286615mA
+ 8.894ns 0.0334601mA
+ 8.896ns 0.0382586mA
+ 8.898ns 0.0430571mA
+ 8.9ns 0.0478556mA
+ 8.902ns 0.0416422mA
+ 8.904ns 0.0362378mA
+ 8.906ns 0.0315346mA
+ 8.908ns 0.0274417mA
+ 8.91ns 0.02388mA
+ 8.912ns 0.0207804mA
+ 8.914ns 0.0180818mA
+ 8.916ns 0.0157347mA
+ 8.918ns 0.0136921mA
+ 8.92ns 0mA
I152 288 0 PWL 0 0
+ 0.51ns 0mA
+ 0.512ns 2.08162e-06mA
+ 0.514ns 0.00776284mA
+ 0.516ns 0.0155238mA
+ 0.518ns 0.0232846mA
+ 0.52ns 0.0310456mA
+ 0.522ns 0.0388063mA
+ 0.524ns 0.0465673mA
+ 0.526ns 0.0543281mA
+ 0.528ns 0.0620888mA
+ 0.53ns 0.0698498mA
+ 0.532ns 0.0776106mA
+ 0.534ns 0.0853715mA
+ 0.536ns 0.0931323mA
+ 0.538ns 0.100893mA
+ 0.54ns 0.108654mA
+ 0.542ns 0.116415mA
+ 0.544ns 0.124176mA
+ 0.546ns 0.131937mA
+ 0.548ns 0.139698mA
+ 0.55ns 0.147458mA
+ 0.552ns 0.155219mA
+ 0.554ns 0.16298mA
+ 0.556ns 0.170741mA
+ 0.558ns 0.178502mA
+ 0.56ns 0.186263mA
+ 0.562ns 0.194023mA
+ 0.564ns 0.201784mA
+ 0.566ns 0.209545mA
+ 0.568ns 0.217306mA
+ 0.57ns 0.225067mA
+ 0.572ns 0.232828mA
+ 0.574ns 0.240588mA
+ 0.576ns 0.248349mA
+ 0.578ns 0.25611mA
+ 0.58ns 0.263871mA
+ 0.582ns 0.271632mA
+ 0.584ns 0.279393mA
+ 0.586ns 0.287154mA
+ 0.588ns 0.294914mA
+ 0.59ns 0.302675mA
+ 0.592ns 0.310436mA
+ 0.594ns 0.318197mA
+ 0.596ns 0.325958mA
+ 0.598ns 0.333719mA
+ 0.6ns 0.34148mA
+ 0.602ns 0.349241mA
+ 0.604ns 0.357001mA
+ 0.606ns 0.364762mA
+ 0.608ns 0.372523mA
+ 0.61ns 0.380284mA
+ 0.612ns 0.388045mA
+ 0.614ns 0.395806mA
+ 0.616ns 0.403567mA
+ 0.618ns 0.411327mA
+ 0.62ns 0.419088mA
+ 0.622ns 0.426849mA
+ 0.624ns 0.43461mA
+ 0.626ns 0.442371mA
+ 0.628ns 0.450132mA
+ 0.63ns 0.457893mA
+ 0.632ns 0.465653mA
+ 0.634ns 0.473414mA
+ 0.636ns 0.481175mA
+ 0.638ns 0.488936mA
+ 0.64ns 0.496697mA
+ 0.642ns 0.504458mA
+ 0.644ns 0.512219mA
+ 0.646ns 0.519979mA
+ 0.648ns 0.52774mA
+ 0.65ns 0.535501mA
+ 0.652ns 0.543262mA
+ 0.654ns 0.550514mA
+ 0.656ns 0.54812mA
+ 0.658ns 0.545735mA
+ 0.66ns 0.543361mA
+ 0.662ns 0.540997mA
+ 0.664ns 0.538644mA
+ 0.666ns 0.536301mA
+ 0.668ns 0.533968mA
+ 0.67ns 0.531645mA
+ 0.672ns 0.529332mA
+ 0.674ns 0.52703mA
+ 0.676ns 0.524737mA
+ 0.678ns 0.522454mA
+ 0.68ns 0.520182mA
+ 0.682ns 0.517919mA
+ 0.684ns 0.515666mA
+ 0.686ns 0.513422mA
+ 0.688ns 0.511189mA
+ 0.69ns 0.508965mA
+ 0.692ns 0.506751mA
+ 0.694ns 0.504547mA
+ 0.696ns 0.502352mA
+ 0.698ns 0.500166mA
+ 0.7ns 0.49799mA
+ 0.702ns 0.495824mA
+ 0.704ns 0.493667mA
+ 0.706ns 0.49152mA
+ 0.708ns 0.489381mA
+ 0.71ns 0.487252mA
+ 0.712ns 0.485133mA
+ 0.714ns 0.483022mA
+ 0.716ns 0.480921mA
+ 0.718ns 0.478829mA
+ 0.72ns 0.476746mA
+ 0.722ns 0.474672mA
+ 0.724ns 0.472607mA
+ 0.726ns 0.470551mA
+ 0.728ns 0.468504mA
+ 0.73ns 0.466466mA
+ 0.732ns 0.464437mA
+ 0.734ns 0.462416mA
+ 0.736ns 0.460404mA
+ 0.738ns 0.458402mA
+ 0.74ns 0.456407mA
+ 0.742ns 0.454422mA
+ 0.744ns 0.452445mA
+ 0.746ns 0.450477mA
+ 0.748ns 0.448517mA
+ 0.75ns 0.446566mA
+ 0.752ns 0.444623mA
+ 0.754ns 0.442689mA
+ 0.756ns 0.440763mA
+ 0.758ns 0.438845mA
+ 0.76ns 0.436936mA
+ 0.762ns 0.435035mA
+ 0.764ns 0.433143mA
+ 0.766ns 0.431259mA
+ 0.768ns 0.429382mA
+ 0.77ns 0.427514mA
+ 0.772ns 0.425655mA
+ 0.774ns 0.423803mA
+ 0.776ns 0.421959mA
+ 0.778ns 0.420123mA
+ 0.78ns 0.418296mA
+ 0.782ns 0.416476mA
+ 0.784ns 0.414664mA
+ 0.786ns 0.41286mA
+ 0.788ns 0.411064mA
+ 0.79ns 0.409276mA
+ 0.792ns 0.407495mA
+ 0.794ns 0.405722mA
+ 0.796ns 0.403957mA
+ 0.798ns 0.4022mA
+ 0.8ns 0.40045mA
+ 0.802ns 0.398708mA
+ 0.804ns 0.396973mA
+ 0.806ns 0.395246mA
+ 0.808ns 0.393527mA
+ 0.81ns 0.391815mA
+ 0.812ns 0.39011mA
+ 0.814ns 0.388413mA
+ 0.816ns 0.386723mA
+ 0.818ns 0.385041mA
+ 0.82ns 0.383366mA
+ 0.822ns 0.381698mA
+ 0.824ns 0.380037mA
+ 0.826ns 0.378384mA
+ 0.828ns 0.376738mA
+ 0.83ns 0.375099mA
+ 0.832ns 0.373467mA
+ 0.834ns 0.371842mA
+ 0.836ns 0.370225mA
+ 0.838ns 0.368614mA
+ 0.84ns 0.36701mA
+ 0.842ns 0.365413mA
+ 0.844ns 0.363824mA
+ 0.846ns 0.362241mA
+ 0.848ns 0.360665mA
+ 0.85ns 0.359096mA
+ 0.852ns 0.357534mA
+ 0.854ns 0.355978mA
+ 0.856ns 0.354429mA
+ 0.858ns 0.352887mA
+ 0.86ns 0.351352mA
+ 0.862ns 0.349824mA
+ 0.864ns 0.348302mA
+ 0.866ns 0.346786mA
+ 0.868ns 0.345278mA
+ 0.87ns 0.343775mA
+ 0.872ns 0.34228mA
+ 0.874ns 0.340791mA
+ 0.876ns 0.339308mA
+ 0.878ns 0.337832mA
+ 0.88ns 0.336362mA
+ 0.882ns 0.334899mA
+ 0.884ns 0.333441mA
+ 0.886ns 0.331991mA
+ 0.888ns 0.330546mA
+ 0.89ns 0.329108mA
+ 0.892ns 0.327677mA
+ 0.894ns 0.326251mA
+ 0.896ns 0.324831mA
+ 0.898ns 0.323418mA
+ 0.9ns 0.322011mA
+ 0.902ns 0.32061mA
+ 0.904ns 0.319215mA
+ 0.906ns 0.317827mA
+ 0.908ns 0.316444mA
+ 0.91ns 0.315067mA
+ 0.912ns 0.313696mA
+ 0.914ns 0.312331mA
+ 0.916ns 0.310973mA
+ 0.918ns 0.30962mA
+ 0.92ns 0.308273mA
+ 0.922ns 0.306931mA
+ 0.924ns 0.305596mA
+ 0.926ns 0.304266mA
+ 0.928ns 0.302943mA
+ 0.93ns 0.301625mA
+ 0.932ns 0.300312mA
+ 0.934ns 0.299006mA
+ 0.936ns 0.297705mA
+ 0.938ns 0.29641mA
+ 0.94ns 0.29512mA
+ 0.942ns 0.293836mA
+ 0.944ns 0.292557mA
+ 0.946ns 0.291285mA
+ 0.948ns 0.290017mA
+ 0.95ns 0.288755mA
+ 0.952ns 0.287499mA
+ 0.954ns 0.286248mA
+ 0.956ns 0.285003mA
+ 0.958ns 0.283763mA
+ 0.96ns 0.282528mA
+ 0.962ns 0.281299mA
+ 0.964ns 0.280075mA
+ 0.966ns 0.278857mA
+ 0.968ns 0.277643mA
+ 0.97ns 0.276435mA
+ 0.972ns 0.275233mA
+ 0.974ns 0.274035mA
+ 0.976ns 0.272843mA
+ 0.978ns 0.271656mA
+ 0.98ns 0.270474mA
+ 0.982ns 0.269297mA
+ 0.984ns 0.268125mA
+ 0.986ns 0.266959mA
+ 0.988ns 0.265797mA
+ 0.99ns 0.264641mA
+ 0.992ns 0.263489mA
+ 0.994ns 0.262343mA
+ 0.996ns 0.261202mA
+ 0.998ns 0.260065mA
+ 1ns 0.258934mA
+ 1.002ns 0.257807mA
+ 1.004ns 0.256685mA
+ 1.006ns 0.255568mA
+ 1.008ns 0.254456mA
+ 1.01ns 0.253349mA
+ 1.012ns 0.252247mA
+ 1.014ns 0.25115mA
+ 1.016ns 0.250057mA
+ 1.018ns 0.248969mA
+ 1.02ns 0.247886mA
+ 1.022ns 0.246807mA
+ 1.024ns 0.245733mA
+ 1.026ns 0.244664mA
+ 1.028ns 0.243599mA
+ 1.03ns 0.24254mA
+ 1.032ns 0.241484mA
+ 1.034ns 0.240434mA
+ 1.036ns 0.239387mA
+ 1.038ns 0.238346mA
+ 1.04ns 0.237309mA
+ 1.042ns 0.236276mA
+ 1.044ns 0mA
I153 289 0 PWL 0 0
+ 7.652ns 0mA
+ 7.654ns 0.00471538mA
+ 7.656ns 0.0146201mA
+ 7.658ns 0.0245247mA
+ 7.66ns 0.0344294mA
+ 7.662ns 0.0443365mA
+ 7.664ns 0.0542412mA
+ 7.666ns 0.0641458mA
+ 7.668ns 0.0740529mA
+ 7.67ns 0.0839576mA
+ 7.672ns 0.0938622mA
+ 7.674ns 0.103769mA
+ 7.676ns 0.113674mA
+ 7.678ns 0.123579mA
+ 7.68ns 0.133486mA
+ 7.682ns 0.132886mA
+ 7.684ns 0.12038mA
+ 7.686ns 0.109052mA
+ 7.688ns 0.0987863mA
+ 7.69ns 0.0894892mA
+ 7.692ns 0.0810669mA
+ 7.694ns 0.0734354mA
+ 7.696ns 0.0665237mA
+ 7.698ns 0.0602624mA
+ 7.7ns 0.0545889mA
+ 7.702ns 0.0494507mA
+ 7.704ns 0.044796mA
+ 7.706ns 0.0405793mA
+ 7.708ns 0.0367586mA
+ 7.71ns 0mA
I154 290 0 PWL 0 0
+ 0.51ns 0mA
+ 0.512ns 0.007264mA
+ 0.514ns 0.01501mA
+ 0.516ns 0.0227563mA
+ 0.518ns 0.0305023mA
+ 0.52ns 0.0382485mA
+ 0.522ns 0.0459945mA
+ 0.524ns 0.0537408mA
+ 0.526ns 0.0614868mA
+ 0.528ns 0.0692328mA
+ 0.53ns 0.0769791mA
+ 0.532ns 0.0847251mA
+ 0.534ns 0.0924713mA
+ 0.536ns 0.100217mA
+ 0.538ns 0.107964mA
+ 0.54ns 0.11571mA
+ 0.542ns 0.123456mA
+ 0.544ns 0.131202mA
+ 0.546ns 0.138948mA
+ 0.548ns 0.146694mA
+ 0.55ns 0.15444mA
+ 0.552ns 0.162186mA
+ 0.554ns 0.169932mA
+ 0.556ns 0.177679mA
+ 0.558ns 0.185425mA
+ 0.56ns 0.193171mA
+ 0.562ns 0.200917mA
+ 0.564ns 0.208663mA
+ 0.566ns 0.216409mA
+ 0.568ns 0.224155mA
+ 0.57ns 0.231901mA
+ 0.572ns 0.239648mA
+ 0.574ns 0.247394mA
+ 0.576ns 0.25514mA
+ 0.578ns 0.262886mA
+ 0.58ns 0.270632mA
+ 0.582ns 0.278378mA
+ 0.584ns 0.286124mA
+ 0.586ns 0.29387mA
+ 0.588ns 0.301616mA
+ 0.59ns 0.309363mA
+ 0.592ns 0.317109mA
+ 0.594ns 0.324855mA
+ 0.596ns 0.332601mA
+ 0.598ns 0.340347mA
+ 0.6ns 0.348093mA
+ 0.602ns 0.355839mA
+ 0.604ns 0.363585mA
+ 0.606ns 0.371331mA
+ 0.608ns 0.379078mA
+ 0.61ns 0.386824mA
+ 0.612ns 0.39457mA
+ 0.614ns 0.402316mA
+ 0.616ns 0.410062mA
+ 0.618ns 0.417808mA
+ 0.62ns 0.425554mA
+ 0.622ns 0.4333mA
+ 0.624ns 0.441046mA
+ 0.626ns 0.448793mA
+ 0.628ns 0.456539mA
+ 0.63ns 0.464285mA
+ 0.632ns 0.472031mA
+ 0.634ns 0.479777mA
+ 0.636ns 0.487523mA
+ 0.638ns 0.495269mA
+ 0.64ns 0.503016mA
+ 0.642ns 0.510762mA
+ 0.644ns 0.518508mA
+ 0.646ns 0.526254mA
+ 0.648ns 0.534mA
+ 0.65ns 0.541746mA
+ 0.652ns 0.549492mA
+ 0.654ns 0.54912mA
+ 0.656ns 0.546729mA
+ 0.658ns 0.544348mA
+ 0.66ns 0.541978mA
+ 0.662ns 0.539617mA
+ 0.664ns 0.537267mA
+ 0.666ns 0.534927mA
+ 0.668ns 0.532598mA
+ 0.67ns 0.530279mA
+ 0.672ns 0.527969mA
+ 0.674ns 0.52567mA
+ 0.676ns 0.523381mA
+ 0.678ns 0.521101mA
+ 0.68ns 0.518832mA
+ 0.682ns 0.516572mA
+ 0.684ns 0.514323mA
+ 0.686ns 0.512083mA
+ 0.688ns 0.509853mA
+ 0.69ns 0.507632mA
+ 0.692ns 0.505422mA
+ 0.694ns 0.503221mA
+ 0.696ns 0.501029mA
+ 0.698ns 0.498847mA
+ 0.7ns 0.496675mA
+ 0.702ns 0.494512mA
+ 0.704ns 0.492358mA
+ 0.706ns 0.490214mA
+ 0.708ns 0.488079mA
+ 0.71ns 0.485953mA
+ 0.712ns 0.483837mA
+ 0.714ns 0.48173mA
+ 0.716ns 0.479632mA
+ 0.718ns 0.477543mA
+ 0.72ns 0.475463mA
+ 0.722ns 0.473392mA
+ 0.724ns 0.471331mA
+ 0.726ns 0.469278mA
+ 0.728ns 0.467234mA
+ 0.73ns 0.4652mA
+ 0.732ns 0.463174mA
+ 0.734ns 0.461156mA
+ 0.736ns 0.459148mA
+ 0.738ns 0.457148mA
+ 0.74ns 0.455158mA
+ 0.742ns 0.453175mA
+ 0.744ns 0.451202mA
+ 0.746ns 0.449237mA
+ 0.748ns 0.44728mA
+ 0.75ns 0.445332mA
+ 0.752ns 0.443393mA
+ 0.754ns 0.441462mA
+ 0.756ns 0.439539mA
+ 0.758ns 0.437625mA
+ 0.76ns 0.435719mA
+ 0.762ns 0.433821mA
+ 0.764ns 0.431932mA
+ 0.766ns 0.430051mA
+ 0.768ns 0.428178mA
+ 0.77ns 0.426313mA
+ 0.772ns 0.424456mA
+ 0.774ns 0.422608mA
+ 0.776ns 0.420767mA
+ 0.778ns 0.418935mA
+ 0.78ns 0.41711mA
+ 0.782ns 0.415293mA
+ 0.784ns 0.413485mA
+ 0.786ns 0.411684mA
+ 0.788ns 0.409891mA
+ 0.79ns 0.408106mA
+ 0.792ns 0.406328mA
+ 0.794ns 0.404559mA
+ 0.796ns 0.402797mA
+ 0.798ns 0.401043mA
+ 0.8ns 0.399296mA
+ 0.802ns 0.397557mA
+ 0.804ns 0.395826mA
+ 0.806ns 0.394102mA
+ 0.808ns 0.392385mA
+ 0.81ns 0.390676mA
+ 0.812ns 0.388975mA
+ 0.814ns 0.387281mA
+ 0.816ns 0.385594mA
+ 0.818ns 0.383915mA
+ 0.82ns 0.382242mA
+ 0.822ns 0.380578mA
+ 0.824ns 0.37892mA
+ 0.826ns 0.37727mA
+ 0.828ns 0.375627mA
+ 0.83ns 0.373991mA
+ 0.832ns 0.372362mA
+ 0.834ns 0.37074mA
+ 0.836ns 0.369125mA
+ 0.838ns 0.367518mA
+ 0.84ns 0.365917mA
+ 0.842ns 0.364323mA
+ 0.844ns 0.362737mA
+ 0.846ns 0.361157mA
+ 0.848ns 0.359584mA
+ 0.85ns 0.358018mA
+ 0.852ns 0.356458mA
+ 0.854ns 0.354906mA
+ 0.856ns 0.35336mA
+ 0.858ns 0.351821mA
+ 0.86ns 0.350289mA
+ 0.862ns 0.348763mA
+ 0.864ns 0.347244mA
+ 0.866ns 0.345732mA
+ 0.868ns 0.344226mA
+ 0.87ns 0.342727mA
+ 0.872ns 0.341234mA
+ 0.874ns 0.339748mA
+ 0.876ns 0.338268mA
+ 0.878ns 0.336795mA
+ 0.88ns 0.335328mA
+ 0.882ns 0.333867mA
+ 0.884ns 0.332413mA
+ 0.886ns 0.330965mA
+ 0.888ns 0.329524mA
+ 0.89ns 0.328089mA
+ 0.892ns 0.32666mA
+ 0.894ns 0.325237mA
+ 0.896ns 0.32382mA
+ 0.898ns 0.32241mA
+ 0.9ns 0.321006mA
+ 0.902ns 0.319608mA
+ 0.904ns 0.318216mA
+ 0.906ns 0.31683mA
+ 0.908ns 0.31545mA
+ 0.91ns 0.314076mA
+ 0.912ns 0.312708mA
+ 0.914ns 0.311346mA
+ 0.916ns 0.30999mA
+ 0.918ns 0.30864mA
+ 0.92ns 0.307295mA
+ 0.922ns 0.305957mA
+ 0.924ns 0.304624mA
+ 0.926ns 0.303297mA
+ 0.928ns 0.301976mA
+ 0.93ns 0.300661mA
+ 0.932ns 0.299352mA
+ 0.934ns 0.298048mA
+ 0.936ns 0.29675mA
+ 0.938ns 0.295457mA
+ 0.94ns 0.29417mA
+ 0.942ns 0.292889mA
+ 0.944ns 0.291613mA
+ 0.946ns 0.290343mA
+ 0.948ns 0.289078mA
+ 0.95ns 0.287819mA
+ 0.952ns 0.286566mA
+ 0.954ns 0.285318mA
+ 0.956ns 0.284075mA
+ 0.958ns 0.282838mA
+ 0.96ns 0.281606mA
+ 0.962ns 0.280379mA
+ 0.964ns 0.279158mA
+ 0.966ns 0.277942mA
+ 0.968ns 0.276731mA
+ 0.97ns 0.275526mA
+ 0.972ns 0.274326mA
+ 0.974ns 0.273131mA
+ 0.976ns 0.271941mA
+ 0.978ns 0.270757mA
+ 0.98ns 0.269578mA
+ 0.982ns 0.268403mA
+ 0.984ns 0.267234mA
+ 0.986ns 0.26607mA
+ 0.988ns 0.264911mA
+ 0.99ns 0.263757mA
+ 0.992ns 0.262609mA
+ 0.994ns 0.261465mA
+ 0.996ns 0.260326mA
+ 0.998ns 0.259192mA
+ 1ns 0.258063mA
+ 1.002ns 0.256939mA
+ 1.004ns 0.25582mA
+ 1.006ns 0.254706mA
+ 1.008ns 0.253596mA
+ 1.01ns 0.252492mA
+ 1.012ns 0.251392mA
+ 1.014ns 0.250297mA
+ 1.016ns 0.249207mA
+ 1.018ns 0.248121mA
+ 1.02ns 0.24704mA
+ 1.022ns 0.245964mA
+ 1.024ns 0.244893mA
+ 1.026ns 0.243826mA
+ 1.028ns 0.242764mA
+ 1.03ns 0.241707mA
+ 1.032ns 0.240654mA
+ 1.034ns 0.239606mA
+ 1.036ns 0.238562mA
+ 1.038ns 0.237523mA
+ 1.04ns 0.236488mA
+ 1.042ns 0mA
+ 8.01ns 0mA
+ 8.012ns 0.007264mA
+ 8.014ns 0.0150096mA
+ 8.016ns 0.0227551mA
+ 8.018ns 0.0305007mA
+ 8.02ns 0.0382499mA
+ 8.022ns 0.0459955mA
+ 8.024ns 0.053741mA
+ 8.026ns 0.0614866mA
+ 8.028ns 0.0692321mA
+ 8.03ns 0.0769777mA
+ 8.032ns 0.0847232mA
+ 8.034ns 0.0924725mA
+ 8.036ns 0.100218mA
+ 8.038ns 0.107964mA
+ 8.04ns 0.115709mA
+ 8.042ns 0.123455mA
+ 8.044ns 0.1312mA
+ 8.046ns 0.138946mA
+ 8.048ns 0.146695mA
+ 8.05ns 0.154441mA
+ 8.052ns 0.162186mA
+ 8.054ns 0.169932mA
+ 8.056ns 0.177677mA
+ 8.058ns 0.185423mA
+ 8.06ns 0.193172mA
+ 8.062ns 0.200918mA
+ 8.064ns 0.208663mA
+ 8.066ns 0.216409mA
+ 8.068ns 0.224154mA
+ 8.07ns 0.2319mA
+ 8.072ns 0.239645mA
+ 8.074ns 0.247395mA
+ 8.076ns 0.25514mA
+ 8.078ns 0.262886mA
+ 8.08ns 0.270631mA
+ 8.082ns 0.278377mA
+ 8.084ns 0.286122mA
+ 8.086ns 0.293872mA
+ 8.088ns 0.301617mA
+ 8.09ns 0.309363mA
+ 8.092ns 0.317108mA
+ 8.094ns 0.324854mA
+ 8.096ns 0.332599mA
+ 8.098ns 0.340345mA
+ 8.1ns 0.348094mA
+ 8.102ns 0.35584mA
+ 8.104ns 0.363585mA
+ 8.106ns 0.371331mA
+ 8.108ns 0.379077mA
+ 8.11ns 0.386822mA
+ 8.112ns 0.394571mA
+ 8.114ns 0.402317mA
+ 8.116ns 0.410062mA
+ 8.118ns 0.417808mA
+ 8.12ns 0.425554mA
+ 8.122ns 0.433299mA
+ 8.124ns 0.441045mA
+ 8.126ns 0.448794mA
+ 8.128ns 0.456539mA
+ 8.13ns 0.464285mA
+ 8.132ns 0.472031mA
+ 8.134ns 0.479776mA
+ 8.136ns 0.487522mA
+ 8.138ns 0.495267mA
+ 8.14ns 0.503016mA
+ 8.142ns 0.510762mA
+ 8.144ns 0.518508mA
+ 8.146ns 0.526253mA
+ 8.148ns 0.533999mA
+ 8.15ns 0.541744mA
+ 8.152ns 0.549493mA
+ 8.154ns 0.54912mA
+ 8.156ns 0.546729mA
+ 8.158ns 0.544348mA
+ 8.16ns 0.541978mA
+ 8.162ns 0.539618mA
+ 8.164ns 0.537268mA
+ 8.166ns 0.534927mA
+ 8.168ns 0.532598mA
+ 8.17ns 0.530279mA
+ 8.172ns 0.527969mA
+ 8.174ns 0.52567mA
+ 8.176ns 0.523381mA
+ 8.178ns 0.521101mA
+ 8.18ns 0.518832mA
+ 8.182ns 0.516572mA
+ 8.184ns 0.514323mA
+ 8.186ns 0.512083mA
+ 8.188ns 0.509853mA
+ 8.19ns 0.507633mA
+ 8.192ns 0.505421mA
+ 8.194ns 0.50322mA
+ 8.196ns 0.501029mA
+ 8.198ns 0.498847mA
+ 8.2ns 0.496675mA
+ 8.202ns 0.494512mA
+ 8.204ns 0.492357mA
+ 8.206ns 0.490213mA
+ 8.208ns 0.488079mA
+ 8.21ns 0.485953mA
+ 8.212ns 0.483837mA
+ 8.214ns 0.48173mA
+ 8.216ns 0.479632mA
+ 8.218ns 0.477543mA
+ 8.22ns 0.475463mA
+ 8.222ns 0.473392mA
+ 8.224ns 0.471331mA
+ 8.226ns 0.469278mA
+ 8.228ns 0.467235mA
+ 8.23ns 0.4652mA
+ 8.232ns 0.463173mA
+ 8.234ns 0.461156mA
+ 8.236ns 0.459148mA
+ 8.238ns 0.457149mA
+ 8.24ns 0.455158mA
+ 8.242ns 0.453176mA
+ 8.244ns 0.451201mA
+ 8.246ns 0.449236mA
+ 8.248ns 0.44728mA
+ 8.25ns 0.445332mA
+ 8.252ns 0.443393mA
+ 8.254ns 0.441462mA
+ 8.256ns 0.439539mA
+ 8.258ns 0.437624mA
+ 8.26ns 0.435719mA
+ 8.262ns 0.433821mA
+ 8.264ns 0.431932mA
+ 8.266ns 0.430051mA
+ 8.268ns 0.428178mA
+ 8.27ns 0.426313mA
+ 8.272ns 0.424456mA
+ 8.274ns 0.422608mA
+ 8.276ns 0.420767mA
+ 8.278ns 0.418935mA
+ 8.28ns 0.41711mA
+ 8.282ns 0.415294mA
+ 8.284ns 0.413485mA
+ 8.286ns 0.411684mA
+ 8.288ns 0.409891mA
+ 8.29ns 0.408106mA
+ 8.292ns 0.406329mA
+ 8.294ns 0.404559mA
+ 8.296ns 0.402797mA
+ 8.298ns 0.401042mA
+ 8.3ns 0.399296mA
+ 8.302ns 0.397557mA
+ 8.304ns 0.395826mA
+ 8.306ns 0.394102mA
+ 8.308ns 0.392386mA
+ 8.31ns 0.390676mA
+ 8.312ns 0.388975mA
+ 8.314ns 0.387281mA
+ 8.316ns 0.385594mA
+ 8.318ns 0.383915mA
+ 8.32ns 0.382243mA
+ 8.322ns 0.380578mA
+ 8.324ns 0.37892mA
+ 8.326ns 0.37727mA
+ 8.328ns 0.375627mA
+ 8.33ns 0.373991mA
+ 8.332ns 0.372362mA
+ 8.334ns 0.370741mA
+ 8.336ns 0.369125mA
+ 8.338ns 0.367518mA
+ 8.34ns 0.365917mA
+ 8.342ns 0.364323mA
+ 8.344ns 0.362737mA
+ 8.346ns 0.361157mA
+ 8.348ns 0.359584mA
+ 8.35ns 0.358018mA
+ 8.352ns 0.356458mA
+ 8.354ns 0.354906mA
+ 8.356ns 0.35336mA
+ 8.358ns 0.351821mA
+ 8.36ns 0.350289mA
+ 8.362ns 0.348763mA
+ 8.364ns 0.347244mA
+ 8.366ns 0.345732mA
+ 8.368ns 0.344226mA
+ 8.37ns 0.342727mA
+ 8.372ns 0.341234mA
+ 8.374ns 0.339748mA
+ 8.376ns 0.338268mA
+ 8.378ns 0.336795mA
+ 8.38ns 0.335328mA
+ 8.382ns 0.333868mA
+ 8.384ns 0.332413mA
+ 8.386ns 0.330966mA
+ 8.388ns 0.329524mA
+ 8.39ns 0.328089mA
+ 8.392ns 0.32666mA
+ 8.394ns 0.325237mA
+ 8.396ns 0.323821mA
+ 8.398ns 0.32241mA
+ 8.4ns 0.321006mA
+ 8.402ns 0.319607mA
+ 8.404ns 0.318216mA
+ 8.406ns 0.31683mA
+ 8.408ns 0.31545mA
+ 8.41ns 0.314076mA
+ 8.412ns 0.312708mA
+ 8.414ns 0.311346mA
+ 8.416ns 0.30999mA
+ 8.418ns 0.308639mA
+ 8.42ns 0.307295mA
+ 8.422ns 0.305957mA
+ 8.424ns 0.304624mA
+ 8.426ns 0.303298mA
+ 8.428ns 0.301976mA
+ 8.43ns 0.300661mA
+ 8.432ns 0.299352mA
+ 8.434ns 0.298048mA
+ 8.436ns 0.29675mA
+ 8.438ns 0.295457mA
+ 8.44ns 0.294171mA
+ 8.442ns 0.292889mA
+ 8.444ns 0.291613mA
+ 8.446ns 0.290343mA
+ 8.448ns 0.289079mA
+ 8.45ns 0.28782mA
+ 8.452ns 0.286566mA
+ 8.454ns 0.285317mA
+ 8.456ns 0.284075mA
+ 8.458ns 0.282837mA
+ 8.46ns 0.281606mA
+ 8.462ns 0.280379mA
+ 8.464ns 0.279158mA
+ 8.466ns 0.277942mA
+ 8.468ns 0.276731mA
+ 8.47ns 0.275526mA
+ 8.472ns 0.274326mA
+ 8.474ns 0.273131mA
+ 8.476ns 0.271941mA
+ 8.478ns 0.270757mA
+ 8.48ns 0.269577mA
+ 8.482ns 0.268403mA
+ 8.484ns 0.267234mA
+ 8.486ns 0.26607mA
+ 8.488ns 0.264911mA
+ 8.49ns 0.263758mA
+ 8.492ns 0.262609mA
+ 8.494ns 0.261465mA
+ 8.496ns 0.260326mA
+ 8.498ns 0.259192mA
+ 8.5ns 0.258063mA
+ 8.502ns 0.256939mA
+ 8.504ns 0.25582mA
+ 8.506ns 0.254706mA
+ 8.508ns 0.253596mA
+ 8.51ns 0.252492mA
+ 8.512ns 0.251392mA
+ 8.514ns 0.250297mA
+ 8.516ns 0.249207mA
+ 8.518ns 0.248121mA
+ 8.52ns 0.24704mA
+ 8.522ns 0.245964mA
+ 8.524ns 0.244893mA
+ 8.526ns 0.243826mA
+ 8.528ns 0.242764mA
+ 8.53ns 0.241707mA
+ 8.532ns 0.240654mA
+ 8.534ns 0.239606mA
+ 8.536ns 0.238562mA
+ 8.538ns 0.237523mA
+ 8.54ns 0.236488mA
+ 8.542ns 0mA
I155 291 0 PWL 0 0
+ 8.014ns 0mA
+ 8.016ns 0.0013263mA
+ 8.018ns 0.00886741mA
+ 8.02ns 0.0164121mA
+ 8.022ns 0.0239532mA
+ 8.024ns 0.0314943mA
+ 8.026ns 0.0390354mA
+ 8.028ns 0.0465765mA
+ 8.03ns 0.0541176mA
+ 8.032ns 0.0616588mA
+ 8.034ns 0.0692035mA
+ 8.036ns 0.0767446mA
+ 8.038ns 0.0842857mA
+ 8.04ns 0.0918268mA
+ 8.042ns 0.0993679mA
+ 8.044ns 0.106909mA
+ 8.046ns 0.11445mA
+ 8.048ns 0.121995mA
+ 8.05ns 0.129536mA
+ 8.052ns 0.137077mA
+ 8.054ns 0.144618mA
+ 8.056ns 0.152159mA
+ 8.058ns 0.1597mA
+ 8.06ns 0.167245mA
+ 8.062ns 0.174786mA
+ 8.064ns 0.182327mA
+ 8.066ns 0.189868mA
+ 8.068ns 0.197409mA
+ 8.07ns 0.204951mA
+ 8.072ns 0.212492mA
+ 8.074ns 0.220036mA
+ 8.076ns 0.227577mA
+ 8.078ns 0.235119mA
+ 8.08ns 0.24266mA
+ 8.082ns 0.250201mA
+ 8.084ns 0.257742mA
+ 8.086ns 0.265287mA
+ 8.088ns 0.272828mA
+ 8.09ns 0.280369mA
+ 8.092ns 0.28791mA
+ 8.094ns 0.295451mA
+ 8.096ns 0.302992mA
+ 8.098ns 0.310533mA
+ 8.1ns 0.318078mA
+ 8.102ns 0.325619mA
+ 8.104ns 0.33316mA
+ 8.106ns 0.340701mA
+ 8.108ns 0.348242mA
+ 8.11ns 0.355783mA
+ 8.112ns 0.363328mA
+ 8.114ns 0.370869mA
+ 8.116ns 0.37841mA
+ 8.118ns 0.385952mA
+ 8.12ns 0.393493mA
+ 8.122ns 0.401034mA
+ 8.124ns 0.408575mA
+ 8.126ns 0.41612mA
+ 8.128ns 0.423661mA
+ 8.13ns 0.431202mA
+ 8.132ns 0.438743mA
+ 8.134ns 0.446284mA
+ 8.136ns 0.453825mA
+ 8.138ns 0.461366mA
+ 8.14ns 0.468911mA
+ 8.142ns 0.476452mA
+ 8.144ns 0.483993mA
+ 8.146ns 0.491534mA
+ 8.148ns 0.499075mA
+ 8.15ns 0.506616mA
+ 8.152ns 0.514161mA
+ 8.154ns 0.521702mA
+ 8.156ns 0.529243mA
+ 8.158ns 0.536784mA
+ 8.16ns 0.544326mA
+ 8.162ns 0.541976mA
+ 8.164ns 0.539637mA
+ 8.166ns 0.537307mA
+ 8.168ns 0.534988mA
+ 8.17ns 0.532678mA
+ 8.172ns 0.530379mA
+ 8.174ns 0.52809mA
+ 8.176ns 0.525811mA
+ 8.178ns 0.52354mA
+ 8.18ns 0.521281mA
+ 8.182ns 0.519031mA
+ 8.184ns 0.51679mA
+ 8.186ns 0.51456mA
+ 8.188ns 0.512339mA
+ 8.19ns 0.510128mA
+ 8.192ns 0.507925mA
+ 8.194ns 0.505732mA
+ 8.196ns 0.50355mA
+ 8.198ns 0.501376mA
+ 8.2ns 0.499212mA
+ 8.202ns 0.497057mA
+ 8.204ns 0.494911mA
+ 8.206ns 0.492775mA
+ 8.208ns 0.490648mA
+ 8.21ns 0.48853mA
+ 8.212ns 0.486422mA
+ 8.214ns 0.484322mA
+ 8.216ns 0.482232mA
+ 8.218ns 0.480149mA
+ 8.22ns 0.478077mA
+ 8.222ns 0.476013mA
+ 8.224ns 0.473959mA
+ 8.226ns 0.471913mA
+ 8.228ns 0.469876mA
+ 8.23ns 0.467848mA
+ 8.232ns 0.465828mA
+ 8.234ns 0.463817mA
+ 8.236ns 0.461815mA
+ 8.238ns 0.459822mA
+ 8.24ns 0.457837mA
+ 8.242ns 0.455861mA
+ 8.244ns 0.453892mA
+ 8.246ns 0.451933mA
+ 8.248ns 0.449982mA
+ 8.25ns 0.44804mA
+ 8.252ns 0.446106mA
+ 8.254ns 0.444181mA
+ 8.256ns 0.442263mA
+ 8.258ns 0.440353mA
+ 8.26ns 0.438453mA
+ 8.262ns 0.43656mA
+ 8.264ns 0.434676mA
+ 8.266ns 0.4328mA
+ 8.268ns 0.430932mA
+ 8.27ns 0.429071mA
+ 8.272ns 0.427219mA
+ 8.274ns 0.425375mA
+ 8.276ns 0.423538mA
+ 8.278ns 0.42171mA
+ 8.28ns 0.41989mA
+ 8.282ns 0.418078mA
+ 8.284ns 0.416272mA
+ 8.286ns 0.414475mA
+ 8.288ns 0.412686mA
+ 8.29ns 0.410905mA
+ 8.292ns 0.409131mA
+ 8.294ns 0.407365mA
+ 8.296ns 0.405606mA
+ 8.298ns 0.403855mA
+ 8.3ns 0.402112mA
+ 8.302ns 0.400376mA
+ 8.304ns 0.398648mA
+ 8.306ns 0.396928mA
+ 8.308ns 0.395214mA
+ 8.31ns 0.393508mA
+ 8.312ns 0.391809mA
+ 8.314ns 0.390118mA
+ 8.316ns 0.388434mA
+ 8.318ns 0.386757mA
+ 8.32ns 0.385088mA
+ 8.322ns 0.383425mA
+ 8.324ns 0.38177mA
+ 8.326ns 0.380122mA
+ 8.328ns 0.378481mA
+ 8.33ns 0.376847mA
+ 8.332ns 0.375221mA
+ 8.334ns 0.373601mA
+ 8.336ns 0.371987mA
+ 8.338ns 0.370382mA
+ 8.34ns 0.368783mA
+ 8.342ns 0.367191mA
+ 8.344ns 0.365606mA
+ 8.346ns 0.364028mA
+ 8.348ns 0.362457mA
+ 8.35ns 0.360891mA
+ 8.352ns 0.359334mA
+ 8.354ns 0.357782mA
+ 8.356ns 0.356238mA
+ 8.358ns 0.3547mA
+ 8.36ns 0.353169mA
+ 8.362ns 0.351644mA
+ 8.364ns 0.350126mA
+ 8.366ns 0.348615mA
+ 8.368ns 0.34711mA
+ 8.37ns 0.345612mA
+ 8.372ns 0.34412mA
+ 8.374ns 0.342634mA
+ 8.376ns 0.341155mA
+ 8.378ns 0.339682mA
+ 8.38ns 0.338216mA
+ 8.382ns 0.336756mA
+ 8.384ns 0.335302mA
+ 8.386ns 0.333855mA
+ 8.388ns 0.332413mA
+ 8.39ns 0.330978mA
+ 8.392ns 0.329549mA
+ 8.394ns 0.328127mA
+ 8.396ns 0.32671mA
+ 8.398ns 0.3253mA
+ 8.4ns 0.323896mA
+ 8.402ns 0.322497mA
+ 8.404ns 0.321105mA
+ 8.406ns 0.319719mA
+ 8.408ns 0.318339mA
+ 8.41ns 0.316964mA
+ 8.412ns 0.315596mA
+ 8.414ns 0.314234mA
+ 8.416ns 0.312877mA
+ 8.418ns 0.311526mA
+ 8.42ns 0.310181mA
+ 8.422ns 0.308842mA
+ 8.424ns 0.307509mA
+ 8.426ns 0.306182mA
+ 8.428ns 0.30486mA
+ 8.43ns 0.303544mA
+ 8.432ns 0.302233mA
+ 8.434ns 0.300929mA
+ 8.436ns 0.29963mA
+ 8.438ns 0.298336mA
+ 8.44ns 0.297048mA
+ 8.442ns 0.295765mA
+ 8.444ns 0.294489mA
+ 8.446ns 0.293217mA
+ 8.448ns 0.291952mA
+ 8.45ns 0.290691mA
+ 8.452ns 0.289436mA
+ 8.454ns 0.288186mA
+ 8.456ns 0.286942mA
+ 8.458ns 0.285704mA
+ 8.46ns 0.28447mA
+ 8.462ns 0.283242mA
+ 8.464ns 0.28202mA
+ 8.466ns 0.280802mA
+ 8.468ns 0.27959mA
+ 8.47ns 0.278383mA
+ 8.472ns 0.277181mA
+ 8.474ns 0.275984mA
+ 8.476ns 0.274793mA
+ 8.478ns 0.273607mA
+ 8.48ns 0.272425mA
+ 8.482ns 0.271249mA
+ 8.484ns 0.270078mA
+ 8.486ns 0.268912mA
+ 8.488ns 0.267751mA
+ 8.49ns 0.266595mA
+ 8.492ns 0.265445mA
+ 8.494ns 0.264298mA
+ 8.496ns 0.263157mA
+ 8.498ns 0.262021mA
+ 8.5ns 0.26089mA
+ 8.502ns 0.259764mA
+ 8.504ns 0.258642mA
+ 8.506ns 0.257526mA
+ 8.508ns 0.256414mA
+ 8.51ns 0.255307mA
+ 8.512ns 0.254205mA
+ 8.514ns 0.253107mA
+ 8.516ns 0.252015mA
+ 8.518ns 0.250927mA
+ 8.52ns 0.249843mA
+ 8.522ns 0.248764mA
+ 8.524ns 0.24769mA
+ 8.526ns 0.246621mA
+ 8.528ns 0.245557mA
+ 8.53ns 0.244496mA
+ 8.532ns 0.243441mA
+ 8.534ns 0.24239mA
+ 8.536ns 0.241343mA
+ 8.538ns 0.240301mA
+ 8.54ns 0.239264mA
+ 8.542ns 0.238231mA
+ 8.544ns 0.237203mA
+ 8.546ns 0.236178mA
+ 8.548ns 0.235158mA
+ 8.55ns 0.234143mA
+ 8.552ns 0.233133mA
+ 8.554ns 0mA
I156 293 0 PWL 0 0
+ 5.516ns 0mA
+ 5.518ns 0.00486783mA
+ 5.52ns 0.0123753mA
+ 5.522ns 0.0198828mA
+ 5.524ns 0.0273921mA
+ 5.526ns 0.0348996mA
+ 5.528ns 0.0424071mA
+ 5.53ns 0.0499164mA
+ 5.532ns 0.0574238mA
+ 5.534ns 0.0649313mA
+ 5.536ns 0.0724406mA
+ 5.538ns 0.0799481mA
+ 5.54ns 0.0874556mA
+ 5.542ns 0.0949649mA
+ 5.544ns 0.102472mA
+ 5.546ns 0.10998mA
+ 5.548ns 0.117487mA
+ 5.55ns 0.124997mA
+ 5.552ns 0.132504mA
+ 5.554ns 0.140012mA
+ 5.556ns 0.147521mA
+ 5.558ns 0.155028mA
+ 5.56ns 0.162536mA
+ 5.562ns 0.170045mA
+ 5.564ns 0.177553mA
+ 5.566ns 0.18506mA
+ 5.568ns 0.192568mA
+ 5.57ns 0.200077mA
+ 5.572ns 0.207584mA
+ 5.574ns 0.215092mA
+ 5.576ns 0.222601mA
+ 5.578ns 0.230109mA
+ 5.58ns 0.237616mA
+ 5.582ns 0.245125mA
+ 5.584ns 0.252633mA
+ 5.586ns 0.26014mA
+ 5.588ns 0.26765mA
+ 5.59ns 0.275157mA
+ 5.592ns 0.282665mA
+ 5.594ns 0.290172mA
+ 5.596ns 0.297681mA
+ 5.598ns 0.305189mA
+ 5.6ns 0.312696mA
+ 5.602ns 0.320206mA
+ 5.604ns 0.327713mA
+ 5.606ns 0.335221mA
+ 5.608ns 0.34273mA
+ 5.61ns 0.350237mA
+ 5.612ns 0.357745mA
+ 5.614ns 0.365252mA
+ 5.616ns 0.372762mA
+ 5.618ns 0.380269mA
+ 5.62ns 0.387777mA
+ 5.622ns 0.395286mA
+ 5.624ns 0.402793mA
+ 5.626ns 0.410301mA
+ 5.628ns 0.41781mA
+ 5.63ns 0.425318mA
+ 5.632ns 0.432825mA
+ 5.634ns 0.440335mA
+ 5.636ns 0.447842mA
+ 5.638ns 0.45535mA
+ 5.64ns 0.462857mA
+ 5.642ns 0.470366mA
+ 5.644ns 0.477874mA
+ 5.646ns 0.485381mA
+ 5.648ns 0.492891mA
+ 5.65ns 0.500398mA
+ 5.652ns 0.507906mA
+ 5.654ns 0.515415mA
+ 5.656ns 0.522922mA
+ 5.658ns 0.53043mA
+ 5.66ns 0.537937mA
+ 5.662ns 0.54298mA
+ 5.664ns 0.540631mA
+ 5.666ns 0.538292mA
+ 5.668ns 0.535963mA
+ 5.67ns 0.533645mA
+ 5.672ns 0.531336mA
+ 5.674ns 0.529037mA
+ 5.676ns 0.526748mA
+ 5.678ns 0.52447mA
+ 5.68ns 0.5222mA
+ 5.682ns 0.519942mA
+ 5.684ns 0.517692mA
+ 5.686ns 0.515453mA
+ 5.688ns 0.513222mA
+ 5.69ns 0.511002mA
+ 5.692ns 0.508792mA
+ 5.694ns 0.50659mA
+ 5.696ns 0.504399mA
+ 5.698ns 0.502217mA
+ 5.7ns 0.500044mA
+ 5.702ns 0.497881mA
+ 5.704ns 0.495727mA
+ 5.706ns 0.493582mA
+ 5.708ns 0.491447mA
+ 5.71ns 0.489321mA
+ 5.712ns 0.487204mA
+ 5.714ns 0.485096mA
+ 5.716ns 0.482997mA
+ 5.718ns 0.480908mA
+ 5.72ns 0.478827mA
+ 5.722ns 0.476755mA
+ 5.724ns 0.474693mA
+ 5.726ns 0.472639mA
+ 5.728ns 0.470594mA
+ 5.73ns 0.468559mA
+ 5.732ns 0.466532mA
+ 5.734ns 0.464513mA
+ 5.736ns 0.462503mA
+ 5.738ns 0.460503mA
+ 5.74ns 0.45851mA
+ 5.742ns 0.456526mA
+ 5.744ns 0.454551mA
+ 5.746ns 0.452585mA
+ 5.748ns 0.450627mA
+ 5.75ns 0.448677mA
+ 5.752ns 0.446736mA
+ 5.754ns 0.444803mA
+ 5.756ns 0.442879mA
+ 5.758ns 0.440963mA
+ 5.76ns 0.439055mA
+ 5.762ns 0.437156mA
+ 5.764ns 0.435264mA
+ 5.766ns 0.433381mA
+ 5.768ns 0.431506mA
+ 5.77ns 0.429639mA
+ 5.772ns 0.42778mA
+ 5.774ns 0.42593mA
+ 5.776ns 0.424087mA
+ 5.778ns 0.422252mA
+ 5.78ns 0.420425mA
+ 5.782ns 0.418606mA
+ 5.784ns 0.416795mA
+ 5.786ns 0.414992mA
+ 5.788ns 0.413197mA
+ 5.79ns 0.411409mA
+ 5.792ns 0.409629mA
+ 5.794ns 0.407857mA
+ 5.796ns 0.406092mA
+ 5.798ns 0.404335mA
+ 5.8ns 0.402586mA
+ 5.802ns 0.400844mA
+ 5.804ns 0.39911mA
+ 5.806ns 0.397383mA
+ 5.808ns 0.395664mA
+ 5.81ns 0.393952mA
+ 5.812ns 0.392247mA
+ 5.814ns 0.39055mA
+ 5.816ns 0.388861mA
+ 5.818ns 0.387178mA
+ 5.82ns 0.385503mA
+ 5.822ns 0.383835mA
+ 5.824ns 0.382175mA
+ 5.826ns 0.380521mA
+ 5.828ns 0.378875mA
+ 5.83ns 0.377236mA
+ 5.832ns 0.375603mA
+ 5.834ns 0.373978mA
+ 5.836ns 0.37236mA
+ 5.838ns 0.370749mA
+ 5.84ns 0.369145mA
+ 5.842ns 0.367548mA
+ 5.844ns 0.365958mA
+ 5.846ns 0.364374mA
+ 5.848ns 0.362798mA
+ 5.85ns 0.361229mA
+ 5.852ns 0.359665mA
+ 5.854ns 0.358109mA
+ 5.856ns 0.35656mA
+ 5.858ns 0.355017mA
+ 5.86ns 0.353481mA
+ 5.862ns 0.351952mA
+ 5.864ns 0.350429mA
+ 5.866ns 0.348913mA
+ 5.868ns 0.347403mA
+ 5.87ns 0.3459mA
+ 5.872ns 0.344404mA
+ 5.874ns 0.342914mA
+ 5.876ns 0.34143mA
+ 5.878ns 0.339952mA
+ 5.88ns 0.338482mA
+ 5.882ns 0.337017mA
+ 5.884ns 0.335559mA
+ 5.886ns 0.334107mA
+ 5.888ns 0.332662mA
+ 5.89ns 0.331223mA
+ 5.892ns 0.329789mA
+ 5.894ns 0.328362mA
+ 5.896ns 0.326942mA
+ 5.898ns 0.325527mA
+ 5.9ns 0.324119mA
+ 5.902ns 0.322716mA
+ 5.904ns 0.32132mA
+ 5.906ns 0.31993mA
+ 5.908ns 0.318545mA
+ 5.91ns 0.317167mA
+ 5.912ns 0.315795mA
+ 5.914ns 0.314429mA
+ 5.916ns 0.313068mA
+ 5.918ns 0.311713mA
+ 5.92ns 0.310365mA
+ 5.922ns 0.309022mA
+ 5.924ns 0.307685mA
+ 5.926ns 0.306354mA
+ 5.928ns 0.305028mA
+ 5.93ns 0.303708mA
+ 5.932ns 0.302394mA
+ 5.934ns 0.301086mA
+ 5.936ns 0.299783mA
+ 5.938ns 0.298486mA
+ 5.94ns 0.297194mA
+ 5.942ns 0.295909mA
+ 5.944ns 0.294628mA
+ 5.946ns 0.293353mA
+ 5.948ns 0.292084mA
+ 5.95ns 0.29082mA
+ 5.952ns 0.289562mA
+ 5.954ns 0.288309mA
+ 5.956ns 0.287062mA
+ 5.958ns 0.28582mA
+ 5.96ns 0.284583mA
+ 5.962ns 0.283352mA
+ 5.964ns 0.282125mA
+ 5.966ns 0.280905mA
+ 5.968ns 0.279689mA
+ 5.97ns 0.278479mA
+ 5.972ns 0.277274mA
+ 5.974ns 0.276075mA
+ 5.976ns 0.27488mA
+ 5.978ns 0.273691mA
+ 5.98ns 0.272506mA
+ 5.982ns 0.271327mA
+ 5.984ns 0.270153mA
+ 5.986ns 0.268984mA
+ 5.988ns 0.267821mA
+ 5.99ns 0.266662mA
+ 5.992ns 0.265508mA
+ 5.994ns 0.264359mA
+ 5.996ns 0.263215mA
+ 5.998ns 0.262076mA
+ 6ns 0.260942mA
+ 6.002ns 0.259813mA
+ 6.004ns 0.258689mA
+ 6.006ns 0.25757mA
+ 6.008ns 0.256455mA
+ 6.01ns 0.255345mA
+ 6.012ns 0.254241mA
+ 6.014ns 0.253141mA
+ 6.016ns 0.252045mA
+ 6.018ns 0.250955mA
+ 6.02ns 0.249869mA
+ 6.022ns 0.248788mA
+ 6.024ns 0.247711mA
+ 6.026ns 0.246639mA
+ 6.028ns 0.245572mA
+ 6.03ns 0.244509mA
+ 6.032ns 0.243451mA
+ 6.034ns 0.242398mA
+ 6.036ns 0.241349mA
+ 6.038ns 0.240305mA
+ 6.04ns 0.239265mA
+ 6.042ns 0.23823mA
+ 6.044ns 0.237199mA
+ 6.046ns 0.236173mA
+ 6.048ns 0.235151mA
+ 6.05ns 0.234133mA
+ 6.052ns 0.23312mA
+ 6.054ns 0mA
I157 294 0 PWL 0 0
+ 0.486ns 0mA
+ 0.488ns 0.00105748mA
+ 0.49ns 0.00869311mA
+ 0.492ns 0.0163289mA
+ 0.494ns 0.0239646mA
+ 0.496ns 0.0316003mA
+ 0.498ns 0.0392361mA
+ 0.5ns 0.0468717mA
+ 0.502ns 0.0545076mA
+ 0.504ns 0.0621432mA
+ 0.506ns 0.069779mA
+ 0.508ns 0.0774147mA
+ 0.51ns 0.0850505mA
+ 0.512ns 0.0926862mA
+ 0.514ns 0.100322mA
+ 0.516ns 0.107958mA
+ 0.518ns 0.115593mA
+ 0.52ns 0.123229mA
+ 0.522ns 0.130865mA
+ 0.524ns 0.138501mA
+ 0.526ns 0.146136mA
+ 0.528ns 0.153772mA
+ 0.53ns 0.161408mA
+ 0.532ns 0.169043mA
+ 0.534ns 0.176679mA
+ 0.536ns 0.184315mA
+ 0.538ns 0.191951mA
+ 0.54ns 0.199586mA
+ 0.542ns 0.207222mA
+ 0.544ns 0.214858mA
+ 0.546ns 0.222493mA
+ 0.548ns 0.230129mA
+ 0.55ns 0.237765mA
+ 0.552ns 0.245401mA
+ 0.554ns 0.253036mA
+ 0.556ns 0.260672mA
+ 0.558ns 0.268308mA
+ 0.56ns 0.275944mA
+ 0.562ns 0.283579mA
+ 0.564ns 0.291215mA
+ 0.566ns 0.298851mA
+ 0.568ns 0.306486mA
+ 0.57ns 0.314122mA
+ 0.572ns 0.321758mA
+ 0.574ns 0.329394mA
+ 0.576ns 0.337029mA
+ 0.578ns 0.344665mA
+ 0.58ns 0.352301mA
+ 0.582ns 0.359937mA
+ 0.584ns 0.367572mA
+ 0.586ns 0.375208mA
+ 0.588ns 0.382844mA
+ 0.59ns 0.39048mA
+ 0.592ns 0.398115mA
+ 0.594ns 0.405751mA
+ 0.596ns 0.413387mA
+ 0.598ns 0.421023mA
+ 0.6ns 0.428658mA
+ 0.602ns 0.436294mA
+ 0.604ns 0.44393mA
+ 0.606ns 0.451565mA
+ 0.608ns 0.459201mA
+ 0.61ns 0.466837mA
+ 0.612ns 0.474473mA
+ 0.614ns 0.482108mA
+ 0.616ns 0.489744mA
+ 0.618ns 0.49738mA
+ 0.62ns 0.505015mA
+ 0.622ns 0.512651mA
+ 0.624ns 0.520287mA
+ 0.626ns 0.527923mA
+ 0.628ns 0.535558mA
+ 0.63ns 0.543194mA
+ 0.632ns 0.55083mA
+ 0.634ns 0.549421mA
+ 0.636ns 0.547017mA
+ 0.638ns 0.544624mA
+ 0.64ns 0.542242mA
+ 0.642ns 0.53987mA
+ 0.644ns 0.537508mA
+ 0.646ns 0.535157mA
+ 0.648ns 0.532815mA
+ 0.65ns 0.530484mA
+ 0.652ns 0.528164mA
+ 0.654ns 0.525853mA
+ 0.656ns 0.523553mA
+ 0.658ns 0.521262mA
+ 0.66ns 0.518982mA
+ 0.662ns 0.516712mA
+ 0.664ns 0.514451mA
+ 0.666ns 0.512201mA
+ 0.668ns 0.50996mA
+ 0.67ns 0.507729mA
+ 0.672ns 0.505508mA
+ 0.674ns 0.503296mA
+ 0.676ns 0.501094mA
+ 0.678ns 0.498902mA
+ 0.68ns 0.49672mA
+ 0.682ns 0.494547mA
+ 0.684ns 0.492383mA
+ 0.686ns 0.490229mA
+ 0.688ns 0.488084mA
+ 0.69ns 0.485949mA
+ 0.692ns 0.483823mA
+ 0.694ns 0.481707mA
+ 0.696ns 0.479599mA
+ 0.698ns 0.477501mA
+ 0.7ns 0.475412mA
+ 0.702ns 0.473332mA
+ 0.704ns 0.471261mA
+ 0.706ns 0.4692mA
+ 0.708ns 0.467147mA
+ 0.71ns 0.465103mA
+ 0.712ns 0.463069mA
+ 0.714ns 0.461043mA
+ 0.716ns 0.459026mA
+ 0.718ns 0.457018mA
+ 0.72ns 0.455018mA
+ 0.722ns 0.453028mA
+ 0.724ns 0.451046mA
+ 0.726ns 0.449072mA
+ 0.728ns 0.447108mA
+ 0.73ns 0.445152mA
+ 0.732ns 0.443204mA
+ 0.734ns 0.441265mA
+ 0.736ns 0.439335mA
+ 0.738ns 0.437413mA
+ 0.74ns 0.435499mA
+ 0.742ns 0.433594mA
+ 0.744ns 0.431697mA
+ 0.746ns 0.429808mA
+ 0.748ns 0.427928mA
+ 0.75ns 0.426056mA
+ 0.752ns 0.424192mA
+ 0.754ns 0.422336mA
+ 0.756ns 0.420488mA
+ 0.758ns 0.418649mA
+ 0.76ns 0.416817mA
+ 0.762ns 0.414993mA
+ 0.764ns 0.413178mA
+ 0.766ns 0.41137mA
+ 0.768ns 0.409571mA
+ 0.77ns 0.407779mA
+ 0.772ns 0.405995mA
+ 0.774ns 0.404218mA
+ 0.776ns 0.40245mA
+ 0.778ns 0.400689mA
+ 0.78ns 0.398936mA
+ 0.782ns 0.397191mA
+ 0.784ns 0.395453mA
+ 0.786ns 0.393723mA
+ 0.788ns 0.392mA
+ 0.79ns 0.390285mA
+ 0.792ns 0.388578mA
+ 0.794ns 0.386878mA
+ 0.796ns 0.385185mA
+ 0.798ns 0.3835mA
+ 0.8ns 0.381822mA
+ 0.802ns 0.380152mA
+ 0.804ns 0.378489mA
+ 0.806ns 0.376833mA
+ 0.808ns 0.375184mA
+ 0.81ns 0.373543mA
+ 0.812ns 0.371908mA
+ 0.814ns 0.370281mA
+ 0.816ns 0.368661mA
+ 0.818ns 0.367048mA
+ 0.82ns 0.365442mA
+ 0.822ns 0.363844mA
+ 0.824ns 0.362252mA
+ 0.826ns 0.360667mA
+ 0.828ns 0.359089mA
+ 0.83ns 0.357518mA
+ 0.832ns 0.355954mA
+ 0.834ns 0.354396mA
+ 0.836ns 0.352846mA
+ 0.838ns 0.351302mA
+ 0.84ns 0.349765mA
+ 0.842ns 0.348235mA
+ 0.844ns 0.346711mA
+ 0.846ns 0.345194mA
+ 0.848ns 0.343684mA
+ 0.85ns 0.34218mA
+ 0.852ns 0.340683mA
+ 0.854ns 0.339193mA
+ 0.856ns 0.337709mA
+ 0.858ns 0.336231mA
+ 0.86ns 0.33476mA
+ 0.862ns 0.333295mA
+ 0.864ns 0.331837mA
+ 0.866ns 0.330385mA
+ 0.868ns 0.32894mA
+ 0.87ns 0.327501mA
+ 0.872ns 0.326068mA
+ 0.874ns 0.324641mA
+ 0.876ns 0.323221mA
+ 0.878ns 0.321806mA
+ 0.88ns 0.320398mA
+ 0.882ns 0.318997mA
+ 0.884ns 0.317601mA
+ 0.886ns 0.316211mA
+ 0.888ns 0.314828mA
+ 0.89ns 0.31345mA
+ 0.892ns 0.312079mA
+ 0.894ns 0.310714mA
+ 0.896ns 0.309354mA
+ 0.898ns 0.308001mA
+ 0.9ns 0.306653mA
+ 0.902ns 0.305311mA
+ 0.904ns 0.303976mA
+ 0.906ns 0.302646mA
+ 0.908ns 0.301321mA
+ 0.91ns 0.300003mA
+ 0.912ns 0.29869mA
+ 0.914ns 0.297384mA
+ 0.916ns 0.296082mA
+ 0.918ns 0.294787mA
+ 0.92ns 0.293497mA
+ 0.922ns 0.292213mA
+ 0.924ns 0.290934mA
+ 0.926ns 0.289661mA
+ 0.928ns 0.288394mA
+ 0.93ns 0.287132mA
+ 0.932ns 0.285876mA
+ 0.934ns 0.284625mA
+ 0.936ns 0.28338mA
+ 0.938ns 0.28214mA
+ 0.94ns 0.280905mA
+ 0.942ns 0.279676mA
+ 0.944ns 0.278453mA
+ 0.946ns 0.277234mA
+ 0.948ns 0.276021mA
+ 0.95ns 0.274814mA
+ 0.952ns 0.273611mA
+ 0.954ns 0.272414mA
+ 0.956ns 0.271222mA
+ 0.958ns 0.270035mA
+ 0.96ns 0.268854mA
+ 0.962ns 0.267678mA
+ 0.964ns 0.266506mA
+ 0.966ns 0.26534mA
+ 0.968ns 0.264179mA
+ 0.97ns 0.263023mA
+ 0.972ns 0.261873mA
+ 0.974ns 0.260727mA
+ 0.976ns 0.259586mA
+ 0.978ns 0.25845mA
+ 0.98ns 0.257319mA
+ 0.982ns 0.256193mA
+ 0.984ns 0.255072mA
+ 0.986ns 0.253956mA
+ 0.988ns 0.252845mA
+ 0.99ns 0.251739mA
+ 0.992ns 0.250637mA
+ 0.994ns 0.249541mA
+ 0.996ns 0.248449mA
+ 0.998ns 0.247362mA
+ 1ns 0.246279mA
+ 1.002ns 0.245202mA
+ 1.004ns 0.244129mA
+ 1.006ns 0.243061mA
+ 1.008ns 0.241997mA
+ 1.01ns 0.240938mA
+ 1.012ns 0.239884mA
+ 1.014ns 0.238835mA
+ 1.016ns 0.237789mA
+ 1.018ns 0.236749mA
+ 1.02ns 0.235713mA
+ 1.022ns 0mA
+ 5.486ns 0mA
+ 5.488ns 0.00105794mA
+ 5.49ns 0.00869493mA
+ 5.492ns 0.0163301mA
+ 5.494ns 0.0239653mA
+ 5.496ns 0.0316023mA
+ 5.498ns 0.0392374mA
+ 5.5ns 0.0468726mA
+ 5.502ns 0.0545078mA
+ 5.504ns 0.0621448mA
+ 5.506ns 0.06978mA
+ 5.508ns 0.0774151mA
+ 5.51ns 0.0850521mA
+ 5.512ns 0.0926873mA
+ 5.514ns 0.100322mA
+ 5.516ns 0.107959mA
+ 5.518ns 0.115595mA
+ 5.52ns 0.12323mA
+ 5.522ns 0.130865mA
+ 5.524ns 0.138502mA
+ 5.526ns 0.146137mA
+ 5.528ns 0.153772mA
+ 5.53ns 0.161409mA
+ 5.532ns 0.169044mA
+ 5.534ns 0.17668mA
+ 5.536ns 0.184317mA
+ 5.538ns 0.191952mA
+ 5.54ns 0.199587mA
+ 5.542ns 0.207224mA
+ 5.544ns 0.214859mA
+ 5.546ns 0.222494mA
+ 5.548ns 0.23013mA
+ 5.55ns 0.237767mA
+ 5.552ns 0.245402mA
+ 5.554ns 0.253037mA
+ 5.556ns 0.260674mA
+ 5.558ns 0.268309mA
+ 5.56ns 0.275944mA
+ 5.562ns 0.283581mA
+ 5.564ns 0.291216mA
+ 5.566ns 0.298852mA
+ 5.568ns 0.306487mA
+ 5.57ns 0.314124mA
+ 5.572ns 0.321759mA
+ 5.574ns 0.329394mA
+ 5.576ns 0.337031mA
+ 5.578ns 0.344666mA
+ 5.58ns 0.352301mA
+ 5.582ns 0.359938mA
+ 5.584ns 0.367574mA
+ 5.586ns 0.375209mA
+ 5.588ns 0.382846mA
+ 5.59ns 0.390481mA
+ 5.592ns 0.398116mA
+ 5.594ns 0.405751mA
+ 5.596ns 0.413388mA
+ 5.598ns 0.421023mA
+ 5.6ns 0.428659mA
+ 5.602ns 0.436296mA
+ 5.604ns 0.443931mA
+ 5.606ns 0.451566mA
+ 5.608ns 0.459203mA
+ 5.61ns 0.466838mA
+ 5.612ns 0.474473mA
+ 5.614ns 0.482108mA
+ 5.616ns 0.489745mA
+ 5.618ns 0.497381mA
+ 5.62ns 0.505016mA
+ 5.622ns 0.512653mA
+ 5.624ns 0.520288mA
+ 5.626ns 0.527923mA
+ 5.628ns 0.53556mA
+ 5.63ns 0.543195mA
+ 5.632ns 0.55083mA
+ 5.634ns 0.54942mA
+ 5.636ns 0.547017mA
+ 5.638ns 0.544624mA
+ 5.64ns 0.542242mA
+ 5.642ns 0.539869mA
+ 5.644ns 0.537508mA
+ 5.646ns 0.535156mA
+ 5.648ns 0.532815mA
+ 5.65ns 0.530484mA
+ 5.652ns 0.528164mA
+ 5.654ns 0.525853mA
+ 5.656ns 0.523552mA
+ 5.658ns 0.521262mA
+ 5.66ns 0.518982mA
+ 5.662ns 0.516711mA
+ 5.664ns 0.514451mA
+ 5.666ns 0.5122mA
+ 5.668ns 0.509959mA
+ 5.67ns 0.507729mA
+ 5.672ns 0.505508mA
+ 5.674ns 0.503296mA
+ 5.676ns 0.501094mA
+ 5.678ns 0.498902mA
+ 5.68ns 0.496719mA
+ 5.682ns 0.494546mA
+ 5.684ns 0.492383mA
+ 5.686ns 0.490229mA
+ 5.688ns 0.488084mA
+ 5.69ns 0.485949mA
+ 5.692ns 0.483823mA
+ 5.694ns 0.481706mA
+ 5.696ns 0.479599mA
+ 5.698ns 0.477501mA
+ 5.7ns 0.475412mA
+ 5.702ns 0.473332mA
+ 5.704ns 0.471261mA
+ 5.706ns 0.4692mA
+ 5.708ns 0.467147mA
+ 5.71ns 0.465103mA
+ 5.712ns 0.463069mA
+ 5.714ns 0.461042mA
+ 5.716ns 0.459026mA
+ 5.718ns 0.457017mA
+ 5.72ns 0.455018mA
+ 5.722ns 0.453027mA
+ 5.724ns 0.451045mA
+ 5.726ns 0.449072mA
+ 5.728ns 0.447107mA
+ 5.73ns 0.445151mA
+ 5.732ns 0.443204mA
+ 5.734ns 0.441265mA
+ 5.736ns 0.439334mA
+ 5.738ns 0.437413mA
+ 5.74ns 0.435499mA
+ 5.742ns 0.433594mA
+ 5.744ns 0.431697mA
+ 5.746ns 0.429808mA
+ 5.748ns 0.427927mA
+ 5.75ns 0.426055mA
+ 5.752ns 0.424192mA
+ 5.754ns 0.422336mA
+ 5.756ns 0.420488mA
+ 5.758ns 0.418648mA
+ 5.76ns 0.416817mA
+ 5.762ns 0.414993mA
+ 5.764ns 0.413178mA
+ 5.766ns 0.41137mA
+ 5.768ns 0.40957mA
+ 5.77ns 0.407778mA
+ 5.772ns 0.405994mA
+ 5.774ns 0.404218mA
+ 5.776ns 0.40245mA
+ 5.778ns 0.400689mA
+ 5.78ns 0.398936mA
+ 5.782ns 0.397191mA
+ 5.784ns 0.395453mA
+ 5.786ns 0.393723mA
+ 5.788ns 0.392mA
+ 5.79ns 0.390285mA
+ 5.792ns 0.388578mA
+ 5.794ns 0.386878mA
+ 5.796ns 0.385185mA
+ 5.798ns 0.3835mA
+ 5.8ns 0.381822mA
+ 5.802ns 0.380152mA
+ 5.804ns 0.378489mA
+ 5.806ns 0.376832mA
+ 5.808ns 0.375184mA
+ 5.81ns 0.373542mA
+ 5.812ns 0.371908mA
+ 5.814ns 0.370281mA
+ 5.816ns 0.368661mA
+ 5.818ns 0.367048mA
+ 5.82ns 0.365442mA
+ 5.822ns 0.363843mA
+ 5.824ns 0.362252mA
+ 5.826ns 0.360666mA
+ 5.828ns 0.359089mA
+ 5.83ns 0.357518mA
+ 5.832ns 0.355953mA
+ 5.834ns 0.354396mA
+ 5.836ns 0.352846mA
+ 5.838ns 0.351302mA
+ 5.84ns 0.349765mA
+ 5.842ns 0.348235mA
+ 5.844ns 0.346711mA
+ 5.846ns 0.345194mA
+ 5.848ns 0.343684mA
+ 5.85ns 0.34218mA
+ 5.852ns 0.340683mA
+ 5.854ns 0.339192mA
+ 5.856ns 0.337708mA
+ 5.858ns 0.336231mA
+ 5.86ns 0.33476mA
+ 5.862ns 0.333295mA
+ 5.864ns 0.331837mA
+ 5.866ns 0.330385mA
+ 5.868ns 0.32894mA
+ 5.87ns 0.3275mA
+ 5.872ns 0.326067mA
+ 5.874ns 0.324641mA
+ 5.876ns 0.323221mA
+ 5.878ns 0.321806mA
+ 5.88ns 0.320398mA
+ 5.882ns 0.318997mA
+ 5.884ns 0.317601mA
+ 5.886ns 0.316211mA
+ 5.888ns 0.314828mA
+ 5.89ns 0.31345mA
+ 5.892ns 0.312079mA
+ 5.894ns 0.310713mA
+ 5.896ns 0.309354mA
+ 5.898ns 0.308mA
+ 5.9ns 0.306653mA
+ 5.902ns 0.305311mA
+ 5.904ns 0.303975mA
+ 5.906ns 0.302645mA
+ 5.908ns 0.301321mA
+ 5.91ns 0.300003mA
+ 5.912ns 0.29869mA
+ 5.914ns 0.297383mA
+ 5.916ns 0.296082mA
+ 5.918ns 0.294787mA
+ 5.92ns 0.293497mA
+ 5.922ns 0.292213mA
+ 5.924ns 0.290934mA
+ 5.926ns 0.289661mA
+ 5.928ns 0.288394mA
+ 5.93ns 0.287132mA
+ 5.932ns 0.285876mA
+ 5.934ns 0.284625mA
+ 5.936ns 0.28338mA
+ 5.938ns 0.28214mA
+ 5.94ns 0.280905mA
+ 5.942ns 0.279676mA
+ 5.944ns 0.278452mA
+ 5.946ns 0.277234mA
+ 5.948ns 0.276021mA
+ 5.95ns 0.274813mA
+ 5.952ns 0.273611mA
+ 5.954ns 0.272414mA
+ 5.956ns 0.271222mA
+ 5.958ns 0.270035mA
+ 5.96ns 0.268854mA
+ 5.962ns 0.267678mA
+ 5.964ns 0.266506mA
+ 5.966ns 0.26534mA
+ 5.968ns 0.264179mA
+ 5.97ns 0.263023mA
+ 5.972ns 0.261872mA
+ 5.974ns 0.260727mA
+ 5.976ns 0.259586mA
+ 5.978ns 0.25845mA
+ 5.98ns 0.257319mA
+ 5.982ns 0.256193mA
+ 5.984ns 0.255072mA
+ 5.986ns 0.253956mA
+ 5.988ns 0.252845mA
+ 5.99ns 0.251739mA
+ 5.992ns 0.250637mA
+ 5.994ns 0.249541mA
+ 5.996ns 0.248449mA
+ 5.998ns 0.247362mA
+ 6ns 0.246279mA
+ 6.002ns 0.245202mA
+ 6.004ns 0.244129mA
+ 6.006ns 0.243061mA
+ 6.008ns 0.241997mA
+ 6.01ns 0.240938mA
+ 6.012ns 0.239884mA
+ 6.014ns 0.238834mA
+ 6.016ns 0.237789mA
+ 6.018ns 0.236749mA
+ 6.02ns 0.235713mA
+ 6.022ns 0mA
I158 295 0 PWL 0 0
+ 5.486ns 0mA
+ 5.488ns 0.00126972mA
+ 5.49ns 0.00889939mA
+ 5.492ns 0.0165273mA
+ 5.494ns 0.0241551mA
+ 5.496ns 0.0317848mA
+ 5.498ns 0.0394126mA
+ 5.5ns 0.0470405mA
+ 5.502ns 0.0546684mA
+ 5.504ns 0.062298mA
+ 5.506ns 0.0699259mA
+ 5.508ns 0.0775537mA
+ 5.51ns 0.0851834mA
+ 5.512ns 0.0928113mA
+ 5.514ns 0.100439mA
+ 5.516ns 0.108069mA
+ 5.518ns 0.115697mA
+ 5.52ns 0.123325mA
+ 5.522ns 0.130952mA
+ 5.524ns 0.138582mA
+ 5.526ns 0.14621mA
+ 5.528ns 0.153838mA
+ 5.53ns 0.161467mA
+ 5.532ns 0.169095mA
+ 5.534ns 0.176723mA
+ 5.536ns 0.184353mA
+ 5.538ns 0.191981mA
+ 5.54ns 0.199609mA
+ 5.542ns 0.207238mA
+ 5.544ns 0.214866mA
+ 5.546ns 0.222494mA
+ 5.548ns 0.230122mA
+ 5.55ns 0.237751mA
+ 5.552ns 0.245379mA
+ 5.554ns 0.253007mA
+ 5.556ns 0.260637mA
+ 5.558ns 0.268265mA
+ 5.56ns 0.275893mA
+ 5.562ns 0.283522mA
+ 5.564ns 0.29115mA
+ 5.566ns 0.298778mA
+ 5.568ns 0.306406mA
+ 5.57ns 0.314036mA
+ 5.572ns 0.321663mA
+ 5.574ns 0.329291mA
+ 5.576ns 0.336921mA
+ 5.578ns 0.344549mA
+ 5.58ns 0.352177mA
+ 5.582ns 0.359806mA
+ 5.584ns 0.367434mA
+ 5.586ns 0.375062mA
+ 5.588ns 0.382692mA
+ 5.59ns 0.39032mA
+ 5.592ns 0.397947mA
+ 5.594ns 0.405575mA
+ 5.596ns 0.413205mA
+ 5.598ns 0.420833mA
+ 5.6ns 0.428461mA
+ 5.602ns 0.43609mA
+ 5.604ns 0.443718mA
+ 5.606ns 0.451346mA
+ 5.608ns 0.458976mA
+ 5.61ns 0.466604mA
+ 5.612ns 0.474231mA
+ 5.614ns 0.481859mA
+ 5.616ns 0.489489mA
+ 5.618ns 0.497117mA
+ 5.62ns 0.504745mA
+ 5.622ns 0.512374mA
+ 5.624ns 0.520002mA
+ 5.626ns 0.52763mA
+ 5.628ns 0.53526mA
+ 5.63ns 0.542888mA
+ 5.632ns 0.550515mA
+ 5.634ns 0.549607mA
+ 5.636ns 0.547203mA
+ 5.638ns 0.544809mA
+ 5.64ns 0.542426mA
+ 5.642ns 0.540053mA
+ 5.644ns 0.537691mA
+ 5.646ns 0.535339mA
+ 5.648ns 0.532996mA
+ 5.65ns 0.530665mA
+ 5.652ns 0.528344mA
+ 5.654ns 0.526032mA
+ 5.656ns 0.523731mA
+ 5.658ns 0.52144mA
+ 5.66ns 0.519159mA
+ 5.662ns 0.516888mA
+ 5.664ns 0.514627mA
+ 5.666ns 0.512375mA
+ 5.668ns 0.510134mA
+ 5.67ns 0.507902mA
+ 5.672ns 0.505681mA
+ 5.674ns 0.503468mA
+ 5.676ns 0.501266mA
+ 5.678ns 0.499073mA
+ 5.68ns 0.496889mA
+ 5.682ns 0.494716mA
+ 5.684ns 0.492552mA
+ 5.686ns 0.490397mA
+ 5.688ns 0.488251mA
+ 5.69ns 0.486116mA
+ 5.692ns 0.483989mA
+ 5.694ns 0.481872mA
+ 5.696ns 0.479764mA
+ 5.698ns 0.477665mA
+ 5.7ns 0.475575mA
+ 5.702ns 0.473495mA
+ 5.704ns 0.471423mA
+ 5.706ns 0.469361mA
+ 5.708ns 0.467308mA
+ 5.71ns 0.465263mA
+ 5.712ns 0.463228mA
+ 5.714ns 0.461201mA
+ 5.716ns 0.459184mA
+ 5.718ns 0.457175mA
+ 5.72ns 0.455175mA
+ 5.722ns 0.453184mA
+ 5.724ns 0.451201mA
+ 5.726ns 0.449227mA
+ 5.728ns 0.447262mA
+ 5.73ns 0.445305mA
+ 5.732ns 0.443357mA
+ 5.734ns 0.441418mA
+ 5.736ns 0.439487mA
+ 5.738ns 0.437564mA
+ 5.74ns 0.43565mA
+ 5.742ns 0.433744mA
+ 5.744ns 0.431846mA
+ 5.746ns 0.429957mA
+ 5.748ns 0.428076mA
+ 5.75ns 0.426203mA
+ 5.752ns 0.424339mA
+ 5.754ns 0.422482mA
+ 5.756ns 0.420634mA
+ 5.758ns 0.418794mA
+ 5.76ns 0.416962mA
+ 5.762ns 0.415138mA
+ 5.764ns 0.413322mA
+ 5.766ns 0.411513mA
+ 5.768ns 0.409713mA
+ 5.77ns 0.407921mA
+ 5.772ns 0.406136mA
+ 5.774ns 0.404359mA
+ 5.776ns 0.40259mA
+ 5.778ns 0.400829mA
+ 5.78ns 0.399075mA
+ 5.782ns 0.397329mA
+ 5.784ns 0.395591mA
+ 5.786ns 0.39386mA
+ 5.788ns 0.392137mA
+ 5.79ns 0.390422mA
+ 5.792ns 0.388713mA
+ 5.794ns 0.387013mA
+ 5.796ns 0.38532mA
+ 5.798ns 0.383634mA
+ 5.8ns 0.381956mA
+ 5.802ns 0.380285mA
+ 5.804ns 0.378621mA
+ 5.806ns 0.376964mA
+ 5.808ns 0.375315mA
+ 5.81ns 0.373674mA
+ 5.812ns 0.372038mA
+ 5.814ns 0.370411mA
+ 5.816ns 0.368791mA
+ 5.818ns 0.367177mA
+ 5.82ns 0.365571mA
+ 5.822ns 0.363971mA
+ 5.824ns 0.362379mA
+ 5.826ns 0.360793mA
+ 5.828ns 0.359215mA
+ 5.83ns 0.357644mA
+ 5.832ns 0.356079mA
+ 5.834ns 0.354521mA
+ 5.836ns 0.35297mA
+ 5.838ns 0.351425mA
+ 5.84ns 0.349888mA
+ 5.842ns 0.348357mA
+ 5.844ns 0.346833mA
+ 5.846ns 0.345316mA
+ 5.848ns 0.343805mA
+ 5.85ns 0.342301mA
+ 5.852ns 0.340803mA
+ 5.854ns 0.339312mA
+ 5.856ns 0.337828mA
+ 5.858ns 0.33635mA
+ 5.86ns 0.334878mA
+ 5.862ns 0.333413mA
+ 5.864ns 0.331954mA
+ 5.866ns 0.330502mA
+ 5.868ns 0.329056mA
+ 5.87ns 0.327617mA
+ 5.872ns 0.326183mA
+ 5.874ns 0.324756mA
+ 5.876ns 0.323335mA
+ 5.878ns 0.32192mA
+ 5.88ns 0.320512mA
+ 5.882ns 0.31911mA
+ 5.884ns 0.317714mA
+ 5.886ns 0.316324mA
+ 5.888ns 0.31494mA
+ 5.89ns 0.313562mA
+ 5.892ns 0.31219mA
+ 5.894ns 0.310824mA
+ 5.896ns 0.309464mA
+ 5.898ns 0.30811mA
+ 5.9ns 0.306762mA
+ 5.902ns 0.30542mA
+ 5.904ns 0.304084mA
+ 5.906ns 0.302753mA
+ 5.908ns 0.301429mA
+ 5.91ns 0.30011mA
+ 5.912ns 0.298797mA
+ 5.914ns 0.29749mA
+ 5.916ns 0.296188mA
+ 5.918ns 0.294892mA
+ 5.92ns 0.293602mA
+ 5.922ns 0.292318mA
+ 5.924ns 0.291038mA
+ 5.926ns 0.289765mA
+ 5.928ns 0.288497mA
+ 5.93ns 0.287235mA
+ 5.932ns 0.285978mA
+ 5.934ns 0.284727mA
+ 5.936ns 0.283482mA
+ 5.938ns 0.282241mA
+ 5.94ns 0.281006mA
+ 5.942ns 0.279777mA
+ 5.944ns 0.278553mA
+ 5.946ns 0.277334mA
+ 5.948ns 0.276121mA
+ 5.95ns 0.274912mA
+ 5.952ns 0.27371mA
+ 5.954ns 0.272512mA
+ 5.956ns 0.27132mA
+ 5.958ns 0.270133mA
+ 5.96ns 0.268951mA
+ 5.962ns 0.267774mA
+ 5.964ns 0.266602mA
+ 5.966ns 0.265436mA
+ 5.968ns 0.264275mA
+ 5.97ns 0.263118mA
+ 5.972ns 0.261967mA
+ 5.974ns 0.260821mA
+ 5.976ns 0.25968mA
+ 5.978ns 0.258543mA
+ 5.98ns 0.257412mA
+ 5.982ns 0.256286mA
+ 5.984ns 0.255165mA
+ 5.986ns 0.254048mA
+ 5.988ns 0.252937mA
+ 5.99ns 0.25183mA
+ 5.992ns 0.250728mA
+ 5.994ns 0.249631mA
+ 5.996ns 0.248539mA
+ 5.998ns 0.247451mA
+ 6ns 0.246369mA
+ 6.002ns 0.245291mA
+ 6.004ns 0.244217mA
+ 6.006ns 0.243149mA
+ 6.008ns 0.242085mA
+ 6.01ns 0.241026mA
+ 6.012ns 0.239971mA
+ 6.014ns 0.238921mA
+ 6.016ns 0.237876mA
+ 6.018ns 0.236835mA
+ 6.02ns 0.235799mA
+ 6.022ns 0mA
I159 296 0 PWL 0 0
+ 0.144ns 0mA
+ 0.146ns 0.0120229mA
+ 0.148ns 0.0267904mA
+ 0.15ns 0.041558mA
+ 0.152ns 0.0563255mA
+ 0.154ns 0.0710931mA
+ 0.156ns 0.0858606mA
+ 0.158ns 0.0978219mA
+ 0.16ns 0.0939714mA
+ 0.162ns 0.0902724mA
+ 0.164ns 0.0867189mA
+ 0.166ns 0.0833053mA
+ 0.168ns 0.080026mA
+ 0.17ns 0.0768758mA
+ 0.172ns 0.0738496mA
+ 0.174ns 0.0709425mA
+ 0.176ns 0.0681497mA
+ 0.178ns 0.065467mA
+ 0.18ns 0.0628897mA
+ 0.182ns 0.0604139mA
+ 0.184ns 0.0580356mA
+ 0.186ns 0.0557509mA
+ 0.188ns 0.0535561mA
+ 0.19ns 0.0514476mA
+ 0.192ns 0.0494222mA
+ 0.194ns 0.0474765mA
+ 0.196ns 0.0456073mA
+ 0.198ns 0.0438118mA
+ 0.2ns 0mA
+ 5.144ns 0mA
+ 5.146ns 0.0120217mA
+ 5.148ns 0.0267917mA
+ 5.15ns 0.0415582mA
+ 5.152ns 0.0563247mA
+ 5.154ns 0.0710947mA
+ 5.156ns 0.0858611mA
+ 5.158ns 0.0978221mA
+ 5.16ns 0.0939718mA
+ 5.162ns 0.0902722mA
+ 5.164ns 0.086719mA
+ 5.166ns 0.0833056mA
+ 5.168ns 0.0800258mA
+ 5.17ns 0.0768758mA
+ 5.172ns 0.0738498mA
+ 5.174ns 0.0709422mA
+ 5.176ns 0.0681497mA
+ 5.178ns 0.0654671mA
+ 5.18ns 0.06289mA
+ 5.182ns 0.0604138mA
+ 5.184ns 0.0580357mA
+ 5.186ns 0.0557511mA
+ 5.188ns 0.0535559mA
+ 5.19ns 0.0514476mA
+ 5.192ns 0.0494223mA
+ 5.194ns 0.0474763mA
+ 5.196ns 0.0456073mA
+ 5.198ns 0.0438119mA
+ 5.2ns 0mA
I160 299 0 PWL 0 0
+ 2.922ns 0mA
+ 2.924ns 0.00280324mA
+ 2.926ns 0.00769136mA
+ 2.928ns 0.0125789mA
+ 2.93ns 0.017467mA
+ 2.932ns 0.0223551mA
+ 2.934ns 0.0272426mA
+ 2.936ns 0.0321308mA
+ 2.938ns 0.0370183mA
+ 2.94ns 0.0419064mA
+ 2.942ns 0.0467945mA
+ 2.944ns 0.0516821mA
+ 2.946ns 0.0565694mA
+ 2.948ns 0.0552764mA
+ 2.95ns 0.0540128mA
+ 2.952ns 0.0527781mA
+ 2.954ns 0.0515718mA
+ 2.956ns 0.0503929mA
+ 2.958ns 0.049241mA
+ 2.96ns 0.0481154mA
+ 2.962ns 0.0470154mA
+ 2.964ns 0.0459408mA
+ 2.966ns 0.0448905mA
+ 2.968ns 0.0438644mA
+ 2.97ns 0.0428617mA
+ 2.972ns 0.0418818mA
+ 2.974ns 0.0409245mA
+ 2.976ns 0.0399889mA
+ 2.978ns 0.0390747mA
+ 2.98ns 0.0381815mA
+ 2.982ns 0.0373086mA
+ 2.984ns 0.0364558mA
+ 2.986ns 0.0356223mA
+ 2.988ns 0.0348079mA
+ 2.99ns 0.0340122mA
+ 2.992ns 0.0332346mA
+ 2.994ns 0.0324749mA
+ 2.996ns 0.0317325mA
+ 2.998ns 0.031007mA
+ 3ns 0.0302981mA
+ 3.002ns 0.0296054mA
+ 3.004ns 0.0289287mA
+ 3.006ns 0.0282673mA
+ 3.008ns 0.027621mA
+ 3.01ns 0.0269895mA
+ 3.012ns 0.0263725mA
+ 3.014ns 0.0257696mA
+ 3.016ns 0.0251804mA
+ 3.018ns 0mA
I161 301 0 PWL 0 0
+ 2.992ns 0mA
+ 2.994ns 0.00129654mA
+ 2.996ns 0.00290481mA
+ 2.998ns 0.00451307mA
+ 3ns 0.00612114mA
+ 3.002ns 0.00772941mA
+ 3.004ns 0.00933748mA
+ 3.006ns 0.0109457mA
+ 3.008ns 0.012554mA
+ 3.01ns 0.0141621mA
+ 3.012ns 0.0157703mA
+ 3.014ns 0.0158525mA
+ 3.016ns 0.015436mA
+ 3.018ns 0.0150305mA
+ 3.02ns 0.0146357mA
+ 3.022ns 0.0142512mA
+ 3.024ns 0.0138768mA
+ 3.026ns 0.0135123mA
+ 3.028ns 0.0131573mA
+ 3.03ns 0.0128117mA
+ 3.032ns 0.0124751mA
+ 3.034ns 0.0121474mA
+ 3.036ns 0.0118283mA
+ 3.038ns 0.0115175mA
+ 3.04ns 0.011215mA
+ 3.042ns 0.0109203mA
+ 3.044ns 0.0106334mA
+ 3.046ns 0.0103541mA
+ 3.048ns 0.0100821mA
+ 3.05ns 0.0098172mA
+ 3.052ns 0.00955927mA
+ 3.054ns 0.00930812mA
+ 3.056ns 0.00906359mA
+ 3.058ns 0.00882546mA
+ 3.06ns 0.0085936mA
+ 3.062ns 0.00836782mA
+ 3.064ns 0.00814796mA
+ 3.066ns 0.0079339mA
+ 3.068ns 0.00772544mA
+ 3.07ns 0.00752248mA
+ 3.072ns 0.00732483mA
+ 3.074ns 0.00713237mA
+ 3.076ns 0mA
I162 303 0 PWL 0 0
+ 8.016ns 0mA
+ 8.018ns 0.00114526mA
+ 8.02ns 0.00357935mA
+ 8.022ns 0.00601228mA
+ 8.024ns 0.00844521mA
+ 8.026ns 0.0108781mA
+ 8.028ns 0.0133111mA
+ 8.03ns 0.015744mA
+ 8.032ns 0.0181769mA
+ 8.034ns 0.020611mA
+ 8.036ns 0.023044mA
+ 8.038ns 0.0254769mA
+ 8.04ns 0.0279098mA
+ 8.042ns 0.0303428mA
+ 8.044ns 0.0327757mA
+ 8.046ns 0.0352086mA
+ 8.048ns 0.0376427mA
+ 8.05ns 0.0400756mA
+ 8.052ns 0.0425086mA
+ 8.054ns 0.0449415mA
+ 8.056ns 0.0416922mA
+ 8.058ns 0.0386777mA
+ 8.06ns 0.0358799mA
+ 8.062ns 0.0332856mA
+ 8.064ns 0.0308788mA
+ 8.066ns 0.028646mA
+ 8.068ns 0.0265747mA
+ 8.07ns 0.024653mA
+ 8.072ns 0.0228703mA
+ 8.074ns 0.0212157mA
+ 8.076ns 0.0196815mA
+ 8.078ns 0.0182583mA
+ 8.08ns 0.0169379mA
+ 8.082ns 0.015713mA
+ 8.084ns 0.0145766mA
+ 8.086ns 0.0135219mA
+ 8.088ns 0.012544mA
+ 8.09ns 0.0116368mA
+ 8.092ns 0mA
I163 306 0 PWL 0 0
+ 0.21ns 0mA
+ 0.212ns 0.00531719mA
+ 0.214ns 0.0164034mA
+ 0.216ns 0.0274896mA
+ 0.218ns 0.0385759mA
+ 0.22ns 0.0496621mA
+ 0.222ns 0.0607484mA
+ 0.224ns 0.0718345mA
+ 0.226ns 0.0829208mA
+ 0.228ns 0.0736891mA
+ 0.23ns 0.0615179mA
+ 0.232ns 0.0513566mA
+ 0.234ns 0.0428734mA
+ 0.236ns 0.0357911mA
+ 0.238ns 0.0298786mA
+ 0.24ns 0.0249426mA
+ 0.242ns 0mA
+ 5.21ns 0mA
+ 5.212ns 0.00531703mA
+ 5.214ns 0.0164051mA
+ 5.216ns 0.0274905mA
+ 5.218ns 0.0385759mA
+ 5.22ns 0.049664mA
+ 5.222ns 0.0607494mA
+ 5.224ns 0.0718349mA
+ 5.226ns 0.0829203mA
+ 5.228ns 0.0736875mA
+ 5.23ns 0.0615174mA
+ 5.232ns 0.0513568mA
+ 5.234ns 0.0428723mA
+ 5.236ns 0.0357907mA
+ 5.238ns 0.0298786mA
+ 5.24ns 0.0249418mA
+ 5.242ns 0mA
I164 308 0 PWL 0 0
+ 5.166ns 0mA
+ 5.168ns 0.00147623mA
+ 5.17ns 0.00319936mA
+ 5.172ns 0.00492248mA
+ 5.174ns 0.00664601mA
+ 5.176ns 0.00836914mA
+ 5.178ns 0.0100923mA
+ 5.18ns 0.0118154mA
+ 5.182ns 0.0135389mA
+ 5.184ns 0.015262mA
+ 5.186ns 0.0169852mA
+ 5.188ns 0.0187087mA
+ 5.19ns 0.0204318mA
+ 5.192ns 0.0221549mA
+ 5.194ns 0.0238785mA
+ 5.196ns 0.0256016mA
+ 5.198ns 0.0273247mA
+ 5.2ns 0.0290483mA
+ 5.202ns 0.0307714mA
+ 5.204ns 0.0324945mA
+ 5.206ns 0.0342176mA
+ 5.208ns 0.0359412mA
+ 5.21ns 0.0376643mA
+ 5.212ns 0.0393874mA
+ 5.214ns 0.0411109mA
+ 5.216ns 0.0428341mA
+ 5.218ns 0.0445572mA
+ 5.22ns 0.0462807mA
+ 5.222ns 0.0480038mA
+ 5.224ns 0.049727mA
+ 5.226ns 0.0514501mA
+ 5.228ns 0.0531736mA
+ 5.23ns 0.0548968mA
+ 5.232ns 0.0566199mA
+ 5.234ns 0.0583434mA
+ 5.236ns 0.0596552mA
+ 5.238ns 0.0573228mA
+ 5.24ns 0.055081mA
+ 5.242ns 0.0529274mA
+ 5.244ns 0.050858mA
+ 5.246ns 0.048869mA
+ 5.248ns 0.0469582mA
+ 5.25ns 0.0451221mA
+ 5.252ns 0.0433578mA
+ 5.254ns 0.041662mA
+ 5.256ns 0.0400329mA
+ 5.258ns 0.0384676mA
+ 5.26ns 0.036963mA
+ 5.262ns 0.0355177mA
+ 5.264ns 0.0341288mA
+ 5.266ns 0.0327939mA
+ 5.268ns 0.0315116mA
+ 5.27ns 0.0302793mA
+ 5.272ns 0.0290953mA
+ 5.274ns 0.0279572mA
+ 5.276ns 0.0268639mA
+ 5.278ns 0.0258134mA
+ 5.28ns 0.0248037mA
+ 5.282ns 0.0238337mA
+ 5.284ns 0.0229016mA
+ 5.286ns 0.0220058mA
+ 5.288ns 0.0211452mA
+ 5.29ns 0.0203183mA
+ 5.292ns 0.0195235mA
+ 5.294ns 0.0187599mA
+ 5.296ns 0.0180262mA
+ 5.298ns 0.0173212mA
+ 5.3ns 0.0166436mA
+ 5.302ns 0.0159927mA
+ 5.304ns 0.0153672mA
+ 5.306ns 0mA
I165 311 0 PWL 0 0
+ 0.42ns 0mA
+ 0.422ns 0.000123022mA
+ 0.424ns 0.00615583mA
+ 0.426ns 0.0121886mA
+ 0.428ns 0.0182214mA
+ 0.43ns 0.0242542mA
+ 0.432ns 0.030287mA
+ 0.434ns 0.0294704mA
+ 0.436ns 0.0279692mA
+ 0.438ns 0.0265445mA
+ 0.44ns 0.0251923mA
+ 0.442ns 0.023909mA
+ 0.444ns 0.0226911mA
+ 0.446ns 0.0215352mA
+ 0.448ns 0.0204382mA
+ 0.45ns 0.019397mA
+ 0.452ns 0.0184089mA
+ 0.454ns 0.017471mA
+ 0.456ns 0.016581mA
+ 0.458ns 0.0157363mA
+ 0.46ns 0.0149346mA
+ 0.462ns 0.0141737mA
+ 0.464ns 0mA
+ 5.904ns 0mA
+ 5.906ns 0.00555398mA
+ 5.908ns 0.0115863mA
+ 5.91ns 0.0176201mA
+ 5.912ns 0.0236525mA
+ 5.914ns 0.0296848mA
+ 5.916ns 0.0296246mA
+ 5.918ns 0.0281154mA
+ 5.92ns 0.0266833mA
+ 5.922ns 0.0253242mA
+ 5.924ns 0.024034mA
+ 5.926ns 0.0228098mA
+ 5.928ns 0.0216479mA
+ 5.93ns 0.020545mA
+ 5.932ns 0.0194984mA
+ 5.934ns 0.0185052mA
+ 5.936ns 0.0175625mA
+ 5.938ns 0.0166677mA
+ 5.94ns 0.0158186mA
+ 5.942ns 0.0150128mA
+ 5.944ns 0.0142478mA
+ 5.946ns 0.013522mA
+ 5.948ns 0mA
I166 313 0 PWL 0 0
+ 2.87ns 0mA
+ 2.872ns 0.00734087mA
+ 2.874ns 0.0161367mA
+ 2.876ns 0.0249314mA
+ 2.878ns 0.0337272mA
+ 2.88ns 0.042523mA
+ 2.882ns 0.0513178mA
+ 2.884ns 0.0601136mA
+ 2.886ns 0.0509473mA
+ 2.888ns 0.0417159mA
+ 2.89ns 0.034156mA
+ 2.892ns 0.0279666mA
+ 2.894ns 0.0228979mA
+ 2.896ns 0.0187478mA
+ 2.898ns 0.01535mA
+ 2.9ns 0mA
I167 315 0 PWL 0 0
+ 2.838ns 0mA
+ 2.84ns 0.00464205mA
+ 2.842ns 0.00942425mA
+ 2.844ns 0.014207mA
+ 2.846ns 0.0189892mA
+ 2.848ns 0.023772mA
+ 2.85ns 0.0285548mA
+ 2.852ns 0.033337mA
+ 2.854ns 0.0381197mA
+ 2.856ns 0.0429019mA
+ 2.858ns 0.0476847mA
+ 2.86ns 0.0414946mA
+ 2.862ns 0.0361085mA
+ 2.864ns 0.0314208mA
+ 2.866ns 0.027342mA
+ 2.868ns 0.0237922mA
+ 2.87ns 0.0207032mA
+ 2.872ns 0.0180154mA
+ 2.874ns 0.0156763mA
+ 2.876ns 0.013641mA
+ 2.878ns 0mA
I168 317 0 PWL 0 0
+ 5.29ns 0mA
+ 5.292ns 0.0037301mA
+ 5.294ns 0.00796397mA
+ 5.296ns 0.0121978mA
+ 5.298ns 0.0164317mA
+ 5.3ns 0.0206666mA
+ 5.302ns 0.0249005mA
+ 5.304ns 0.0291344mA
+ 5.306ns 0.0333692mA
+ 5.308ns 0.0376031mA
+ 5.31ns 0.041837mA
+ 5.312ns 0.0460719mA
+ 5.314ns 0.0503057mA
+ 5.316ns 0.0545396mA
+ 5.318ns 0.0587735mA
+ 5.32ns 0.0630084mA
+ 5.322ns 0.0672422mA
+ 5.324ns 0.0664857mA
+ 5.326ns 0.0610896mA
+ 5.328ns 0.0561325mA
+ 5.33ns 0.0515776mA
+ 5.332ns 0.0473912mA
+ 5.334ns 0.0435454mA
+ 5.336ns 0.0400116mA
+ 5.338ns 0.0367638mA
+ 5.34ns 0.0337803mA
+ 5.342ns 0.0310388mA
+ 5.344ns 0.0285198mA
+ 5.346ns 0.0262046mA
+ 5.348ns 0.0240778mA
+ 5.35ns 0.0221236mA
+ 5.352ns 0.0203276mA
+ 5.354ns 0.0186777mA
+ 5.356ns 0mA
I169 320 0 PWL 0 0
+ 0.15ns 0mA
+ 0.152ns 0.00210485mA
+ 0.154ns 0.0129851mA
+ 0.156ns 0.0238652mA
+ 0.158ns 0.0347454mA
+ 0.16ns 0.0456256mA
+ 0.162ns 0.0565058mA
+ 0.164ns 0.067386mA
+ 0.166ns 0.0782662mA
+ 0.168ns 0.0891464mA
+ 0.17ns 0.100027mA
+ 0.172ns 0.0896131mA
+ 0.174ns 0.0772559mA
+ 0.176ns 0.0666023mA
+ 0.178ns 0.0574176mA
+ 0.18ns 0.0494992mA
+ 0.182ns 0.0426726mA
+ 0.184ns 0.0367873mA
+ 0.186ns 0.0317135mA
+ 0.188ns 0.0273393mA
+ 0.19ns 0mA
I170 321 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.000989563mA
+ 2.654ns 0.0118732mA
+ 2.656ns 0.0227569mA
+ 2.658ns 0.0336393mA
+ 2.66ns 0.044523mA
+ 2.662ns 0.0554054mA
+ 2.664ns 0.0662891mA
+ 2.666ns 0.0771728mA
+ 2.668ns 0.0880551mA
+ 2.67ns 0.0989388mA
+ 2.672ns 0.0958595mA
+ 2.674ns 0.0828947mA
+ 2.676ns 0.071683mA
+ 2.678ns 0.0619884mA
+ 2.68ns 0.0536038mA
+ 2.682ns 0.0463538mA
+ 2.684ns 0.0400835mA
+ 2.686ns 0.0346612mA
+ 2.688ns 0.0299728mA
+ 2.69ns 0mA
+ 7.65ns 0mA
+ 7.652ns 0.000989563mA
+ 7.654ns 0.0118745mA
+ 7.656ns 0.0227569mA
+ 7.658ns 0.0336393mA
+ 7.66ns 0.0445217mA
+ 7.662ns 0.0554067mA
+ 7.664ns 0.0662891mA
+ 7.666ns 0.0771715mA
+ 7.668ns 0.0880564mA
+ 7.67ns 0.0989388mA
+ 7.672ns 0.0958595mA
+ 7.674ns 0.0828933mA
+ 7.676ns 0.071683mA
+ 7.678ns 0.0619884mA
+ 7.68ns 0.0536029mA
+ 7.682ns 0.046353mA
+ 7.684ns 0.0400835mA
+ 7.686ns 0.0346618mA
+ 7.688ns 0.0299723mA
+ 7.69ns 0mA
I171 322 0 PWL 0 0
+ 2.744ns 0mA
+ 2.746ns 0.0015214mA
+ 2.748ns 0.00532995mA
+ 2.75ns 0.00913805mA
+ 2.752ns 0.0129466mA
+ 2.754ns 0.0167547mA
+ 2.756ns 0.0205633mA
+ 2.758ns 0.0243718mA
+ 2.76ns 0.0281799mA
+ 2.762ns 0.0319885mA
+ 2.764ns 0.0357966mA
+ 2.766ns 0.0396051mA
+ 2.768ns 0.0434137mA
+ 2.77ns 0.0472218mA
+ 2.772ns 0.0510303mA
+ 2.774ns 0.0548384mA
+ 2.776ns 0.0519677mA
+ 2.778ns 0.0472751mA
+ 2.78ns 0.0430066mA
+ 2.782ns 0.039123mA
+ 2.784ns 0.0355904mA
+ 2.786ns 0.0323764mA
+ 2.788ns 0.0294525mA
+ 2.79ns 0.026793mA
+ 2.792ns 0.0243732mA
+ 2.794ns 0.022172mA
+ 2.796ns 0.0201697mA
+ 2.798ns 0.018348mA
+ 2.8ns 0.016691mA
+ 2.802ns 0.0151835mA
+ 2.804ns 0mA
+ 7.744ns 0mA
+ 7.746ns 0.00152186mA
+ 7.748ns 0.00532995mA
+ 7.75ns 0.00913805mA
+ 7.752ns 0.0129462mA
+ 7.754ns 0.0167552mA
+ 7.756ns 0.0205633mA
+ 7.758ns 0.0243714mA
+ 7.76ns 0.0281804mA
+ 7.762ns 0.0319885mA
+ 7.764ns 0.0357966mA
+ 7.766ns 0.0396056mA
+ 7.768ns 0.0434137mA
+ 7.77ns 0.0472218mA
+ 7.772ns 0.0510308mA
+ 7.774ns 0.0548389mA
+ 7.776ns 0.0519677mA
+ 7.778ns 0.0472756mA
+ 7.78ns 0.0430061mA
+ 7.782ns 0.039123mA
+ 7.784ns 0.0355904mA
+ 7.786ns 0.032376mA
+ 7.788ns 0.0294525mA
+ 7.79ns 0.026793mA
+ 7.792ns 0.024373mA
+ 7.794ns 0.022172mA
+ 7.796ns 0.0201697mA
+ 7.798ns 0.0183482mA
+ 7.8ns 0.0166908mA
+ 7.802ns 0.0151835mA
+ 7.804ns 0mA
I172 327 0 PWL 0 0
+ 7.652ns 0mA
+ 7.654ns 0.00319889mA
+ 7.656ns 0.0137951mA
+ 7.658ns 0.0243914mA
+ 7.66ns 0.0349876mA
+ 7.662ns 0.0455864mA
+ 7.664ns 0.0561826mA
+ 7.666ns 0.0667789mA
+ 7.668ns 0.0773777mA
+ 7.67ns 0.0879739mA
+ 7.672ns 0.0985702mA
+ 7.674ns 0.109169mA
+ 7.676ns 0.119765mA
+ 7.678ns 0.130361mA
+ 7.68ns 0.130962mA
+ 7.682ns 0.11762mA
+ 7.684ns 0.105637mA
+ 7.686ns 0.094875mA
+ 7.688ns 0.0852067mA
+ 7.69ns 0.0765254mA
+ 7.692ns 0.0687284mA
+ 7.694ns 0.061724mA
+ 7.696ns 0.0554348mA
+ 7.698ns 0.0497862mA
+ 7.7ns 0.044712mA
+ 7.702ns 0.0401558mA
+ 7.704ns 0.0360638mA
+ 7.706ns 0mA
I173 329 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00308459mA
+ 2.656ns 0.0137682mA
+ 2.658ns 0.0244506mA
+ 2.66ns 0.0351342mA
+ 2.662ns 0.0458166mA
+ 2.664ns 0.0565002mA
+ 2.666ns 0.0671838mA
+ 2.668ns 0.0778662mA
+ 2.67ns 0.0885498mA
+ 2.672ns 0.0992322mA
+ 2.674ns 0.109916mA
+ 2.676ns 0.120599mA
+ 2.678ns 0.131282mA
+ 2.68ns 0.128182mA
+ 2.682ns 0.114966mA
+ 2.684ns 0.10311mA
+ 2.686ns 0.0924768mA
+ 2.688ns 0.0829409mA
+ 2.69ns 0.0743872mA
+ 2.692ns 0.0667154mA
+ 2.694ns 0.0598354mA
+ 2.696ns 0.0536641mA
+ 2.698ns 0.0481298mA
+ 2.7ns 0.0431655mA
+ 2.702ns 0.0387131mA
+ 2.704ns 0.0347204mA
+ 2.706ns 0mA
I174 331 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00480446mA
+ 0.156ns 0.015729mA
+ 0.158ns 0.0266537mA
+ 0.16ns 0.0375784mA
+ 0.162ns 0.0485029mA
+ 0.164ns 0.0594276mA
+ 0.166ns 0.0703523mA
+ 0.168ns 0.0812769mA
+ 0.17ns 0.0922015mA
+ 0.172ns 0.103126mA
+ 0.174ns 0.114051mA
+ 0.176ns 0.124975mA
+ 0.178ns 0.121823mA
+ 0.18ns 0.108416mA
+ 0.182ns 0.0964833mA
+ 0.184ns 0.0858639mA
+ 0.186ns 0.0764132mA
+ 0.188ns 0.0680024mA
+ 0.19ns 0.0605172mA
+ 0.192ns 0.0538557mA
+ 0.194ns 0.0479273mA
+ 0.196ns 0.0426514mA
+ 0.198ns 0.0379561mA
+ 0.2ns 0.0337777mA
+ 0.202ns 0mA
+ 2.652ns 0mA
+ 2.654ns 0.00480511mA
+ 2.656ns 0.0157303mA
+ 2.658ns 0.0266541mA
+ 2.66ns 0.0375793mA
+ 2.662ns 0.0485031mA
+ 2.664ns 0.0594283mA
+ 2.666ns 0.0703534mA
+ 2.668ns 0.0812773mA
+ 2.67ns 0.0922024mA
+ 2.672ns 0.103126mA
+ 2.674ns 0.114051mA
+ 2.676ns 0.124977mA
+ 2.678ns 0.121823mA
+ 2.68ns 0.108415mA
+ 2.682ns 0.0964833mA
+ 2.684ns 0.0858635mA
+ 2.686ns 0.0764123mA
+ 2.688ns 0.0680022mA
+ 2.69ns 0.0605167mA
+ 2.692ns 0.053855mA
+ 2.694ns 0.0479271mA
+ 2.696ns 0.042651mA
+ 2.698ns 0.0379561mA
+ 2.7ns 0.0337774mA
+ 2.702ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00480641mA
+ 7.656ns 0.0157303mA
+ 7.658ns 0.0266541mA
+ 7.66ns 0.037578mA
+ 7.662ns 0.0485044mA
+ 7.664ns 0.0594283mA
+ 7.666ns 0.0703521mA
+ 7.668ns 0.0812786mA
+ 7.67ns 0.0922024mA
+ 7.672ns 0.103126mA
+ 7.674ns 0.114053mA
+ 7.676ns 0.124977mA
+ 7.678ns 0.121823mA
+ 7.68ns 0.108413mA
+ 7.682ns 0.0964819mA
+ 7.684ns 0.0858635mA
+ 7.686ns 0.0764134mA
+ 7.688ns 0.0680013mA
+ 7.69ns 0.0605167mA
+ 7.692ns 0.0538557mA
+ 7.694ns 0.0479264mA
+ 7.696ns 0.042651mA
+ 7.698ns 0.0379561mA
+ 7.7ns 0.0337769mA
+ 7.702ns 0mA
I175 333 0 PWL 0 0
+ 0.518ns 0mA
+ 0.52ns 0.00761945mA
+ 0.522ns 0.0152784mA
+ 0.524ns 0.0229376mA
+ 0.526ns 0.0305965mA
+ 0.528ns 0.0382555mA
+ 0.53ns 0.0459146mA
+ 0.532ns 0.0535736mA
+ 0.534ns 0.0612327mA
+ 0.536ns 0.0688917mA
+ 0.538ns 0.0765509mA
+ 0.54ns 0.0842098mA
+ 0.542ns 0.091869mA
+ 0.544ns 0.0995279mA
+ 0.546ns 0.107187mA
+ 0.548ns 0.114846mA
+ 0.55ns 0.122505mA
+ 0.552ns 0.130164mA
+ 0.554ns 0.137823mA
+ 0.556ns 0.145482mA
+ 0.558ns 0.153141mA
+ 0.56ns 0.1608mA
+ 0.562ns 0.168459mA
+ 0.564ns 0.176118mA
+ 0.566ns 0.183777mA
+ 0.568ns 0.191436mA
+ 0.57ns 0.199096mA
+ 0.572ns 0.206754mA
+ 0.574ns 0.214413mA
+ 0.576ns 0.222073mA
+ 0.578ns 0.229732mA
+ 0.58ns 0.237391mA
+ 0.582ns 0.24505mA
+ 0.584ns 0.252709mA
+ 0.586ns 0.260368mA
+ 0.588ns 0.268027mA
+ 0.59ns 0.275686mA
+ 0.592ns 0.283345mA
+ 0.594ns 0.291004mA
+ 0.596ns 0.298663mA
+ 0.598ns 0.306322mA
+ 0.6ns 0.313981mA
+ 0.602ns 0.32164mA
+ 0.604ns 0.329299mA
+ 0.606ns 0.336958mA
+ 0.608ns 0.344617mA
+ 0.61ns 0.352276mA
+ 0.612ns 0.359935mA
+ 0.614ns 0.367594mA
+ 0.616ns 0.375254mA
+ 0.618ns 0.382912mA
+ 0.62ns 0.390571mA
+ 0.622ns 0.398231mA
+ 0.624ns 0.40589mA
+ 0.626ns 0.413549mA
+ 0.628ns 0.421208mA
+ 0.63ns 0.428867mA
+ 0.632ns 0.436526mA
+ 0.634ns 0.444185mA
+ 0.636ns 0.451844mA
+ 0.638ns 0.459503mA
+ 0.64ns 0.467162mA
+ 0.642ns 0.474821mA
+ 0.644ns 0.48248mA
+ 0.646ns 0.490139mA
+ 0.648ns 0.497798mA
+ 0.65ns 0.505457mA
+ 0.652ns 0.513116mA
+ 0.654ns 0.520775mA
+ 0.656ns 0.528434mA
+ 0.658ns 0.536093mA
+ 0.66ns 0.543752mA
+ 0.662ns 0.551411mA
+ 0.664ns 0.549002mA
+ 0.666ns 0.546603mA
+ 0.668ns 0.544214mA
+ 0.67ns 0.541836mA
+ 0.672ns 0.539468mA
+ 0.674ns 0.537111mA
+ 0.676ns 0.534764mA
+ 0.678ns 0.532427mA
+ 0.68ns 0.530101mA
+ 0.682ns 0.527784mA
+ 0.684ns 0.525478mA
+ 0.686ns 0.523182mA
+ 0.688ns 0.520896mA
+ 0.69ns 0.518619mA
+ 0.692ns 0.516353mA
+ 0.694ns 0.514097mA
+ 0.696ns 0.51185mA
+ 0.698ns 0.509614mA
+ 0.7ns 0.507387mA
+ 0.702ns 0.505169mA
+ 0.704ns 0.502962mA
+ 0.706ns 0.500764mA
+ 0.708ns 0.498576mA
+ 0.71ns 0.496397mA
+ 0.712ns 0.494228mA
+ 0.714ns 0.492068mA
+ 0.716ns 0.489918mA
+ 0.718ns 0.487777mA
+ 0.72ns 0.485646mA
+ 0.722ns 0.483523mA
+ 0.724ns 0.48141mA
+ 0.726ns 0.479307mA
+ 0.728ns 0.477212mA
+ 0.73ns 0.475127mA
+ 0.732ns 0.473051mA
+ 0.734ns 0.470983mA
+ 0.736ns 0.468925mA
+ 0.738ns 0.466876mA
+ 0.74ns 0.464836mA
+ 0.742ns 0.462805mA
+ 0.744ns 0.460782mA
+ 0.746ns 0.458769mA
+ 0.748ns 0.456764mA
+ 0.75ns 0.454768mA
+ 0.752ns 0.45278mA
+ 0.754ns 0.450802mA
+ 0.756ns 0.448832mA
+ 0.758ns 0.44687mA
+ 0.76ns 0.444918mA
+ 0.762ns 0.442973mA
+ 0.764ns 0.441038mA
+ 0.766ns 0.43911mA
+ 0.768ns 0.437191mA
+ 0.77ns 0.435281mA
+ 0.772ns 0.433379mA
+ 0.774ns 0.431485mA
+ 0.776ns 0.429599mA
+ 0.778ns 0.427722mA
+ 0.78ns 0.425853mA
+ 0.782ns 0.423992mA
+ 0.784ns 0.422139mA
+ 0.786ns 0.420294mA
+ 0.788ns 0.418457mA
+ 0.79ns 0.416629mA
+ 0.792ns 0.414808mA
+ 0.794ns 0.412995mA
+ 0.796ns 0.411191mA
+ 0.798ns 0.409394mA
+ 0.8ns 0.407605mA
+ 0.802ns 0.405823mA
+ 0.804ns 0.40405mA
+ 0.806ns 0.402284mA
+ 0.808ns 0.400526mA
+ 0.81ns 0.398776mA
+ 0.812ns 0.397033mA
+ 0.814ns 0.395298mA
+ 0.816ns 0.393571mA
+ 0.818ns 0.391851mA
+ 0.82ns 0.390138mA
+ 0.822ns 0.388433mA
+ 0.824ns 0.386736mA
+ 0.826ns 0.385046mA
+ 0.828ns 0.383363mA
+ 0.83ns 0.381688mA
+ 0.832ns 0.38002mA
+ 0.834ns 0.378359mA
+ 0.836ns 0.376705mA
+ 0.838ns 0.375059mA
+ 0.84ns 0.37342mA
+ 0.842ns 0.371788mA
+ 0.844ns 0.370163mA
+ 0.846ns 0.368546mA
+ 0.848ns 0.366935mA
+ 0.85ns 0.365332mA
+ 0.852ns 0.363735mA
+ 0.854ns 0.362145mA
+ 0.856ns 0.360563mA
+ 0.858ns 0.358987mA
+ 0.86ns 0.357418mA
+ 0.862ns 0.355856mA
+ 0.864ns 0.354301mA
+ 0.866ns 0.352753mA
+ 0.868ns 0.351211mA
+ 0.87ns 0.349676mA
+ 0.872ns 0.348148mA
+ 0.874ns 0.346627mA
+ 0.876ns 0.345112mA
+ 0.878ns 0.343603mA
+ 0.88ns 0.342102mA
+ 0.882ns 0.340607mA
+ 0.884ns 0.339118mA
+ 0.886ns 0.337636mA
+ 0.888ns 0.336161mA
+ 0.89ns 0.334692mA
+ 0.892ns 0.333229mA
+ 0.894ns 0.331773mA
+ 0.896ns 0.330323mA
+ 0.898ns 0.328879mA
+ 0.9ns 0.327442mA
+ 0.902ns 0.326011mA
+ 0.904ns 0.324586mA
+ 0.906ns 0.323167mA
+ 0.908ns 0.321755mA
+ 0.91ns 0.320349mA
+ 0.912ns 0.318949mA
+ 0.914ns 0.317555mA
+ 0.916ns 0.316167mA
+ 0.918ns 0.314785mA
+ 0.92ns 0.31341mA
+ 0.922ns 0.31204mA
+ 0.924ns 0.310676mA
+ 0.926ns 0.309318mA
+ 0.928ns 0.307967mA
+ 0.93ns 0.306621mA
+ 0.932ns 0.305281mA
+ 0.934ns 0.303947mA
+ 0.936ns 0.302618mA
+ 0.938ns 0.301296mA
+ 0.94ns 0.299979mA
+ 0.942ns 0.298668mA
+ 0.944ns 0.297362mA
+ 0.946ns 0.296063mA
+ 0.948ns 0.294769mA
+ 0.95ns 0.293481mA
+ 0.952ns 0.292198mA
+ 0.954ns 0.290921mA
+ 0.956ns 0.28965mA
+ 0.958ns 0.288384mA
+ 0.96ns 0.287123mA
+ 0.962ns 0.285868mA
+ 0.964ns 0.284619mA
+ 0.966ns 0.283375mA
+ 0.968ns 0.282137mA
+ 0.97ns 0.280904mA
+ 0.972ns 0.279676mA
+ 0.974ns 0.278454mA
+ 0.976ns 0.277237mA
+ 0.978ns 0.276025mA
+ 0.98ns 0.274819mA
+ 0.982ns 0.273618mA
+ 0.984ns 0.272422mA
+ 0.986ns 0.271231mA
+ 0.988ns 0.270046mA
+ 0.99ns 0.268866mA
+ 0.992ns 0.26769mA
+ 0.994ns 0.266521mA
+ 0.996ns 0.265356mA
+ 0.998ns 0.264196mA
+ 1ns 0.263041mA
+ 1.002ns 0.261892mA
+ 1.004ns 0.260747mA
+ 1.006ns 0.259607mA
+ 1.008ns 0.258473mA
+ 1.01ns 0.257343mA
+ 1.012ns 0.256218mA
+ 1.014ns 0.255099mA
+ 1.016ns 0.253984mA
+ 1.018ns 0.252874mA
+ 1.02ns 0.251768mA
+ 1.022ns 0.250668mA
+ 1.024ns 0.249572mA
+ 1.026ns 0.248482mA
+ 1.028ns 0.247396mA
+ 1.03ns 0.246314mA
+ 1.032ns 0.245238mA
+ 1.034ns 0.244166mA
+ 1.036ns 0.243099mA
+ 1.038ns 0.242036mA
+ 1.04ns 0.240979mA
+ 1.042ns 0.239925mA
+ 1.044ns 0.238877mA
+ 1.046ns 0.237833mA
+ 1.048ns 0.236793mA
+ 1.05ns 0.235758mA
+ 1.052ns 0mA
+ 8.018ns 0mA
+ 8.02ns 0.00762219mA
+ 8.022ns 0.0152807mA
+ 8.024ns 0.0229392mA
+ 8.026ns 0.0305977mA
+ 8.028ns 0.0382561mA
+ 8.03ns 0.0459146mA
+ 8.032ns 0.0535731mA
+ 8.034ns 0.0612353mA
+ 8.036ns 0.0688937mA
+ 8.038ns 0.0765522mA
+ 8.04ns 0.0842107mA
+ 8.042ns 0.0918692mA
+ 8.044ns 0.0995277mA
+ 8.046ns 0.107186mA
+ 8.048ns 0.114848mA
+ 8.05ns 0.122507mA
+ 8.052ns 0.130165mA
+ 8.054ns 0.137824mA
+ 8.056ns 0.145482mA
+ 8.058ns 0.153141mA
+ 8.06ns 0.160803mA
+ 8.062ns 0.168461mA
+ 8.064ns 0.17612mA
+ 8.066ns 0.183778mA
+ 8.068ns 0.191437mA
+ 8.07ns 0.199095mA
+ 8.072ns 0.206754mA
+ 8.074ns 0.214416mA
+ 8.076ns 0.222074mA
+ 8.078ns 0.229733mA
+ 8.08ns 0.237391mA
+ 8.082ns 0.24505mA
+ 8.084ns 0.252708mA
+ 8.086ns 0.260371mA
+ 8.088ns 0.268029mA
+ 8.09ns 0.275687mA
+ 8.092ns 0.283346mA
+ 8.094ns 0.291004mA
+ 8.096ns 0.298663mA
+ 8.098ns 0.306321mA
+ 8.1ns 0.313984mA
+ 8.102ns 0.321642mA
+ 8.104ns 0.329301mA
+ 8.106ns 0.336959mA
+ 8.108ns 0.344618mA
+ 8.11ns 0.352276mA
+ 8.112ns 0.359938mA
+ 8.114ns 0.367597mA
+ 8.116ns 0.375255mA
+ 8.118ns 0.382914mA
+ 8.12ns 0.390572mA
+ 8.122ns 0.398231mA
+ 8.124ns 0.405889mA
+ 8.126ns 0.413551mA
+ 8.128ns 0.42121mA
+ 8.13ns 0.428868mA
+ 8.132ns 0.436527mA
+ 8.134ns 0.444185mA
+ 8.136ns 0.451844mA
+ 8.138ns 0.459502mA
+ 8.14ns 0.467164mA
+ 8.142ns 0.474823mA
+ 8.144ns 0.482481mA
+ 8.146ns 0.49014mA
+ 8.148ns 0.497798mA
+ 8.15ns 0.505457mA
+ 8.152ns 0.513119mA
+ 8.154ns 0.520777mA
+ 8.156ns 0.528436mA
+ 8.158ns 0.536094mA
+ 8.16ns 0.543753mA
+ 8.162ns 0.551411mA
+ 8.164ns 0.549002mA
+ 8.166ns 0.546602mA
+ 8.168ns 0.544214mA
+ 8.17ns 0.541836mA
+ 8.172ns 0.539468mA
+ 8.174ns 0.537111mA
+ 8.176ns 0.534764mA
+ 8.178ns 0.532426mA
+ 8.18ns 0.5301mA
+ 8.182ns 0.527784mA
+ 8.184ns 0.525478mA
+ 8.186ns 0.523182mA
+ 8.188ns 0.520896mA
+ 8.19ns 0.518619mA
+ 8.192ns 0.516352mA
+ 8.194ns 0.514096mA
+ 8.196ns 0.51185mA
+ 8.198ns 0.509613mA
+ 8.2ns 0.507387mA
+ 8.202ns 0.505169mA
+ 8.204ns 0.502961mA
+ 8.206ns 0.500763mA
+ 8.208ns 0.498575mA
+ 8.21ns 0.496397mA
+ 8.212ns 0.494228mA
+ 8.214ns 0.492068mA
+ 8.216ns 0.489918mA
+ 8.218ns 0.487776mA
+ 8.22ns 0.485645mA
+ 8.222ns 0.483523mA
+ 8.224ns 0.48141mA
+ 8.226ns 0.479307mA
+ 8.228ns 0.477212mA
+ 8.23ns 0.475127mA
+ 8.232ns 0.47305mA
+ 8.234ns 0.470983mA
+ 8.236ns 0.468925mA
+ 8.238ns 0.466876mA
+ 8.24ns 0.464836mA
+ 8.242ns 0.462805mA
+ 8.244ns 0.460781mA
+ 8.246ns 0.458768mA
+ 8.248ns 0.456763mA
+ 8.25ns 0.454767mA
+ 8.252ns 0.45278mA
+ 8.254ns 0.450802mA
+ 8.256ns 0.448832mA
+ 8.258ns 0.44687mA
+ 8.26ns 0.444917mA
+ 8.262ns 0.442973mA
+ 8.264ns 0.441037mA
+ 8.266ns 0.43911mA
+ 8.268ns 0.437191mA
+ 8.27ns 0.43528mA
+ 8.272ns 0.433378mA
+ 8.274ns 0.431484mA
+ 8.276ns 0.429599mA
+ 8.278ns 0.427722mA
+ 8.28ns 0.425853mA
+ 8.282ns 0.423992mA
+ 8.284ns 0.422138mA
+ 8.286ns 0.420294mA
+ 8.288ns 0.418457mA
+ 8.29ns 0.416629mA
+ 8.292ns 0.414808mA
+ 8.294ns 0.412995mA
+ 8.296ns 0.41119mA
+ 8.298ns 0.409393mA
+ 8.3ns 0.407604mA
+ 8.302ns 0.405823mA
+ 8.304ns 0.40405mA
+ 8.306ns 0.402284mA
+ 8.308ns 0.400526mA
+ 8.31ns 0.398775mA
+ 8.312ns 0.397033mA
+ 8.314ns 0.395298mA
+ 8.316ns 0.39357mA
+ 8.318ns 0.391851mA
+ 8.32ns 0.390138mA
+ 8.322ns 0.388433mA
+ 8.324ns 0.386735mA
+ 8.326ns 0.385045mA
+ 8.328ns 0.383363mA
+ 8.33ns 0.381687mA
+ 8.332ns 0.38002mA
+ 8.334ns 0.378359mA
+ 8.336ns 0.376705mA
+ 8.338ns 0.375059mA
+ 8.34ns 0.37342mA
+ 8.342ns 0.371788mA
+ 8.344ns 0.370163mA
+ 8.346ns 0.368546mA
+ 8.348ns 0.366935mA
+ 8.35ns 0.365331mA
+ 8.352ns 0.363735mA
+ 8.354ns 0.362145mA
+ 8.356ns 0.360563mA
+ 8.358ns 0.358987mA
+ 8.36ns 0.357418mA
+ 8.362ns 0.355856mA
+ 8.364ns 0.354301mA
+ 8.366ns 0.352752mA
+ 8.368ns 0.351211mA
+ 8.37ns 0.349676mA
+ 8.372ns 0.348148mA
+ 8.374ns 0.346627mA
+ 8.376ns 0.345111mA
+ 8.378ns 0.343603mA
+ 8.38ns 0.342102mA
+ 8.382ns 0.340607mA
+ 8.384ns 0.339118mA
+ 8.386ns 0.337636mA
+ 8.388ns 0.33616mA
+ 8.39ns 0.334691mA
+ 8.392ns 0.333229mA
+ 8.394ns 0.331772mA
+ 8.396ns 0.330323mA
+ 8.398ns 0.328879mA
+ 8.4ns 0.327442mA
+ 8.402ns 0.32601mA
+ 8.404ns 0.324586mA
+ 8.406ns 0.323167mA
+ 8.408ns 0.321755mA
+ 8.41ns 0.320349mA
+ 8.412ns 0.318949mA
+ 8.414ns 0.317555mA
+ 8.416ns 0.316167mA
+ 8.418ns 0.314785mA
+ 8.42ns 0.313409mA
+ 8.422ns 0.31204mA
+ 8.424ns 0.310676mA
+ 8.426ns 0.309319mA
+ 8.428ns 0.307966mA
+ 8.43ns 0.30662mA
+ 8.432ns 0.30528mA
+ 8.434ns 0.303946mA
+ 8.436ns 0.302618mA
+ 8.438ns 0.301296mA
+ 8.44ns 0.299979mA
+ 8.442ns 0.298667mA
+ 8.444ns 0.297362mA
+ 8.446ns 0.296063mA
+ 8.448ns 0.294769mA
+ 8.45ns 0.293481mA
+ 8.452ns 0.292198mA
+ 8.454ns 0.290921mA
+ 8.456ns 0.289649mA
+ 8.458ns 0.288383mA
+ 8.46ns 0.287123mA
+ 8.462ns 0.285868mA
+ 8.464ns 0.284619mA
+ 8.466ns 0.283375mA
+ 8.468ns 0.282136mA
+ 8.47ns 0.280903mA
+ 8.472ns 0.279676mA
+ 8.474ns 0.278454mA
+ 8.476ns 0.277237mA
+ 8.478ns 0.276025mA
+ 8.48ns 0.274818mA
+ 8.482ns 0.273617mA
+ 8.484ns 0.272422mA
+ 8.486ns 0.271231mA
+ 8.488ns 0.270046mA
+ 8.49ns 0.268866mA
+ 8.492ns 0.267691mA
+ 8.494ns 0.26652mA
+ 8.496ns 0.265355mA
+ 8.498ns 0.264196mA
+ 8.5ns 0.263041mA
+ 8.502ns 0.261892mA
+ 8.504ns 0.260747mA
+ 8.506ns 0.259608mA
+ 8.508ns 0.258472mA
+ 8.51ns 0.257343mA
+ 8.512ns 0.256218mA
+ 8.514ns 0.255098mA
+ 8.516ns 0.253984mA
+ 8.518ns 0.252874mA
+ 8.52ns 0.251768mA
+ 8.522ns 0.250668mA
+ 8.524ns 0.249572mA
+ 8.526ns 0.248482mA
+ 8.528ns 0.247396mA
+ 8.53ns 0.246314mA
+ 8.532ns 0.245238mA
+ 8.534ns 0.244166mA
+ 8.536ns 0.243099mA
+ 8.538ns 0.242036mA
+ 8.54ns 0.240978mA
+ 8.542ns 0.239925mA
+ 8.544ns 0.238877mA
+ 8.546ns 0.237832mA
+ 8.548ns 0.236793mA
+ 8.55ns 0.235758mA
+ 8.552ns 0mA
I176 336 0 PWL 0 0
+ 0.486ns 0mA
+ 0.488ns 0.00605671mA
+ 0.49ns 0.0136728mA
+ 0.492ns 0.0212889mA
+ 0.494ns 0.0289051mA
+ 0.496ns 0.0365212mA
+ 0.498ns 0.0441374mA
+ 0.5ns 0.0517535mA
+ 0.502ns 0.0593697mA
+ 0.504ns 0.0669858mA
+ 0.506ns 0.0746021mA
+ 0.508ns 0.0822181mA
+ 0.51ns 0.0898344mA
+ 0.512ns 0.0974505mA
+ 0.514ns 0.105067mA
+ 0.516ns 0.112683mA
+ 0.518ns 0.120299mA
+ 0.52ns 0.127915mA
+ 0.522ns 0.135531mA
+ 0.524ns 0.143147mA
+ 0.526ns 0.150763mA
+ 0.528ns 0.15838mA
+ 0.53ns 0.165996mA
+ 0.532ns 0.173612mA
+ 0.534ns 0.181228mA
+ 0.536ns 0.188844mA
+ 0.538ns 0.19646mA
+ 0.54ns 0.204077mA
+ 0.542ns 0.211693mA
+ 0.544ns 0.219309mA
+ 0.546ns 0.226925mA
+ 0.548ns 0.234541mA
+ 0.55ns 0.242157mA
+ 0.552ns 0.249774mA
+ 0.554ns 0.25739mA
+ 0.556ns 0.265006mA
+ 0.558ns 0.272622mA
+ 0.56ns 0.280238mA
+ 0.562ns 0.287854mA
+ 0.564ns 0.29547mA
+ 0.566ns 0.303087mA
+ 0.568ns 0.310703mA
+ 0.57ns 0.318319mA
+ 0.572ns 0.325935mA
+ 0.574ns 0.333551mA
+ 0.576ns 0.341167mA
+ 0.578ns 0.348783mA
+ 0.58ns 0.3564mA
+ 0.582ns 0.364016mA
+ 0.584ns 0.371632mA
+ 0.586ns 0.379248mA
+ 0.588ns 0.386864mA
+ 0.59ns 0.39448mA
+ 0.592ns 0.402096mA
+ 0.594ns 0.409713mA
+ 0.596ns 0.417329mA
+ 0.598ns 0.424945mA
+ 0.6ns 0.432561mA
+ 0.602ns 0.440177mA
+ 0.604ns 0.447793mA
+ 0.606ns 0.455409mA
+ 0.608ns 0.463026mA
+ 0.61ns 0.470642mA
+ 0.612ns 0.478258mA
+ 0.614ns 0.485874mA
+ 0.616ns 0.49349mA
+ 0.618ns 0.501106mA
+ 0.62ns 0.508722mA
+ 0.622ns 0.516339mA
+ 0.624ns 0.523955mA
+ 0.626ns 0.531571mA
+ 0.628ns 0.539187mA
+ 0.63ns 0.546803mA
+ 0.632ns 0.550907mA
+ 0.634ns 0.548495mA
+ 0.636ns 0.546094mA
+ 0.638ns 0.543703mA
+ 0.64ns 0.541323mA
+ 0.642ns 0.538953mA
+ 0.644ns 0.536593mA
+ 0.646ns 0.534244mA
+ 0.648ns 0.531905mA
+ 0.65ns 0.529576mA
+ 0.652ns 0.527258mA
+ 0.654ns 0.52495mA
+ 0.656ns 0.522651mA
+ 0.658ns 0.520363mA
+ 0.66ns 0.518085mA
+ 0.662ns 0.515817mA
+ 0.664ns 0.513559mA
+ 0.666ns 0.51131mA
+ 0.668ns 0.509072mA
+ 0.67ns 0.506843mA
+ 0.672ns 0.504624mA
+ 0.674ns 0.502415mA
+ 0.676ns 0.500215mA
+ 0.678ns 0.498025mA
+ 0.68ns 0.495845mA
+ 0.682ns 0.493674mA
+ 0.684ns 0.491513mA
+ 0.686ns 0.489361mA
+ 0.688ns 0.487218mA
+ 0.69ns 0.485085mA
+ 0.692ns 0.482961mA
+ 0.694ns 0.480847mA
+ 0.696ns 0.478742mA
+ 0.698ns 0.476646mA
+ 0.7ns 0.474559mA
+ 0.702ns 0.472481mA
+ 0.704ns 0.470413mA
+ 0.706ns 0.468353mA
+ 0.708ns 0.466303mA
+ 0.71ns 0.464261mA
+ 0.712ns 0.462228mA
+ 0.714ns 0.460205mA
+ 0.716ns 0.45819mA
+ 0.718ns 0.456184mA
+ 0.72ns 0.454187mA
+ 0.722ns 0.452198mA
+ 0.724ns 0.450218mA
+ 0.726ns 0.448247mA
+ 0.728ns 0.446285mA
+ 0.73ns 0.444331mA
+ 0.732ns 0.442385mA
+ 0.734ns 0.440449mA
+ 0.736ns 0.43852mA
+ 0.738ns 0.4366mA
+ 0.74ns 0.434689mA
+ 0.742ns 0.432786mA
+ 0.744ns 0.430891mA
+ 0.746ns 0.429004mA
+ 0.748ns 0.427126mA
+ 0.75ns 0.425256mA
+ 0.752ns 0.423394mA
+ 0.754ns 0.42154mA
+ 0.756ns 0.419695mA
+ 0.758ns 0.417857mA
+ 0.76ns 0.416028mA
+ 0.762ns 0.414206mA
+ 0.764ns 0.412393mA
+ 0.766ns 0.410587mA
+ 0.768ns 0.40879mA
+ 0.77ns 0.407mA
+ 0.772ns 0.405218mA
+ 0.774ns 0.403444mA
+ 0.776ns 0.401677mA
+ 0.778ns 0.399919mA
+ 0.78ns 0.398168mA
+ 0.782ns 0.396424mA
+ 0.784ns 0.394689mA
+ 0.786ns 0.392961mA
+ 0.788ns 0.39124mA
+ 0.79ns 0.389527mA
+ 0.792ns 0.387822mA
+ 0.794ns 0.386124mA
+ 0.796ns 0.384433mA
+ 0.798ns 0.38275mA
+ 0.8ns 0.381074mA
+ 0.802ns 0.379406mA
+ 0.804ns 0.377744mA
+ 0.806ns 0.37609mA
+ 0.808ns 0.374444mA
+ 0.81ns 0.372804mA
+ 0.812ns 0.371172mA
+ 0.814ns 0.369547mA
+ 0.816ns 0.367929mA
+ 0.818ns 0.366318mA
+ 0.82ns 0.364714mA
+ 0.822ns 0.363117mA
+ 0.824ns 0.361527mA
+ 0.826ns 0.359944mA
+ 0.828ns 0.358368mA
+ 0.83ns 0.356799mA
+ 0.832ns 0.355237mA
+ 0.834ns 0.353682mA
+ 0.836ns 0.352133mA
+ 0.838ns 0.350591mA
+ 0.84ns 0.349056mA
+ 0.842ns 0.347528mA
+ 0.844ns 0.346006mA
+ 0.846ns 0.344491mA
+ 0.848ns 0.342983mA
+ 0.85ns 0.341481mA
+ 0.852ns 0.339986mA
+ 0.854ns 0.338498mA
+ 0.856ns 0.337015mA
+ 0.858ns 0.33554mA
+ 0.86ns 0.334071mA
+ 0.862ns 0.332608mA
+ 0.864ns 0.331152mA
+ 0.866ns 0.329702mA
+ 0.868ns 0.328258mA
+ 0.87ns 0.326821mA
+ 0.872ns 0.32539mA
+ 0.874ns 0.323965mA
+ 0.876ns 0.322547mA
+ 0.878ns 0.321134mA
+ 0.88ns 0.319728mA
+ 0.882ns 0.318328mA
+ 0.884ns 0.316934mA
+ 0.886ns 0.315547mA
+ 0.888ns 0.314165mA
+ 0.89ns 0.31279mA
+ 0.892ns 0.31142mA
+ 0.894ns 0.310056mA
+ 0.896ns 0.308699mA
+ 0.898ns 0.307347mA
+ 0.9ns 0.306001mA
+ 0.902ns 0.304662mA
+ 0.904ns 0.303328mA
+ 0.906ns 0.301999mA
+ 0.908ns 0.300677mA
+ 0.91ns 0.299361mA
+ 0.912ns 0.29805mA
+ 0.914ns 0.296745mA
+ 0.916ns 0.295445mA
+ 0.918ns 0.294152mA
+ 0.92ns 0.292864mA
+ 0.922ns 0.291581mA
+ 0.924ns 0.290305mA
+ 0.926ns 0.289034mA
+ 0.928ns 0.287768mA
+ 0.93ns 0.286508mA
+ 0.932ns 0.285253mA
+ 0.934ns 0.284004mA
+ 0.936ns 0.282761mA
+ 0.938ns 0.281523mA
+ 0.94ns 0.28029mA
+ 0.942ns 0.279063mA
+ 0.944ns 0.277841mA
+ 0.946ns 0.276624mA
+ 0.948ns 0.275413mA
+ 0.95ns 0.274207mA
+ 0.952ns 0.273006mA
+ 0.954ns 0.271811mA
+ 0.956ns 0.270621mA
+ 0.958ns 0.269436mA
+ 0.96ns 0.268256mA
+ 0.962ns 0.267081mA
+ 0.964ns 0.265912mA
+ 0.966ns 0.264748mA
+ 0.968ns 0.263588mA
+ 0.97ns 0.262434mA
+ 0.972ns 0.261285mA
+ 0.974ns 0.260141mA
+ 0.976ns 0.259002mA
+ 0.978ns 0.257868mA
+ 0.98ns 0.256739mA
+ 0.982ns 0.255614mA
+ 0.984ns 0.254495mA
+ 0.986ns 0.253381mA
+ 0.988ns 0.252271mA
+ 0.99ns 0.251167mA
+ 0.992ns 0.250067mA
+ 0.994ns 0.248972mA
+ 0.996ns 0.247882mA
+ 0.998ns 0.246796mA
+ 1ns 0.245715mA
+ 1.002ns 0.244639mA
+ 1.004ns 0.243568mA
+ 1.006ns 0.242502mA
+ 1.008ns 0.24144mA
+ 1.01ns 0.240383mA
+ 1.012ns 0.23933mA
+ 1.014ns 0.238282mA
+ 1.016ns 0.237239mA
+ 1.018ns 0.2362mA
+ 1.02ns 0mA
+ 7.998ns 0mA
+ 8ns 0.0517535mA
+ 8.002ns 0.0593691mA
+ 8.004ns 0.0669847mA
+ 8.006ns 0.0746003mA
+ 8.008ns 0.0822195mA
+ 8.01ns 0.0898351mA
+ 8.012ns 0.0974507mA
+ 8.014ns 0.105066mA
+ 8.016ns 0.112682mA
+ 8.018ns 0.120297mA
+ 8.02ns 0.127917mA
+ 8.022ns 0.135532mA
+ 8.024ns 0.143148mA
+ 8.026ns 0.150763mA
+ 8.028ns 0.158379mA
+ 8.03ns 0.165995mA
+ 8.032ns 0.17361mA
+ 8.034ns 0.18123mA
+ 8.036ns 0.188845mA
+ 8.038ns 0.196461mA
+ 8.04ns 0.204076mA
+ 8.042ns 0.211692mA
+ 8.044ns 0.219307mA
+ 8.046ns 0.226923mA
+ 8.048ns 0.234542mA
+ 8.05ns 0.242158mA
+ 8.052ns 0.249774mA
+ 8.054ns 0.257389mA
+ 8.056ns 0.265005mA
+ 8.058ns 0.27262mA
+ 8.06ns 0.28024mA
+ 8.062ns 0.287855mA
+ 8.064ns 0.295471mA
+ 8.066ns 0.303086mA
+ 8.068ns 0.310702mA
+ 8.07ns 0.318318mA
+ 8.072ns 0.325933mA
+ 8.074ns 0.333552mA
+ 8.076ns 0.341168mA
+ 8.078ns 0.348784mA
+ 8.08ns 0.356399mA
+ 8.082ns 0.364015mA
+ 8.084ns 0.37163mA
+ 8.086ns 0.37925mA
+ 8.088ns 0.386865mA
+ 8.09ns 0.394481mA
+ 8.092ns 0.402096mA
+ 8.094ns 0.409712mA
+ 8.096ns 0.417328mA
+ 8.098ns 0.424943mA
+ 8.1ns 0.432562mA
+ 8.102ns 0.440178mA
+ 8.104ns 0.447794mA
+ 8.106ns 0.455409mA
+ 8.108ns 0.463025mA
+ 8.11ns 0.47064mA
+ 8.112ns 0.47826mA
+ 8.114ns 0.485875mA
+ 8.116ns 0.493491mA
+ 8.118ns 0.501106mA
+ 8.12ns 0.508722mA
+ 8.122ns 0.516338mA
+ 8.124ns 0.523953mA
+ 8.126ns 0.531572mA
+ 8.128ns 0.539188mA
+ 8.13ns 0.546804mA
+ 8.132ns 0.550907mA
+ 8.134ns 0.548495mA
+ 8.136ns 0.546094mA
+ 8.138ns 0.543703mA
+ 8.14ns 0.541322mA
+ 8.142ns 0.538952mA
+ 8.144ns 0.536593mA
+ 8.146ns 0.534244mA
+ 8.148ns 0.531905mA
+ 8.15ns 0.529577mA
+ 8.152ns 0.527257mA
+ 8.154ns 0.524949mA
+ 8.156ns 0.522651mA
+ 8.158ns 0.520363mA
+ 8.16ns 0.518085mA
+ 8.162ns 0.515817mA
+ 8.164ns 0.513559mA
+ 8.166ns 0.51131mA
+ 8.168ns 0.509071mA
+ 8.17ns 0.506843mA
+ 8.172ns 0.504624mA
+ 8.174ns 0.502415mA
+ 8.176ns 0.500215mA
+ 8.178ns 0.498025mA
+ 8.18ns 0.495844mA
+ 8.182ns 0.493674mA
+ 8.184ns 0.491513mA
+ 8.186ns 0.489361mA
+ 8.188ns 0.487218mA
+ 8.19ns 0.485086mA
+ 8.192ns 0.482961mA
+ 8.194ns 0.480847mA
+ 8.196ns 0.478742mA
+ 8.198ns 0.476646mA
+ 8.2ns 0.474559mA
+ 8.202ns 0.472482mA
+ 8.204ns 0.470412mA
+ 8.206ns 0.468353mA
+ 8.208ns 0.466302mA
+ 8.21ns 0.464261mA
+ 8.212ns 0.462229mA
+ 8.214ns 0.460205mA
+ 8.216ns 0.45819mA
+ 8.218ns 0.456184mA
+ 8.22ns 0.454186mA
+ 8.222ns 0.452198mA
+ 8.224ns 0.450218mA
+ 8.226ns 0.448247mA
+ 8.228ns 0.446285mA
+ 8.23ns 0.444331mA
+ 8.232ns 0.442385mA
+ 8.234ns 0.440448mA
+ 8.236ns 0.43852mA
+ 8.238ns 0.4366mA
+ 8.24ns 0.434689mA
+ 8.242ns 0.432786mA
+ 8.244ns 0.43089mA
+ 8.246ns 0.429004mA
+ 8.248ns 0.427126mA
+ 8.25ns 0.425256mA
+ 8.252ns 0.423394mA
+ 8.254ns 0.421541mA
+ 8.256ns 0.419695mA
+ 8.258ns 0.417857mA
+ 8.26ns 0.416028mA
+ 8.262ns 0.414206mA
+ 8.264ns 0.412393mA
+ 8.266ns 0.410587mA
+ 8.268ns 0.40879mA
+ 8.27ns 0.406999mA
+ 8.272ns 0.405217mA
+ 8.274ns 0.403443mA
+ 8.276ns 0.401677mA
+ 8.278ns 0.399919mA
+ 8.28ns 0.398168mA
+ 8.282ns 0.396425mA
+ 8.284ns 0.394688mA
+ 8.286ns 0.39296mA
+ 8.288ns 0.39124mA
+ 8.29ns 0.389527mA
+ 8.292ns 0.387822mA
+ 8.294ns 0.386124mA
+ 8.296ns 0.384433mA
+ 8.298ns 0.38275mA
+ 8.3ns 0.381074mA
+ 8.302ns 0.379406mA
+ 8.304ns 0.377744mA
+ 8.306ns 0.376091mA
+ 8.308ns 0.374444mA
+ 8.31ns 0.372804mA
+ 8.312ns 0.371172mA
+ 8.314ns 0.369547mA
+ 8.316ns 0.367929mA
+ 8.318ns 0.366318mA
+ 8.32ns 0.364714mA
+ 8.322ns 0.363118mA
+ 8.324ns 0.361527mA
+ 8.326ns 0.359944mA
+ 8.328ns 0.358368mA
+ 8.33ns 0.356799mA
+ 8.332ns 0.355237mA
+ 8.334ns 0.353682mA
+ 8.336ns 0.352133mA
+ 8.338ns 0.350591mA
+ 8.34ns 0.349056mA
+ 8.342ns 0.347528mA
+ 8.344ns 0.346007mA
+ 8.346ns 0.344492mA
+ 8.348ns 0.342983mA
+ 8.35ns 0.341481mA
+ 8.352ns 0.339986mA
+ 8.354ns 0.338498mA
+ 8.356ns 0.337016mA
+ 8.358ns 0.33554mA
+ 8.36ns 0.334071mA
+ 8.362ns 0.332608mA
+ 8.364ns 0.331151mA
+ 8.366ns 0.329702mA
+ 8.368ns 0.328258mA
+ 8.37ns 0.326821mA
+ 8.372ns 0.32539mA
+ 8.374ns 0.323965mA
+ 8.376ns 0.322546mA
+ 8.378ns 0.321134mA
+ 8.38ns 0.319728mA
+ 8.382ns 0.318328mA
+ 8.384ns 0.316935mA
+ 8.386ns 0.315547mA
+ 8.388ns 0.314165mA
+ 8.39ns 0.312789mA
+ 8.392ns 0.31142mA
+ 8.394ns 0.310056mA
+ 8.396ns 0.308699mA
+ 8.398ns 0.307347mA
+ 8.4ns 0.306002mA
+ 8.402ns 0.304661mA
+ 8.404ns 0.303327mA
+ 8.406ns 0.301999mA
+ 8.408ns 0.300677mA
+ 8.41ns 0.299361mA
+ 8.412ns 0.29805mA
+ 8.414ns 0.296745mA
+ 8.416ns 0.295445mA
+ 8.418ns 0.294152mA
+ 8.42ns 0.292864mA
+ 8.422ns 0.291581mA
+ 8.424ns 0.290305mA
+ 8.426ns 0.289034mA
+ 8.428ns 0.287768mA
+ 8.43ns 0.286508mA
+ 8.432ns 0.285253mA
+ 8.434ns 0.284004mA
+ 8.436ns 0.282761mA
+ 8.438ns 0.281523mA
+ 8.44ns 0.28029mA
+ 8.442ns 0.279063mA
+ 8.444ns 0.277841mA
+ 8.446ns 0.276624mA
+ 8.448ns 0.275413mA
+ 8.45ns 0.274207mA
+ 8.452ns 0.273007mA
+ 8.454ns 0.271811mA
+ 8.456ns 0.270621mA
+ 8.458ns 0.269436mA
+ 8.46ns 0.268256mA
+ 8.462ns 0.267081mA
+ 8.464ns 0.265912mA
+ 8.466ns 0.264748mA
+ 8.468ns 0.263588mA
+ 8.47ns 0.262434mA
+ 8.472ns 0.261285mA
+ 8.474ns 0.260141mA
+ 8.476ns 0.259002mA
+ 8.478ns 0.257868mA
+ 8.48ns 0.256738mA
+ 8.482ns 0.255614mA
+ 8.484ns 0.254495mA
+ 8.486ns 0.253381mA
+ 8.488ns 0.252271mA
+ 8.49ns 0.251167mA
+ 8.492ns 0.250067mA
+ 8.494ns 0.248972mA
+ 8.496ns 0.247881mA
+ 8.498ns 0.246796mA
+ 8.5ns 0.245715mA
+ 8.502ns 0.24464mA
+ 8.504ns 0.243568mA
+ 8.506ns 0.242502mA
+ 8.508ns 0.24144mA
+ 8.51ns 0.240383mA
+ 8.512ns 0.23933mA
+ 8.514ns 0.238282mA
+ 8.516ns 0.237239mA
+ 8.518ns 0.2362mA
+ 8.52ns 0mA
I177 337 0 PWL 0 0
+ 5.488ns 0mA
+ 5.49ns 0.00341442mA
+ 5.492ns 0.0110431mA
+ 5.494ns 0.0186719mA
+ 5.496ns 0.0263024mA
+ 5.498ns 0.0339311mA
+ 5.5ns 0.0415598mA
+ 5.502ns 0.0491886mA
+ 5.504ns 0.0568191mA
+ 5.506ns 0.0644478mA
+ 5.508ns 0.0720765mA
+ 5.51ns 0.0797071mA
+ 5.512ns 0.0873358mA
+ 5.514ns 0.0949645mA
+ 5.516ns 0.102595mA
+ 5.518ns 0.110224mA
+ 5.52ns 0.117852mA
+ 5.522ns 0.125481mA
+ 5.524ns 0.133112mA
+ 5.526ns 0.14074mA
+ 5.528ns 0.148369mA
+ 5.53ns 0.156mA
+ 5.532ns 0.163628mA
+ 5.534ns 0.171257mA
+ 5.536ns 0.178888mA
+ 5.538ns 0.186516mA
+ 5.54ns 0.194145mA
+ 5.542ns 0.201776mA
+ 5.544ns 0.209404mA
+ 5.546ns 0.217033mA
+ 5.548ns 0.224662mA
+ 5.55ns 0.232292mA
+ 5.552ns 0.239921mA
+ 5.554ns 0.24755mA
+ 5.556ns 0.25518mA
+ 5.558ns 0.262809mA
+ 5.56ns 0.270438mA
+ 5.562ns 0.278068mA
+ 5.564ns 0.285697mA
+ 5.566ns 0.293326mA
+ 5.568ns 0.300954mA
+ 5.57ns 0.308585mA
+ 5.572ns 0.316214mA
+ 5.574ns 0.323842mA
+ 5.576ns 0.331473mA
+ 5.578ns 0.339102mA
+ 5.58ns 0.34673mA
+ 5.582ns 0.354361mA
+ 5.584ns 0.36199mA
+ 5.586ns 0.369618mA
+ 5.588ns 0.377249mA
+ 5.59ns 0.384878mA
+ 5.592ns 0.392506mA
+ 5.594ns 0.400135mA
+ 5.596ns 0.407766mA
+ 5.598ns 0.415394mA
+ 5.6ns 0.423023mA
+ 5.602ns 0.430654mA
+ 5.604ns 0.438282mA
+ 5.606ns 0.445911mA
+ 5.608ns 0.453542mA
+ 5.61ns 0.46117mA
+ 5.612ns 0.468799mA
+ 5.614ns 0.476428mA
+ 5.616ns 0.484058mA
+ 5.618ns 0.491687mA
+ 5.62ns 0.499316mA
+ 5.622ns 0.506946mA
+ 5.624ns 0.514575mA
+ 5.626ns 0.522204mA
+ 5.628ns 0.529834mA
+ 5.63ns 0.537463mA
+ 5.632ns 0.545092mA
+ 5.634ns 0.550711mA
+ 5.636ns 0.548306mA
+ 5.638ns 0.545911mA
+ 5.64ns 0.543526mA
+ 5.642ns 0.541152mA
+ 5.644ns 0.538788mA
+ 5.646ns 0.536434mA
+ 5.648ns 0.534091mA
+ 5.65ns 0.531758mA
+ 5.652ns 0.529435mA
+ 5.654ns 0.527122mA
+ 5.656ns 0.52482mA
+ 5.658ns 0.522527mA
+ 5.66ns 0.520245mA
+ 5.662ns 0.517972mA
+ 5.664ns 0.515709mA
+ 5.666ns 0.513457mA
+ 5.668ns 0.511213mA
+ 5.67ns 0.50898mA
+ 5.672ns 0.506757mA
+ 5.674ns 0.504543mA
+ 5.676ns 0.502339mA
+ 5.678ns 0.500145mA
+ 5.68ns 0.49796mA
+ 5.682ns 0.495785mA
+ 5.684ns 0.493619mA
+ 5.686ns 0.491463mA
+ 5.688ns 0.489316mA
+ 5.69ns 0.487178mA
+ 5.692ns 0.48505mA
+ 5.694ns 0.482931mA
+ 5.696ns 0.480821mA
+ 5.698ns 0.478721mA
+ 5.7ns 0.476629mA
+ 5.702ns 0.474548mA
+ 5.704ns 0.472475mA
+ 5.706ns 0.470411mA
+ 5.708ns 0.468356mA
+ 5.71ns 0.46631mA
+ 5.712ns 0.464273mA
+ 5.714ns 0.462244mA
+ 5.716ns 0.460225mA
+ 5.718ns 0.458215mA
+ 5.72ns 0.456213mA
+ 5.722ns 0.45422mA
+ 5.724ns 0.452236mA
+ 5.726ns 0.45026mA
+ 5.728ns 0.448293mA
+ 5.73ns 0.446335mA
+ 5.732ns 0.444385mA
+ 5.734ns 0.442444mA
+ 5.736ns 0.440511mA
+ 5.738ns 0.438587mA
+ 5.74ns 0.43667mA
+ 5.742ns 0.434763mA
+ 5.744ns 0.432864mA
+ 5.746ns 0.430973mA
+ 5.748ns 0.42909mA
+ 5.75ns 0.427216mA
+ 5.752ns 0.425349mA
+ 5.754ns 0.423491mA
+ 5.756ns 0.421641mA
+ 5.758ns 0.419799mA
+ 5.76ns 0.417965mA
+ 5.762ns 0.416139mA
+ 5.764ns 0.414321mA
+ 5.766ns 0.412511mA
+ 5.768ns 0.410709mA
+ 5.77ns 0.408915mA
+ 5.772ns 0.407128mA
+ 5.774ns 0.40535mA
+ 5.776ns 0.403579mA
+ 5.778ns 0.401816mA
+ 5.78ns 0.400061mA
+ 5.782ns 0.398313mA
+ 5.784ns 0.396573mA
+ 5.786ns 0.39484mA
+ 5.788ns 0.393116mA
+ 5.79ns 0.391398mA
+ 5.792ns 0.389688mA
+ 5.794ns 0.387986mA
+ 5.796ns 0.386291mA
+ 5.798ns 0.384604mA
+ 5.8ns 0.382923mA
+ 5.802ns 0.38125mA
+ 5.804ns 0.379585mA
+ 5.806ns 0.377926mA
+ 5.808ns 0.376275mA
+ 5.81ns 0.374632mA
+ 5.812ns 0.372995mA
+ 5.814ns 0.371365mA
+ 5.816ns 0.369743mA
+ 5.818ns 0.368128mA
+ 5.82ns 0.36652mA
+ 5.822ns 0.364918mA
+ 5.824ns 0.363324mA
+ 5.826ns 0.361737mA
+ 5.828ns 0.360157mA
+ 5.83ns 0.358583mA
+ 5.832ns 0.357016mA
+ 5.834ns 0.355457mA
+ 5.836ns 0.353904mA
+ 5.838ns 0.352358mA
+ 5.84ns 0.350818mA
+ 5.842ns 0.349286mA
+ 5.844ns 0.34776mA
+ 5.846ns 0.346241mA
+ 5.848ns 0.344728mA
+ 5.85ns 0.343222mA
+ 5.852ns 0.341722mA
+ 5.854ns 0.34023mA
+ 5.856ns 0.338743mA
+ 5.858ns 0.337263mA
+ 5.86ns 0.33579mA
+ 5.862ns 0.334323mA
+ 5.864ns 0.332862mA
+ 5.866ns 0.331408mA
+ 5.868ns 0.32996mA
+ 5.87ns 0.328519mA
+ 5.872ns 0.327083mA
+ 5.874ns 0.325654mA
+ 5.876ns 0.324232mA
+ 5.878ns 0.322815mA
+ 5.88ns 0.321405mA
+ 5.882ns 0.320001mA
+ 5.884ns 0.318603mA
+ 5.886ns 0.317211mA
+ 5.888ns 0.315825mA
+ 5.89ns 0.314445mA
+ 5.892ns 0.313071mA
+ 5.894ns 0.311704mA
+ 5.896ns 0.310342mA
+ 5.898ns 0.308986mA
+ 5.9ns 0.307636mA
+ 5.902ns 0.306292mA
+ 5.904ns 0.304954mA
+ 5.906ns 0.303621mA
+ 5.908ns 0.302295mA
+ 5.91ns 0.300974mA
+ 5.912ns 0.299659mA
+ 5.914ns 0.29835mA
+ 5.916ns 0.297047mA
+ 5.918ns 0.295749mA
+ 5.92ns 0.294457mA
+ 5.922ns 0.29317mA
+ 5.924ns 0.291889mA
+ 5.926ns 0.290614mA
+ 5.928ns 0.289345mA
+ 5.93ns 0.28808mA
+ 5.932ns 0.286822mA
+ 5.934ns 0.285569mA
+ 5.936ns 0.284321mA
+ 5.938ns 0.283079mA
+ 5.94ns 0.281842mA
+ 5.942ns 0.280611mA
+ 5.944ns 0.279385mA
+ 5.946ns 0.278164mA
+ 5.948ns 0.276949mA
+ 5.95ns 0.275739mA
+ 5.952ns 0.274534mA
+ 5.954ns 0.273335mA
+ 5.956ns 0.27214mA
+ 5.958ns 0.270951mA
+ 5.96ns 0.269768mA
+ 5.962ns 0.268589mA
+ 5.964ns 0.267416mA
+ 5.966ns 0.266247mA
+ 5.968ns 0.265084mA
+ 5.97ns 0.263926mA
+ 5.972ns 0.262773mA
+ 5.974ns 0.261625mA
+ 5.976ns 0.260482mA
+ 5.978ns 0.259344mA
+ 5.98ns 0.258211mA
+ 5.982ns 0.257082mA
+ 5.984ns 0.255959mA
+ 5.986ns 0.254841mA
+ 5.988ns 0.253727mA
+ 5.99ns 0.252619mA
+ 5.992ns 0.251515mA
+ 5.994ns 0.250416mA
+ 5.996ns 0.249322mA
+ 5.998ns 0.248233mA
+ 6ns 0.247148mA
+ 6.002ns 0.246069mA
+ 6.004ns 0.244993mA
+ 6.006ns 0.243923mA
+ 6.008ns 0.242857mA
+ 6.01ns 0.241796mA
+ 6.012ns 0.24074mA
+ 6.014ns 0.239688mA
+ 6.016ns 0.238641mA
+ 6.018ns 0.237598mA
+ 6.02ns 0.23656mA
+ 6.022ns 0.235526mA
+ 6.024ns 0mA
+ 7.998ns 0mA
+ 8ns 0.041558mA
+ 8.002ns 0.0491867mA
+ 8.004ns 0.0568155mA
+ 8.006ns 0.0644442mA
+ 8.008ns 0.0720765mA
+ 8.01ns 0.0797052mA
+ 8.012ns 0.087334mA
+ 8.014ns 0.0949627mA
+ 8.016ns 0.102591mA
+ 8.018ns 0.11022mA
+ 8.02ns 0.117852mA
+ 8.022ns 0.125481mA
+ 8.024ns 0.13311mA
+ 8.026ns 0.140739mA
+ 8.028ns 0.148367mA
+ 8.03ns 0.155996mA
+ 8.032ns 0.163625mA
+ 8.034ns 0.171257mA
+ 8.036ns 0.178886mA
+ 8.038ns 0.186515mA
+ 8.04ns 0.194143mA
+ 8.042ns 0.201772mA
+ 8.044ns 0.209401mA
+ 8.046ns 0.217029mA
+ 8.048ns 0.224662mA
+ 8.05ns 0.232291mA
+ 8.052ns 0.239919mA
+ 8.054ns 0.247548mA
+ 8.056ns 0.255177mA
+ 8.058ns 0.262805mA
+ 8.06ns 0.270438mA
+ 8.062ns 0.278067mA
+ 8.064ns 0.285695mA
+ 8.066ns 0.293324mA
+ 8.068ns 0.300953mA
+ 8.07ns 0.308581mA
+ 8.072ns 0.31621mA
+ 8.074ns 0.323842mA
+ 8.076ns 0.331471mA
+ 8.078ns 0.3391mA
+ 8.08ns 0.346729mA
+ 8.082ns 0.354357mA
+ 8.084ns 0.361986mA
+ 8.086ns 0.369618mA
+ 8.088ns 0.377247mA
+ 8.09ns 0.384876mA
+ 8.092ns 0.392505mA
+ 8.094ns 0.400133mA
+ 8.096ns 0.407762mA
+ 8.098ns 0.415391mA
+ 8.1ns 0.423023mA
+ 8.102ns 0.430652mA
+ 8.104ns 0.438281mA
+ 8.106ns 0.445909mA
+ 8.108ns 0.453538mA
+ 8.11ns 0.461167mA
+ 8.112ns 0.468799mA
+ 8.114ns 0.476428mA
+ 8.116ns 0.484056mA
+ 8.118ns 0.491685mA
+ 8.12ns 0.499314mA
+ 8.122ns 0.506943mA
+ 8.124ns 0.514571mA
+ 8.126ns 0.522204mA
+ 8.128ns 0.529832mA
+ 8.13ns 0.537461mA
+ 8.132ns 0.54509mA
+ 8.134ns 0.550712mA
+ 8.136ns 0.548307mA
+ 8.138ns 0.545912mA
+ 8.14ns 0.543526mA
+ 8.142ns 0.541152mA
+ 8.144ns 0.538788mA
+ 8.146ns 0.536435mA
+ 8.148ns 0.534092mA
+ 8.15ns 0.531759mA
+ 8.152ns 0.529435mA
+ 8.154ns 0.527123mA
+ 8.156ns 0.52482mA
+ 8.158ns 0.522528mA
+ 8.16ns 0.520245mA
+ 8.162ns 0.517973mA
+ 8.164ns 0.51571mA
+ 8.166ns 0.513457mA
+ 8.168ns 0.511214mA
+ 8.17ns 0.508981mA
+ 8.172ns 0.506758mA
+ 8.174ns 0.504544mA
+ 8.176ns 0.50234mA
+ 8.178ns 0.500145mA
+ 8.18ns 0.49796mA
+ 8.182ns 0.495785mA
+ 8.184ns 0.493619mA
+ 8.186ns 0.491463mA
+ 8.188ns 0.489317mA
+ 8.19ns 0.487179mA
+ 8.192ns 0.48505mA
+ 8.194ns 0.482931mA
+ 8.196ns 0.480822mA
+ 8.198ns 0.478722mA
+ 8.2ns 0.476631mA
+ 8.202ns 0.474549mA
+ 8.204ns 0.472475mA
+ 8.206ns 0.470411mA
+ 8.208ns 0.468356mA
+ 8.21ns 0.46631mA
+ 8.212ns 0.464273mA
+ 8.214ns 0.462245mA
+ 8.216ns 0.460226mA
+ 8.218ns 0.458215mA
+ 8.22ns 0.456213mA
+ 8.222ns 0.45422mA
+ 8.224ns 0.452236mA
+ 8.226ns 0.450261mA
+ 8.228ns 0.448294mA
+ 8.23ns 0.446336mA
+ 8.232ns 0.444385mA
+ 8.234ns 0.442444mA
+ 8.236ns 0.440511mA
+ 8.238ns 0.438587mA
+ 8.24ns 0.436671mA
+ 8.242ns 0.434764mA
+ 8.244ns 0.432864mA
+ 8.246ns 0.430973mA
+ 8.248ns 0.42909mA
+ 8.25ns 0.427216mA
+ 8.252ns 0.42535mA
+ 8.254ns 0.423492mA
+ 8.256ns 0.421642mA
+ 8.258ns 0.419799mA
+ 8.26ns 0.417965mA
+ 8.262ns 0.41614mA
+ 8.264ns 0.414322mA
+ 8.266ns 0.412512mA
+ 8.268ns 0.41071mA
+ 8.27ns 0.408915mA
+ 8.272ns 0.407129mA
+ 8.274ns 0.40535mA
+ 8.276ns 0.40358mA
+ 8.278ns 0.401817mA
+ 8.28ns 0.400061mA
+ 8.282ns 0.398314mA
+ 8.284ns 0.396573mA
+ 8.286ns 0.394841mA
+ 8.288ns 0.393116mA
+ 8.29ns 0.391399mA
+ 8.292ns 0.389689mA
+ 8.294ns 0.387987mA
+ 8.296ns 0.386291mA
+ 8.298ns 0.384604mA
+ 8.3ns 0.382924mA
+ 8.302ns 0.381251mA
+ 8.304ns 0.379585mA
+ 8.306ns 0.377927mA
+ 8.308ns 0.376276mA
+ 8.31ns 0.374632mA
+ 8.312ns 0.372995mA
+ 8.314ns 0.371366mA
+ 8.316ns 0.369744mA
+ 8.318ns 0.368128mA
+ 8.32ns 0.36652mA
+ 8.322ns 0.364919mA
+ 8.324ns 0.363324mA
+ 8.326ns 0.361737mA
+ 8.328ns 0.360157mA
+ 8.33ns 0.358584mA
+ 8.332ns 0.357017mA
+ 8.334ns 0.355458mA
+ 8.336ns 0.353904mA
+ 8.338ns 0.352358mA
+ 8.34ns 0.350819mA
+ 8.342ns 0.349286mA
+ 8.344ns 0.34776mA
+ 8.346ns 0.346241mA
+ 8.348ns 0.344729mA
+ 8.35ns 0.343222mA
+ 8.352ns 0.341723mA
+ 8.354ns 0.34023mA
+ 8.356ns 0.338744mA
+ 8.358ns 0.337264mA
+ 8.36ns 0.335791mA
+ 8.362ns 0.334323mA
+ 8.364ns 0.332862mA
+ 8.366ns 0.331408mA
+ 8.368ns 0.329961mA
+ 8.37ns 0.328519mA
+ 8.372ns 0.327084mA
+ 8.374ns 0.325655mA
+ 8.376ns 0.324232mA
+ 8.378ns 0.322815mA
+ 8.38ns 0.321405mA
+ 8.382ns 0.320001mA
+ 8.384ns 0.318603mA
+ 8.386ns 0.317211mA
+ 8.388ns 0.315825mA
+ 8.39ns 0.314445mA
+ 8.392ns 0.313072mA
+ 8.394ns 0.311704mA
+ 8.396ns 0.310342mA
+ 8.398ns 0.308986mA
+ 8.4ns 0.307637mA
+ 8.402ns 0.306292mA
+ 8.404ns 0.304954mA
+ 8.406ns 0.303622mA
+ 8.408ns 0.302295mA
+ 8.41ns 0.300975mA
+ 8.412ns 0.29966mA
+ 8.414ns 0.298351mA
+ 8.416ns 0.297047mA
+ 8.418ns 0.295749mA
+ 8.42ns 0.294457mA
+ 8.422ns 0.293171mA
+ 8.424ns 0.29189mA
+ 8.426ns 0.290615mA
+ 8.428ns 0.289345mA
+ 8.43ns 0.288081mA
+ 8.432ns 0.286822mA
+ 8.434ns 0.285569mA
+ 8.436ns 0.284322mA
+ 8.438ns 0.283079mA
+ 8.44ns 0.281843mA
+ 8.442ns 0.280611mA
+ 8.444ns 0.279385mA
+ 8.446ns 0.278164mA
+ 8.448ns 0.276949mA
+ 8.45ns 0.275739mA
+ 8.452ns 0.274535mA
+ 8.454ns 0.273335mA
+ 8.456ns 0.272141mA
+ 8.458ns 0.270952mA
+ 8.46ns 0.269768mA
+ 8.462ns 0.268589mA
+ 8.464ns 0.267416mA
+ 8.466ns 0.266248mA
+ 8.468ns 0.265084mA
+ 8.47ns 0.263926mA
+ 8.472ns 0.262773mA
+ 8.474ns 0.261625mA
+ 8.476ns 0.260482mA
+ 8.478ns 0.259344mA
+ 8.48ns 0.258211mA
+ 8.482ns 0.257082mA
+ 8.484ns 0.255959mA
+ 8.486ns 0.254841mA
+ 8.488ns 0.253728mA
+ 8.49ns 0.252619mA
+ 8.492ns 0.251516mA
+ 8.494ns 0.250416mA
+ 8.496ns 0.249322mA
+ 8.498ns 0.248233mA
+ 8.5ns 0.247149mA
+ 8.502ns 0.246069mA
+ 8.504ns 0.244994mA
+ 8.506ns 0.243923mA
+ 8.508ns 0.242857mA
+ 8.51ns 0.241796mA
+ 8.512ns 0.24074mA
+ 8.514ns 0.239688mA
+ 8.516ns 0.238641mA
+ 8.518ns 0.237598mA
+ 8.52ns 0.23656mA
+ 8.522ns 0.235526mA
+ 8.524ns 0mA
I178 338 0 PWL 0 0
+ 5.062ns 0mA
+ 5.064ns 0.00737281mA
+ 5.066ns 0.00870582mA
+ 5.068ns 0.0100388mA
+ 5.07ns 0.0113722mA
+ 5.072ns 0.0127052mA
+ 5.074ns 0.0140382mA
+ 5.076ns 0.0153715mA
+ 5.078ns 0.0167045mA
+ 5.08ns 0.0180375mA
+ 5.082ns 0.0193709mA
+ 5.084ns 0.0207039mA
+ 5.086ns 0.0220369mA
+ 5.088ns 0.0233699mA
+ 5.09ns 0.0247032mA
+ 5.092ns 0.0260362mA
+ 5.094ns 0.0273692mA
+ 5.096ns 0.0287026mA
+ 5.098ns 0.0300356mA
+ 5.1ns 0.0313686mA
+ 5.102ns 0.0327019mA
+ 5.104ns 0.0340349mA
+ 5.106ns 0.0353679mA
+ 5.108ns 0.0367012mA
+ 5.11ns 0.0380343mA
+ 5.112ns 0.0393673mA
+ 5.114ns 0.0407003mA
+ 5.116ns 0.0420336mA
+ 5.118ns 0.0433666mA
+ 5.12ns 0.0446996mA
+ 5.122ns 0.0460329mA
+ 5.124ns 0.047366mA
+ 5.126ns 0.048699mA
+ 5.128ns 0.0500323mA
+ 5.13ns 0.0513653mA
+ 5.132ns 0.0526983mA
+ 5.134ns 0.0540313mA
+ 5.136ns 0.0553646mA
+ 5.138ns 0.0566977mA
+ 5.14ns 0.0580307mA
+ 5.142ns 0.059364mA
+ 5.144ns 0.060697mA
+ 5.146ns 0.06203mA
+ 5.148ns 0.0633633mA
+ 5.15ns 0.0646963mA
+ 5.152ns 0.0660294mA
+ 5.154ns 0.0673627mA
+ 5.156ns 0.0686957mA
+ 5.158ns 0.0700287mA
+ 5.16ns 0.0691746mA
+ 5.162ns 0.0669232mA
+ 5.164ns 0.0647455mA
+ 5.166ns 0.0626386mA
+ 5.168ns 0.0605998mA
+ 5.17ns 0.0586278mA
+ 5.172ns 0.05672mA
+ 5.174ns 0.0548738mA
+ 5.176ns 0.0530881mA
+ 5.178ns 0.0513605mA
+ 5.18ns 0.0496891mA
+ 5.182ns 0.0480717mA
+ 5.184ns 0.0465073mA
+ 5.186ns 0.0449938mA
+ 5.188ns 0.0435292mA
+ 5.19ns 0.0421126mA
+ 5.192ns 0.0407421mA
+ 5.194ns 0.0394158mA
+ 5.196ns 0.0381331mA
+ 5.198ns 0.036892mA
+ 5.2ns 0.0356911mA
+ 5.202ns 0.0345295mA
+ 5.204ns 0.0334057mA
+ 5.206ns 0.0323185mA
+ 5.208ns 0.0312664mA
+ 5.21ns 0.0302488mA
+ 5.212ns 0.0292643mA
+ 5.214ns 0.0283116mA
+ 5.216ns 0.0273902mA
+ 5.218ns 0.0264987mA
+ 5.22ns 0.025636mA
+ 5.222ns 0.0248016mA
+ 5.224ns 0.0239944mA
+ 5.226ns 0.0232134mA
+ 5.228ns 0.0224576mA
+ 5.23ns 0.0217267mA
+ 5.232ns 0.0210195mA
+ 5.234ns 0.0203352mA
+ 5.236ns 0.0196732mA
+ 5.238ns 0.0190329mA
+ 5.24ns 0.0184132mA
+ 5.242ns 0.0178139mA
+ 5.244ns 0.017234mA
+ 5.246ns 0.0166729mA
+ 5.248ns 0.0161302mA
+ 5.25ns 0.0156051mA
+ 5.252ns 0.0150971mA
+ 5.254ns 0mA
+ 7.562ns 0mA
+ 7.564ns 0.00737281mA
+ 7.566ns 0.00870582mA
+ 7.568ns 0.0100388mA
+ 7.57ns 0.0113722mA
+ 7.572ns 0.0127052mA
+ 7.574ns 0.0140382mA
+ 7.576ns 0.0153715mA
+ 7.578ns 0.0167045mA
+ 7.58ns 0.0180375mA
+ 7.582ns 0.0193709mA
+ 7.584ns 0.0207039mA
+ 7.586ns 0.0220369mA
+ 7.588ns 0.0233702mA
+ 7.59ns 0.0247032mA
+ 7.592ns 0.0260362mA
+ 7.594ns 0.0273692mA
+ 7.596ns 0.0287026mA
+ 7.598ns 0.0300356mA
+ 7.6ns 0.0313686mA
+ 7.602ns 0.0327019mA
+ 7.604ns 0.0340349mA
+ 7.606ns 0.0353679mA
+ 7.608ns 0.0367012mA
+ 7.61ns 0.0380343mA
+ 7.612ns 0.0393673mA
+ 7.614ns 0.0407003mA
+ 7.616ns 0.0420336mA
+ 7.618ns 0.0433666mA
+ 7.62ns 0.0446996mA
+ 7.622ns 0.0460329mA
+ 7.624ns 0.047366mA
+ 7.626ns 0.048699mA
+ 7.628ns 0.0500323mA
+ 7.63ns 0.0513653mA
+ 7.632ns 0.0526983mA
+ 7.634ns 0.0540316mA
+ 7.636ns 0.0553646mA
+ 7.638ns 0.0566977mA
+ 7.64ns 0.0580307mA
+ 7.642ns 0.059364mA
+ 7.644ns 0.060697mA
+ 7.646ns 0.06203mA
+ 7.648ns 0.0633633mA
+ 7.65ns 0.0646963mA
+ 7.652ns 0.0660294mA
+ 7.654ns 0.0673627mA
+ 7.656ns 0.0686957mA
+ 7.658ns 0.0700287mA
+ 7.66ns 0.0691746mA
+ 7.662ns 0.0669232mA
+ 7.664ns 0.0647455mA
+ 7.666ns 0.0626386mA
+ 7.668ns 0.0605998mA
+ 7.67ns 0.0586278mA
+ 7.672ns 0.05672mA
+ 7.674ns 0.0548738mA
+ 7.676ns 0.0530881mA
+ 7.678ns 0.0513605mA
+ 7.68ns 0.0496887mA
+ 7.682ns 0.0480717mA
+ 7.684ns 0.0465073mA
+ 7.686ns 0.0449938mA
+ 7.688ns 0.0435292mA
+ 7.69ns 0.0421126mA
+ 7.692ns 0.0407421mA
+ 7.694ns 0.0394158mA
+ 7.696ns 0.0381331mA
+ 7.698ns 0.036892mA
+ 7.7ns 0.0356911mA
+ 7.702ns 0.0345295mA
+ 7.704ns 0.0334057mA
+ 7.706ns 0.0323185mA
+ 7.708ns 0.0312664mA
+ 7.71ns 0.0302488mA
+ 7.712ns 0.0292643mA
+ 7.714ns 0.0283116mA
+ 7.716ns 0.0273902mA
+ 7.718ns 0.0264987mA
+ 7.72ns 0.025636mA
+ 7.722ns 0.0248016mA
+ 7.724ns 0.0239944mA
+ 7.726ns 0.0232132mA
+ 7.728ns 0.0224576mA
+ 7.73ns 0.0217267mA
+ 7.732ns 0.0210195mA
+ 7.734ns 0.0203352mA
+ 7.736ns 0.0196732mA
+ 7.738ns 0.0190329mA
+ 7.74ns 0.0184132mA
+ 7.742ns 0.0178139mA
+ 7.744ns 0.017234mA
+ 7.746ns 0.0166729mA
+ 7.748ns 0.0161302mA
+ 7.75ns 0.0156051mA
+ 7.752ns 0.0150971mA
+ 7.754ns 0mA
I179 339 0 PWL 0 0
+ 0.142ns 0mA
+ 0.144ns 0.00736636mA
+ 0.146ns 0.0203449mA
+ 0.148ns 0.0333233mA
+ 0.15ns 0.0463019mA
+ 0.152ns 0.0592804mA
+ 0.154ns 0.0722589mA
+ 0.156ns 0.0852374mA
+ 0.158ns 0.0891877mA
+ 0.16ns 0.0858516mA
+ 0.162ns 0.0826402mA
+ 0.164ns 0.0795489mA
+ 0.166ns 0.0765731mA
+ 0.168ns 0.0737087mA
+ 0.17ns 0.0709514mA
+ 0.172ns 0.0682973mA
+ 0.174ns 0.0657424mA
+ 0.176ns 0.063283mA
+ 0.178ns 0.0609156mA
+ 0.18ns 0.0586368mA
+ 0.182ns 0.0564432mA
+ 0.184ns 0.0543316mA
+ 0.186ns 0.0522991mA
+ 0.188ns 0.0503425mA
+ 0.19ns 0.0484591mA
+ 0.192ns 0.0466462mA
+ 0.194ns 0.0449011mA
+ 0.196ns 0.0432212mA
+ 0.198ns 0.0416042mA
+ 0.2ns 0.0400477mA
+ 0.202ns 0mA
+ 7.642ns 0mA
+ 7.644ns 0.00736704mA
+ 7.646ns 0.0203446mA
+ 7.648ns 0.0333253mA
+ 7.65ns 0.0463028mA
+ 7.652ns 0.0592804mA
+ 7.654ns 0.0722611mA
+ 7.656ns 0.0852386mA
+ 7.658ns 0.0891877mA
+ 7.66ns 0.0858517mA
+ 7.662ns 0.0826398mA
+ 7.664ns 0.0795487mA
+ 7.666ns 0.0765732mA
+ 7.668ns 0.0737083mA
+ 7.67ns 0.0709513mA
+ 7.672ns 0.0682973mA
+ 7.674ns 0.065742mA
+ 7.676ns 0.0632828mA
+ 7.678ns 0.0609156mA
+ 7.68ns 0.0586364mA
+ 7.682ns 0.056443mA
+ 7.684ns 0.0543316mA
+ 7.686ns 0.0522991mA
+ 7.688ns 0.0503423mA
+ 7.69ns 0.048459mA
+ 7.692ns 0.0466462mA
+ 7.694ns 0.0449008mA
+ 7.696ns 0.0432211mA
+ 7.698ns 0.0416042mA
+ 7.7ns 0.0400474mA
+ 7.702ns 0mA
I180 340 0 PWL 0 0
+ 2.632ns 0mA
+ 2.634ns 0.00310649mA
+ 2.636ns 0.0169619mA
+ 2.638ns 0.0308189mA
+ 2.64ns 0.0446759mA
+ 2.642ns 0.0585313mA
+ 2.644ns 0.0706335mA
+ 2.646ns 0.0670476mA
+ 2.648ns 0.0636441mA
+ 2.65ns 0.060413mA
+ 2.652ns 0.0573462mA
+ 2.654ns 0.0544347mA
+ 2.656ns 0.051671mA
+ 2.658ns 0.0490479mA
+ 2.66ns 0.0465577mA
+ 2.662ns 0.0441941mA
+ 2.664ns 0.0419502mA
+ 2.666ns 0.0398203mA
+ 2.668ns 0.0377987mA
+ 2.67ns 0.0358794mA
+ 2.672ns 0.0340578mA
+ 2.674ns 0.0323285mA
+ 2.676ns 0mA
+ 7.632ns 0mA
+ 7.634ns 0.00310979mA
+ 7.636ns 0.0169652mA
+ 7.638ns 0.0308206mA
+ 7.64ns 0.0446759mA
+ 7.642ns 0.0585346mA
+ 7.644ns 0.070633mA
+ 7.646ns 0.0670476mA
+ 7.648ns 0.0636433mA
+ 7.65ns 0.0604126mA
+ 7.652ns 0.0573458mA
+ 7.654ns 0.0544341mA
+ 7.656ns 0.0516707mA
+ 7.658ns 0.0490476mA
+ 7.66ns 0.0465577mA
+ 7.662ns 0.0441936mA
+ 7.664ns 0.04195mA
+ 7.666ns 0.0398203mA
+ 7.668ns 0.0377982mA
+ 7.67ns 0.0358792mA
+ 7.672ns 0.0340576mA
+ 7.674ns 0.0323281mA
+ 7.676ns 0mA
I181 342 0 PWL 0 0
+ 5.476ns 0mA
+ 5.478ns 0.00231458mA
+ 5.48ns 0.00743835mA
+ 5.482ns 0.0125621mA
+ 5.484ns 0.0176871mA
+ 5.486ns 0.0228109mA
+ 5.488ns 0.0279346mA
+ 5.49ns 0.0330596mA
+ 5.492ns 0.0381834mA
+ 5.494ns 0.0433071mA
+ 5.496ns 0.0484321mA
+ 5.498ns 0.0535559mA
+ 5.5ns 0.0586796mA
+ 5.502ns 0.0638034mA
+ 5.504ns 0.0689284mA
+ 5.506ns 0.0740521mA
+ 5.508ns 0.0791759mA
+ 5.51ns 0.0843009mA
+ 5.512ns 0.0894246mA
+ 5.514ns 0.0945484mA
+ 5.516ns 0.0970677mA
+ 5.518ns 0.0935945mA
+ 5.52ns 0.0902455mA
+ 5.522ns 0.0870163mA
+ 5.524ns 0.0839019mA
+ 5.526ns 0.0808996mA
+ 5.528ns 0.0780047mA
+ 5.53ns 0.0752128mA
+ 5.532ns 0.0725214mA
+ 5.534ns 0.0699263mA
+ 5.536ns 0.0674234mA
+ 5.538ns 0.0650107mA
+ 5.54ns 0.0626843mA
+ 5.542ns 0.0604405mA
+ 5.544ns 0.0582776mA
+ 5.546ns 0.0561921mA
+ 5.548ns 0.0541812mA
+ 5.55ns 0.0522418mA
+ 5.552ns 0.0503722mA
+ 5.554ns 0.0485695mA
+ 5.556ns 0.0468309mA
+ 5.558ns 0.0451549mA
+ 5.56ns 0.0435389mA
+ 5.562ns 0.0419803mA
+ 5.564ns 0.0404779mA
+ 5.566ns 0.0390292mA
+ 5.568ns 0.0376324mA
+ 5.57ns 0.0362852mA
+ 5.572ns 0.0349866mA
+ 5.574ns 0mA
I182 344 0 PWL 0 0
+ 7.65ns 0mA
+ 7.652ns 0.00102215mA
+ 7.654ns 0.0110583mA
+ 7.656ns 0.0210921mA
+ 7.658ns 0.0311259mA
+ 7.66ns 0.0411596mA
+ 7.662ns 0.0511958mA
+ 7.664ns 0.0612296mA
+ 7.666ns 0.0712634mA
+ 7.668ns 0.0812995mA
+ 7.67ns 0.0913333mA
+ 7.672ns 0.101367mA
+ 7.674ns 0.111403mA
+ 7.676ns 0.117858mA
+ 7.678ns 0.104952mA
+ 7.68ns 0.0934554mA
+ 7.682ns 0.0832204mA
+ 7.684ns 0.0741061mA
+ 7.686ns 0.0659898mA
+ 7.688ns 0.0587606mA
+ 7.69ns 0.0523246mA
+ 7.692ns 0.0465934mA
+ 7.694ns 0.0414887mA
+ 7.696ns 0.0369441mA
+ 7.698ns 0.0328972mA
+ 7.7ns 0mA
I183 350 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.000574673mA
+ 2.654ns 0.0105329mA
+ 2.656ns 0.0204911mA
+ 2.658ns 0.0304481mA
+ 2.66ns 0.0404063mA
+ 2.662ns 0.0503633mA
+ 2.664ns 0.0603215mA
+ 2.666ns 0.0702796mA
+ 2.668ns 0.0802367mA
+ 2.67ns 0.0901948mA
+ 2.672ns 0.100152mA
+ 2.674ns 0.11011mA
+ 2.676ns 0.120068mA
+ 2.678ns 0.1115mA
+ 2.68ns 0.0995759mA
+ 2.682ns 0.0889278mA
+ 2.684ns 0.0794171mA
+ 2.686ns 0.0709233mA
+ 2.688ns 0.0633386mA
+ 2.69ns 0.0565641mA
+ 2.692ns 0.050514mA
+ 2.694ns 0.0451115mA
+ 2.696ns 0.0402861mA
+ 2.698ns 0.0359773mA
+ 2.7ns 0.0321288mA
+ 2.702ns 0mA
+ 7.65ns 0mA
+ 7.652ns 0.00057586mA
+ 7.654ns 0.0105352mA
+ 7.656ns 0.0204922mA
+ 7.658ns 0.0304492mA
+ 7.66ns 0.0404063mA
+ 7.662ns 0.0503656mA
+ 7.664ns 0.0603226mA
+ 7.666ns 0.0702796mA
+ 7.668ns 0.080239mA
+ 7.67ns 0.090196mA
+ 7.672ns 0.100153mA
+ 7.674ns 0.110112mA
+ 7.676ns 0.120069mA
+ 7.678ns 0.111499mA
+ 7.68ns 0.0995732mA
+ 7.682ns 0.0889254mA
+ 7.684ns 0.079416mA
+ 7.686ns 0.0709233mA
+ 7.688ns 0.0633369mA
+ 7.69ns 0.0565633mA
+ 7.692ns 0.050514mA
+ 7.694ns 0.0451103mA
+ 7.696ns 0.0402856mA
+ 7.698ns 0.0359768mA
+ 7.7ns 0.0321279mA
+ 7.702ns 0mA
I184 352 0 PWL 0 0
+ 0.238ns 0mA
+ 0.24ns 0.0028126mA
+ 0.242ns 0.00764685mA
+ 0.244ns 0.0124811mA
+ 0.246ns 0.0173153mA
+ 0.248ns 0.0221495mA
+ 0.25ns 0.0269838mA
+ 0.252ns 0.031818mA
+ 0.254ns 0.0366522mA
+ 0.256ns 0.0414865mA
+ 0.258ns 0.0463207mA
+ 0.26ns 0.051155mA
+ 0.262ns 0.0559892mA
+ 0.264ns 0.0608234mA
+ 0.266ns 0.0650816mA
+ 0.268ns 0.0587442mA
+ 0.27ns 0.0530239mA
+ 0.272ns 0.0478604mA
+ 0.274ns 0.0431996mA
+ 0.276ns 0.0389926mA
+ 0.278ns 0.0351952mA
+ 0.28ns 0.0317676mA
+ 0.282ns 0.0286737mA
+ 0.284ns 0.0258811mA
+ 0.286ns 0.0233604mA
+ 0.288ns 0.0210851mA
+ 0.29ns 0.0190314mA
+ 0.292ns 0.0171777mA
+ 0.294ns 0mA
+ 7.738ns 0mA
+ 7.74ns 0.00281397mA
+ 7.742ns 0.00764786mA
+ 7.744ns 0.0124817mA
+ 7.746ns 0.0173168mA
+ 7.748ns 0.0221507mA
+ 7.75ns 0.0269845mA
+ 7.752ns 0.0318184mA
+ 7.754ns 0.0366535mA
+ 7.756ns 0.0414874mA
+ 7.758ns 0.0463212mA
+ 7.76ns 0.0511563mA
+ 7.762ns 0.0559902mA
+ 7.764ns 0.060824mA
+ 7.766ns 0.0650796mA
+ 7.768ns 0.0587429mA
+ 7.77ns 0.053023mA
+ 7.772ns 0.0478588mA
+ 7.774ns 0.0431986mA
+ 7.776ns 0.038992mA
+ 7.778ns 0.0351949mA
+ 7.78ns 0.0317668mA
+ 7.782ns 0.0286732mA
+ 7.784ns 0.0258808mA
+ 7.786ns 0.0233597mA
+ 7.788ns 0.0210846mA
+ 7.79ns 0.0190311mA
+ 7.792ns 0.0171771mA
+ 7.794ns 0mA
I185 353 0 PWL 0 0
+ 8.082ns 0mA
+ 8.084ns 0.00338813mA
+ 8.086ns 0.0384638mA
+ 8.088ns 0.0635115mA
+ 8.09ns 0.0588128mA
+ 8.092ns 0.0544616mA
+ 8.094ns 0.0504323mA
+ 8.096ns 0.046701mA
+ 8.098ns 0.0432457mA
+ 8.1ns 0.0400445mA
+ 8.102ns 0.0370816mA
+ 8.104ns 0.0343379mA
+ 8.106ns 0.0317971mA
+ 8.108ns 0mA
I186 354 0 PWL 0 0
+ 0.136ns 0mA
+ 0.138ns 0.00259907mA
+ 0.14ns 0.00703976mA
+ 0.142ns 0.0114805mA
+ 0.144ns 0.0159212mA
+ 0.146ns 0.0203619mA
+ 0.148ns 0.0248026mA
+ 0.15ns 0.0292433mA
+ 0.152ns 0.033684mA
+ 0.154ns 0.0381247mA
+ 0.156ns 0.0425654mA
+ 0.158ns 0.0470061mA
+ 0.16ns 0.0514468mA
+ 0.162ns 0.0558875mA
+ 0.164ns 0.0603282mA
+ 0.166ns 0.064769mA
+ 0.168ns 0.0692097mA
+ 0.17ns 0.0736504mA
+ 0.172ns 0.0780911mA
+ 0.174ns 0.0825318mA
+ 0.176ns 0.0869725mA
+ 0.178ns 0.0914132mA
+ 0.18ns 0.0958539mA
+ 0.182ns 0.100295mA
+ 0.184ns 0.104735mA
+ 0.186ns 0.109176mA
+ 0.188ns 0.113617mA
+ 0.19ns 0.111028mA
+ 0.192ns 0.107753mA
+ 0.194ns 0.104575mA
+ 0.196ns 0.10149mA
+ 0.198ns 0.0984964mA
+ 0.2ns 0.095591mA
+ 0.202ns 0.0927712mA
+ 0.204ns 0.0900346mA
+ 0.206ns 0.0873787mA
+ 0.208ns 0.0848012mA
+ 0.21ns 0.0822996mA
+ 0.212ns 0.0798719mA
+ 0.214ns 0.0775157mA
+ 0.216ns 0.075229mA
+ 0.218ns 0.0730098mA
+ 0.22ns 0.070856mA
+ 0.222ns 0.0687657mA
+ 0.224ns 0.0667371mA
+ 0.226ns 0.0647683mA
+ 0.228ns 0.0628576mA
+ 0.23ns 0.0610032mA
+ 0.232ns 0.0592036mA
+ 0.234ns 0.057457mA
+ 0.236ns 0.0557619mA
+ 0.238ns 0.0541168mA
+ 0.24ns 0.0525202mA
+ 0.242ns 0.0509708mA
+ 0.244ns 0.049467mA
+ 0.246ns 0.0480076mA
+ 0.248ns 0.0465912mA
+ 0.25ns 0.0452166mA
+ 0.252ns 0.0438826mA
+ 0.254ns 0.0425879mA
+ 0.256ns 0.0413314mA
+ 0.258ns 0.0401119mA
+ 0.26ns 0.0389285mA
+ 0.262ns 0mA
+ 5.136ns 0mA
+ 5.138ns 0.00259907mA
+ 5.14ns 0.00703946mA
+ 5.142ns 0.0114809mA
+ 5.144ns 0.0159213mA
+ 5.146ns 0.0203617mA
+ 5.148ns 0.0248031mA
+ 5.15ns 0.0292435mA
+ 5.152ns 0.0336839mA
+ 5.154ns 0.0381253mA
+ 5.156ns 0.0425657mA
+ 5.158ns 0.0470061mA
+ 5.16ns 0.0514465mA
+ 5.162ns 0.0558879mA
+ 5.164ns 0.0603283mA
+ 5.166ns 0.0647687mA
+ 5.168ns 0.0692101mA
+ 5.17ns 0.0736505mA
+ 5.172ns 0.0780909mA
+ 5.174ns 0.0825324mA
+ 5.176ns 0.0869727mA
+ 5.178ns 0.0914131mA
+ 5.18ns 0.0958535mA
+ 5.182ns 0.100295mA
+ 5.184ns 0.104735mA
+ 5.186ns 0.109176mA
+ 5.188ns 0.113617mA
+ 5.19ns 0.111028mA
+ 5.192ns 0.107753mA
+ 5.194ns 0.104574mA
+ 5.196ns 0.10149mA
+ 5.198ns 0.0984965mA
+ 5.2ns 0.0955906mA
+ 5.202ns 0.0927711mA
+ 5.204ns 0.0900347mA
+ 5.206ns 0.087379mA
+ 5.208ns 0.084801mA
+ 5.21ns 0.0822996mA
+ 5.212ns 0.079872mA
+ 5.214ns 0.0775155mA
+ 5.216ns 0.0752289mA
+ 5.218ns 0.0730099mA
+ 5.22ns 0.0708557mA
+ 5.222ns 0.0687656mA
+ 5.224ns 0.0667371mA
+ 5.226ns 0.0647685mA
+ 5.228ns 0.0628575mA
+ 5.23ns 0.0610032mA
+ 5.232ns 0.0592037mA
+ 5.234ns 0.0574568mA
+ 5.236ns 0.0557619mA
+ 5.238ns 0.0541169mA
+ 5.24ns 0.0525201mA
+ 5.242ns 0.0509707mA
+ 5.244ns 0.049467mA
+ 5.246ns 0.0480074mA
+ 5.248ns 0.0465911mA
+ 5.25ns 0.0452166mA
+ 5.252ns 0.0438827mA
+ 5.254ns 0.0425878mA
+ 5.256ns 0.0413314mA
+ 5.258ns 0.040112mA
+ 5.26ns 0.0389284mA
+ 5.262ns 0mA
I187 356 0 PWL 0 0
+ 7.636ns 0mA
+ 7.638ns 0.00261567mA
+ 7.64ns 0.00707365mA
+ 7.642ns 0.0115327mA
+ 7.644ns 0.0159907mA
+ 7.646ns 0.0204486mA
+ 7.648ns 0.0249077mA
+ 7.65ns 0.0293657mA
+ 7.652ns 0.0338236mA
+ 7.654ns 0.0382827mA
+ 7.656ns 0.0427407mA
+ 7.658ns 0.0471986mA
+ 7.66ns 0.0516566mA
+ 7.662ns 0.0561157mA
+ 7.664ns 0.0605736mA
+ 7.666ns 0.0650316mA
+ 7.668ns 0.0694906mA
+ 7.67ns 0.0739486mA
+ 7.672ns 0.0784066mA
+ 7.674ns 0.0828656mA
+ 7.676ns 0.0873236mA
+ 7.678ns 0.0917816mA
+ 7.68ns 0.0962406mA
+ 7.682ns 0.100699mA
+ 7.684ns 0.105157mA
+ 7.686ns 0.109615mA
+ 7.688ns 0.111702mA
+ 7.69ns 0.108327mA
+ 7.692ns 0.105054mA
+ 7.694ns 0.10188mA
+ 7.696ns 0.0988014mA
+ 7.698ns 0.0958163mA
+ 7.7ns 0.0929207mA
+ 7.702ns 0.0901132mA
+ 7.704ns 0.0873905mA
+ 7.706ns 0.08475mA
+ 7.708ns 0.0821888mA
+ 7.71ns 0.0797055mA
+ 7.712ns 0.0772972mA
+ 7.714ns 0.0749611mA
+ 7.716ns 0.0726961mA
+ 7.718ns 0.0704995mA
+ 7.72ns 0.0683688mA
+ 7.722ns 0.066303mA
+ 7.724ns 0.0642996mA
+ 7.726ns 0.0623562mA
+ 7.728ns 0.060472mA
+ 7.73ns 0.0586447mA
+ 7.732ns 0.0568726mA
+ 7.734ns 0.0551537mA
+ 7.736ns 0.0534871mA
+ 7.738ns 0.0518708mA
+ 7.74ns 0.050303mA
+ 7.742ns 0.0487829mA
+ 7.744ns 0.0473088mA
+ 7.746ns 0.0458788mA
+ 7.748ns 0.0444924mA
+ 7.75ns 0.0431479mA
+ 7.752ns 0.041844mA
+ 7.754ns 0.0405792mA
+ 7.756ns 0.0393529mA
+ 7.758ns 0mA
I188 362 0 PWL 0 0
+ 0.138ns 0mA
+ 0.14ns 0.00252794mA
+ 0.142ns 0.0070497mA
+ 0.144ns 0.0115715mA
+ 0.146ns 0.0160932mA
+ 0.148ns 0.020615mA
+ 0.15ns 0.0251367mA
+ 0.152ns 0.0296585mA
+ 0.154ns 0.0341802mA
+ 0.156ns 0.038702mA
+ 0.158ns 0.0432237mA
+ 0.16ns 0.0477455mA
+ 0.162ns 0.0522672mA
+ 0.164ns 0.056789mA
+ 0.166ns 0.0613108mA
+ 0.168ns 0.0658325mA
+ 0.17ns 0.0703542mA
+ 0.172ns 0.074876mA
+ 0.174ns 0.0793978mA
+ 0.176ns 0.0839195mA
+ 0.178ns 0.0884413mA
+ 0.18ns 0.092963mA
+ 0.182ns 0.0974848mA
+ 0.184ns 0.102007mA
+ 0.186ns 0.106528mA
+ 0.188ns 0.11105mA
+ 0.19ns 0.110416mA
+ 0.192ns 0.10709mA
+ 0.194ns 0.103865mA
+ 0.196ns 0.100737mA
+ 0.198ns 0.097703mA
+ 0.2ns 0.0947604mA
+ 0.202ns 0.0919064mA
+ 0.204ns 0.0891383mA
+ 0.206ns 0.0864535mA
+ 0.208ns 0.0838497mA
+ 0.21ns 0.0813242mA
+ 0.212ns 0.0788747mA
+ 0.214ns 0.0764991mA
+ 0.216ns 0.0741949mA
+ 0.218ns 0.0719602mA
+ 0.22ns 0.0697927mA
+ 0.222ns 0.0676905mA
+ 0.224ns 0.0656516mA
+ 0.226ns 0.0636741mA
+ 0.228ns 0.0617562mA
+ 0.23ns 0.059896mA
+ 0.232ns 0.0580918mA
+ 0.234ns 0.056342mA
+ 0.236ns 0.0546449mA
+ 0.238ns 0.0529988mA
+ 0.24ns 0.0514024mA
+ 0.242ns 0.049854mA
+ 0.244ns 0.0483522mA
+ 0.246ns 0.0468957mA
+ 0.248ns 0.0454831mA
+ 0.25ns 0.0441129mA
+ 0.252ns 0.0427841mA
+ 0.254ns 0.0414953mA
+ 0.256ns 0.0402452mA
+ 0.258ns 0.0390329mA
+ 0.26ns 0mA
I189 363 0 PWL 0 0
+ 0.468ns 0mA
+ 0.47ns 0.0022342mA
+ 0.472ns 0.00675585mA
+ 0.474ns 0.0112775mA
+ 0.476ns 0.0157991mA
+ 0.478ns 0.0203207mA
+ 0.48ns 0.0248424mA
+ 0.482ns 0.029364mA
+ 0.484ns 0.0338857mA
+ 0.486ns 0.0384073mA
+ 0.488ns 0.0429289mA
+ 0.49ns 0.0474505mA
+ 0.492ns 0.0519722mA
+ 0.494ns 0.0564938mA
+ 0.496ns 0.0572788mA
+ 0.498ns 0.0515452mA
+ 0.5ns 0.0463855mA
+ 0.502ns 0.041742mA
+ 0.504ns 0.0375634mA
+ 0.506ns 0.0338029mA
+ 0.508ns 0.0304189mA
+ 0.51ns 0.0273734mA
+ 0.512ns 0.0246329mA
+ 0.514ns 0.0221667mA
+ 0.516ns 0.0199473mA
+ 0.518ns 0.0179501mA
+ 0.52ns 0.0161528mA
+ 0.522ns 0mA
+ 5.95ns 0mA
+ 5.952ns 0.00178237mA
+ 5.954ns 0.00630367mA
+ 5.956ns 0.0108261mA
+ 5.958ns 0.0153474mA
+ 5.96ns 0.0198687mA
+ 5.962ns 0.02439mA
+ 5.964ns 0.0289124mA
+ 5.966ns 0.0334337mA
+ 5.968ns 0.037955mA
+ 5.97ns 0.0424774mA
+ 5.972ns 0.0469987mA
+ 5.974ns 0.05152mA
+ 5.976ns 0.0560424mA
+ 5.978ns 0.0578856mA
+ 5.98ns 0.0520917mA
+ 5.982ns 0.0468776mA
+ 5.984ns 0.0421842mA
+ 5.986ns 0.0379615mA
+ 5.988ns 0.0341615mA
+ 5.99ns 0.030741mA
+ 5.992ns 0.0276636mA
+ 5.994ns 0.0248942mA
+ 5.996ns 0.0224014mA
+ 5.998ns 0.0201587mA
+ 6ns 0.0181405mA
+ 6.002ns 0.0163243mA
+ 6.004ns 0mA
I190 367 0 PWL 0 0
+ 0.136ns 0mA
+ 0.138ns 0.000643245mA
+ 0.14ns 0.00535145mA
+ 0.142ns 0.0100597mA
+ 0.144ns 0.0147679mA
+ 0.146ns 0.0194762mA
+ 0.148ns 0.0241844mA
+ 0.15ns 0.0288926mA
+ 0.152ns 0.0336009mA
+ 0.154ns 0.0383091mA
+ 0.156ns 0.0430173mA
+ 0.158ns 0.0477256mA
+ 0.16ns 0.0524338mA
+ 0.162ns 0.057142mA
+ 0.164ns 0.0618502mA
+ 0.166ns 0.0665585mA
+ 0.168ns 0.0712667mA
+ 0.17ns 0.0759749mA
+ 0.172ns 0.0806832mA
+ 0.174ns 0.0853914mA
+ 0.176ns 0.0900997mA
+ 0.178ns 0.0948079mA
+ 0.18ns 0.0995161mA
+ 0.182ns 0.104224mA
+ 0.184ns 0.104691mA
+ 0.186ns 0.101017mA
+ 0.188ns 0.0974709mA
+ 0.19ns 0.0940495mA
+ 0.192ns 0.0907483mA
+ 0.194ns 0.0875629mA
+ 0.196ns 0.0844893mA
+ 0.198ns 0.0815236mA
+ 0.2ns 0.0786619mA
+ 0.202ns 0.0759007mA
+ 0.204ns 0.0732363mA
+ 0.206ns 0.0706655mA
+ 0.208ns 0.0681849mA
+ 0.21ns 0.0657914mA
+ 0.212ns 0.0634818mA
+ 0.214ns 0.0612533mA
+ 0.216ns 0.0591031mA
+ 0.218ns 0.0570282mA
+ 0.22ns 0.0550262mA
+ 0.222ns 0.0530945mA
+ 0.224ns 0.0512306mA
+ 0.226ns 0.0494321mA
+ 0.228ns 0.0476967mA
+ 0.23ns 0.0460222mA
+ 0.232ns 0.0444065mA
+ 0.234ns 0.0428475mA
+ 0.236ns 0.0413432mA
+ 0.238ns 0.0398918mA
+ 0.24ns 0.0384912mA
+ 0.242ns 0.0371399mA
+ 0.244ns 0.0358359mA
+ 0.246ns 0mA
+ 7.636ns 0mA
+ 7.638ns 0.000644157mA
+ 7.64ns 0.00535205mA
+ 7.642ns 0.0100611mA
+ 7.644ns 0.014769mA
+ 7.646ns 0.0194768mA
+ 7.648ns 0.0241859mA
+ 7.65ns 0.0288937mA
+ 7.652ns 0.0336016mA
+ 7.654ns 0.0383107mA
+ 7.656ns 0.0430185mA
+ 7.658ns 0.0477264mA
+ 7.66ns 0.0524343mA
+ 7.662ns 0.0571433mA
+ 7.664ns 0.0618512mA
+ 7.666ns 0.0665591mA
+ 7.668ns 0.0712681mA
+ 7.67ns 0.075976mA
+ 7.672ns 0.0806839mA
+ 7.674ns 0.0853929mA
+ 7.676ns 0.0901008mA
+ 7.678ns 0.0948087mA
+ 7.68ns 0.0995177mA
+ 7.682ns 0.104226mA
+ 7.684ns 0.104691mA
+ 7.686ns 0.101016mA
+ 7.688ns 0.0974698mA
+ 7.69ns 0.0940488mA
+ 7.692ns 0.0907478mA
+ 7.694ns 0.087562mA
+ 7.696ns 0.0844886mA
+ 7.698ns 0.0815231mA
+ 7.7ns 0.078661mA
+ 7.702ns 0.0759mA
+ 7.704ns 0.0732359mA
+ 7.706ns 0.0706652mA
+ 7.708ns 0.0681842mA
+ 7.71ns 0.0657909mA
+ 7.712ns 0.0634815mA
+ 7.714ns 0.0612527mA
+ 7.716ns 0.0591026mA
+ 7.718ns 0.0570279mA
+ 7.72ns 0.0550256mA
+ 7.722ns 0.053094mA
+ 7.724ns 0.0512303mA
+ 7.726ns 0.0494315mA
+ 7.728ns 0.0476962mA
+ 7.73ns 0.0460219mA
+ 7.732ns 0.0444063mA
+ 7.734ns 0.0428471mA
+ 7.736ns 0.0413429mA
+ 7.738ns 0.0398915mA
+ 7.74ns 0.0384908mA
+ 7.742ns 0.0371395mA
+ 7.744ns 0.0358357mA
+ 7.746ns 0mA
I191 370 0 PWL 0 0
+ 2.64ns 0mA
+ 2.642ns 0.00243835mA
+ 2.644ns 0.00703732mA
+ 2.646ns 0.0116363mA
+ 2.648ns 0.0162347mA
+ 2.65ns 0.0208337mA
+ 2.652ns 0.0254321mA
+ 2.654ns 0.0300311mA
+ 2.656ns 0.03463mA
+ 2.658ns 0.0392285mA
+ 2.66ns 0.0438274mA
+ 2.662ns 0.0484258mA
+ 2.664ns 0.0530248mA
+ 2.666ns 0.0576238mA
+ 2.668ns 0.0622222mA
+ 2.67ns 0.0668212mA
+ 2.672ns 0.0714196mA
+ 2.674ns 0.0760186mA
+ 2.676ns 0.0806175mA
+ 2.678ns 0.085216mA
+ 2.68ns 0.0898149mA
+ 2.682ns 0.0944133mA
+ 2.684ns 0.0990123mA
+ 2.686ns 0.103611mA
+ 2.688ns 0.10821mA
+ 2.69ns 0.112809mA
+ 2.692ns 0.117408mA
+ 2.694ns 0.114917mA
+ 2.696ns 0.111727mA
+ 2.698ns 0.108625mA
+ 2.7ns 0.105608mA
+ 2.702ns 0.102676mA
+ 2.704ns 0.0998251mA
+ 2.706ns 0.0970532mA
+ 2.708ns 0.0943585mA
+ 2.71ns 0.0917384mA
+ 2.712ns 0.0891909mA
+ 2.714ns 0.0867145mA
+ 2.716ns 0.0843065mA
+ 2.718ns 0.0819657mA
+ 2.72ns 0.0796896mA
+ 2.722ns 0.0774766mA
+ 2.724ns 0.0753254mA
+ 2.726ns 0.0732336mA
+ 2.728ns 0.0712002mA
+ 2.73ns 0.0692229mA
+ 2.732ns 0.0673006mA
+ 2.734ns 0.0654318mA
+ 2.736ns 0.0636147mA
+ 2.738ns 0.0618483mA
+ 2.74ns 0.0601307mA
+ 2.742ns 0.0584608mA
+ 2.744ns 0.0568375mA
+ 2.746ns 0.055259mA
+ 2.748ns 0.0537243mA
+ 2.75ns 0.0522325mA
+ 2.752ns 0.0507819mA
+ 2.754ns 0.0493717mA
+ 2.756ns 0.0480005mA
+ 2.758ns 0.0466674mA
+ 2.76ns 0.0453715mA
+ 2.762ns 0.0441114mA
+ 2.764ns 0.0428864mA
+ 2.766ns 0.0416953mA
+ 2.768ns 0mA
I192 372 0 PWL 0 0
+ 2.718ns 0mA
+ 2.72ns 0.00344891mA
+ 2.722ns 0.00816504mA
+ 2.724ns 0.0128806mA
+ 2.726ns 0.0175967mA
+ 2.728ns 0.0223123mA
+ 2.73ns 0.0270284mA
+ 2.732ns 0.0317446mA
+ 2.734ns 0.0364601mA
+ 2.736ns 0.0411762mA
+ 2.738ns 0.0387805mA
+ 2.74ns 0.0332897mA
+ 2.742ns 0.0285762mA
+ 2.744ns 0.0245304mA
+ 2.746ns 0.0210569mA
+ 2.748ns 0.0180751mA
+ 2.75ns 0.0155158mA
+ 2.752ns 0.0133185mA
+ 2.754ns 0.0114325mA
+ 2.756ns 0mA
I193 374 0 PWL 0 0
+ 7.998ns 0mA
+ 8ns 0.0103203mA
+ 8.002ns 0.0149947mA
+ 8.004ns 0.0196691mA
+ 8.006ns 0.0243435mA
+ 8.008ns 0.0290202mA
+ 8.01ns 0.0336946mA
+ 8.012ns 0.038369mA
+ 8.014ns 0.0392mA
+ 8.016ns 0.0335211mA
+ 8.018ns 0.0286647mA
+ 8.02ns 0.0245099mA
+ 8.022ns 0.0209588mA
+ 8.024ns 0.0179221mA
+ 8.026ns 0.0153252mA
+ 8.028ns 0.0131046mA
+ 8.03ns 0.0112057mA
+ 8.032ns 0mA
I194 376 0 PWL 0 0
+ 3.044ns 0mA
+ 3.046ns 0.000125677mA
+ 3.048ns 0.00902865mA
+ 3.05ns 0.0179306mA
+ 3.052ns 0.0268335mA
+ 3.054ns 0.0357365mA
+ 3.056ns 0.0446384mA
+ 3.058ns 0.0535414mA
+ 3.06ns 0.0624433mA
+ 3.062ns 0.0713463mA
+ 3.064ns 0.0609726mA
+ 3.066ns 0.0513424mA
+ 3.068ns 0.043232mA
+ 3.07ns 0.0364033mA
+ 3.072ns 0.0306523mA
+ 3.074ns 0.0258097mA
+ 3.076ns 0.0217325mA
+ 3.078ns 0.0182988mA
+ 3.08ns 0mA
I195 378 0 PWL 0 0
+ 0.212ns 0mA
+ 0.214ns 0.00222013mA
+ 0.216ns 0.00694816mA
+ 0.218ns 0.0116762mA
+ 0.22ns 0.0164043mA
+ 0.222ns 0.0211324mA
+ 0.224ns 0.0258604mA
+ 0.226ns 0.0305885mA
+ 0.228ns 0.0353165mA
+ 0.23ns 0.0400446mA
+ 0.232ns 0.0403381mA
+ 0.234ns 0.0346202mA
+ 0.236ns 0.0297127mA
+ 0.238ns 0.0255008mA
+ 0.24ns 0.0218857mA
+ 0.242ns 0.0187831mA
+ 0.244ns 0.0161201mA
+ 0.246ns 0.0138347mA
+ 0.248ns 0.0118732mA
+ 0.25ns 0mA
I196 379 0 PWL 0 0
+ 3.196ns 0mA
+ 3.198ns 0.00230079mA
+ 3.2ns 0.00468679mA
+ 3.202ns 0.00707278mA
+ 3.204ns 0.00945849mA
+ 3.206ns 0.0118445mA
+ 3.208ns 0.0142302mA
+ 3.21ns 0.0166162mA
+ 3.212ns 0.0190022mA
+ 3.214ns 0.0213879mA
+ 3.216ns 0.0237739mA
+ 3.218ns 0.0261599mA
+ 3.22ns 0.0285456mA
+ 3.222ns 0.0309316mA
+ 3.224ns 0.0333173mA
+ 3.226ns 0.0357033mA
+ 3.228ns 0.0373332mA
+ 3.23ns 0.0367027mA
+ 3.232ns 0.0360827mA
+ 3.234ns 0.0354733mA
+ 3.236ns 0.0348741mA
+ 3.238ns 0.034285mA
+ 3.24ns 0.033706mA
+ 3.242ns 0.0331367mA
+ 3.244ns 0.032577mA
+ 3.246ns 0.0320267mA
+ 3.248ns 0.0314857mA
+ 3.25ns 0.030954mA
+ 3.252ns 0.0304311mA
+ 3.254ns 0.0299171mA
+ 3.256ns 0.0294118mA
+ 3.258ns 0.0289149mA
+ 3.26ns 0.0284266mA
+ 3.262ns 0.0279464mA
+ 3.264ns 0.0274743mA
+ 3.266ns 0.0270103mA
+ 3.268ns 0.026554mA
+ 3.27ns 0.0261055mA
+ 3.272ns 0.0256645mA
+ 3.274ns 0.025231mA
+ 3.276ns 0.0248048mA
+ 3.278ns 0.0243858mA
+ 3.28ns 0.0239739mA
+ 3.282ns 0.0235689mA
+ 3.284ns 0.0231708mA
+ 3.286ns 0.0227794mA
+ 3.288ns 0.0223946mA
+ 3.29ns 0.0220163mA
+ 3.292ns 0.0216444mA
+ 3.294ns 0.0212787mA
+ 3.296ns 0.0209193mA
+ 3.298ns 0.0205659mA
+ 3.3ns 0.0202185mA
+ 3.302ns 0.019877mA
+ 3.304ns 0.0195412mA
+ 3.306ns 0.0192111mA
+ 3.308ns 0.0188865mA
+ 3.31ns 0.0185675mA
+ 3.312ns 0.0182538mA
+ 3.314ns 0.0179455mA
+ 3.316ns 0.0176423mA
+ 3.318ns 0.0173443mA
+ 3.32ns 0.0170513mA
+ 3.322ns 0.0167632mA
+ 3.324ns 0.01648mA
+ 3.326ns 0mA
I197 380 0 PWL 0 0
+ 0.294ns 0mA
+ 0.296ns 0.00258221mA
+ 0.298ns 0.00859378mA
+ 0.3ns 0.0146054mA
+ 0.302ns 0.0206169mA
+ 0.304ns 0.0266285mA
+ 0.306ns 0.0326401mA
+ 0.308ns 0.0386517mA
+ 0.31ns 0.0446631mA
+ 0.312ns 0.0506747mA
+ 0.314ns 0.0566863mA
+ 0.316ns 0.0626979mA
+ 0.318ns 0.0687094mA
+ 0.32ns 0.074721mA
+ 0.322ns 0.0807326mA
+ 0.324ns 0.0867441mA
+ 0.326ns 0.0927556mA
+ 0.328ns 0.0987672mA
+ 0.33ns 0.104779mA
+ 0.332ns 0.11079mA
+ 0.334ns 0.116802mA
+ 0.336ns 0.122814mA
+ 0.338ns 0.128825mA
+ 0.34ns 0.134837mA
+ 0.342ns 0.140848mA
+ 0.344ns 0.14686mA
+ 0.346ns 0.152871mA
+ 0.348ns 0.158883mA
+ 0.35ns 0.164894mA
+ 0.352ns 0.170906mA
+ 0.354ns 0.176917mA
+ 0.356ns 0.182929mA
+ 0.358ns 0.188941mA
+ 0.36ns 0.194952mA
+ 0.362ns 0.200964mA
+ 0.364ns 0.206975mA
+ 0.366ns 0.212987mA
+ 0.368ns 0.218998mA
+ 0.37ns 0.22501mA
+ 0.372ns 0.231022mA
+ 0.374ns 0.237033mA
+ 0.376ns 0.243045mA
+ 0.378ns 0.249056mA
+ 0.38ns 0.255068mA
+ 0.382ns 0.261079mA
+ 0.384ns 0.267091mA
+ 0.386ns 0.273102mA
+ 0.388ns 0.279114mA
+ 0.39ns 0.285126mA
+ 0.392ns 0.291137mA
+ 0.394ns 0.297149mA
+ 0.396ns 0.30316mA
+ 0.398ns 0.309172mA
+ 0.4ns 0.315183mA
+ 0.402ns 0.321195mA
+ 0.404ns 0.327207mA
+ 0.406ns 0.333218mA
+ 0.408ns 0.33923mA
+ 0.41ns 0.345241mA
+ 0.412ns 0.351253mA
+ 0.414ns 0.357264mA
+ 0.416ns 0.363276mA
+ 0.418ns 0.369287mA
+ 0.42ns 0.375299mA
+ 0.422ns 0.381311mA
+ 0.424ns 0.387322mA
+ 0.426ns 0.393334mA
+ 0.428ns 0.399345mA
+ 0.43ns 0.405357mA
+ 0.432ns 0.411368mA
+ 0.434ns 0.41738mA
+ 0.436ns 0.423392mA
+ 0.438ns 0.429403mA
+ 0.44ns 0.435415mA
+ 0.442ns 0.441426mA
+ 0.444ns 0.447438mA
+ 0.446ns 0.453449mA
+ 0.448ns 0.459461mA
+ 0.45ns 0.465472mA
+ 0.452ns 0.471484mA
+ 0.454ns 0.477496mA
+ 0.456ns 0.483507mA
+ 0.458ns 0.489519mA
+ 0.46ns 0.49553mA
+ 0.462ns 0.501542mA
+ 0.464ns 0.507553mA
+ 0.466ns 0.513565mA
+ 0.468ns 0.519577mA
+ 0.47ns 0.525588mA
+ 0.472ns 0.525011mA
+ 0.474ns 0.522796mA
+ 0.476ns 0.52059mA
+ 0.478ns 0.518394mA
+ 0.48ns 0.516206mA
+ 0.482ns 0.514028mA
+ 0.484ns 0.511859mA
+ 0.486ns 0.5097mA
+ 0.488ns 0.507549mA
+ 0.49ns 0.505408mA
+ 0.492ns 0.503275mA
+ 0.494ns 0.501152mA
+ 0.496ns 0.499037mA
+ 0.498ns 0.496931mA
+ 0.5ns 0.494835mA
+ 0.502ns 0.492747mA
+ 0.504ns 0.490668mA
+ 0.506ns 0.488597mA
+ 0.508ns 0.486536mA
+ 0.51ns 0.484483mA
+ 0.512ns 0.482439mA
+ 0.514ns 0.480403mA
+ 0.516ns 0.478376mA
+ 0.518ns 0.476358mA
+ 0.52ns 0.474348mA
+ 0.522ns 0.472346mA
+ 0.524ns 0.470353mA
+ 0.526ns 0.468368mA
+ 0.528ns 0.466392mA
+ 0.53ns 0.464424mA
+ 0.532ns 0.462465mA
+ 0.534ns 0.460513mA
+ 0.536ns 0.45857mA
+ 0.538ns 0.456635mA
+ 0.54ns 0.454708mA
+ 0.542ns 0.45279mA
+ 0.544ns 0.450879mA
+ 0.546ns 0.448977mA
+ 0.548ns 0.447082mA
+ 0.55ns 0.445196mA
+ 0.552ns 0.443317mA
+ 0.554ns 0.441447mA
+ 0.556ns 0.439584mA
+ 0.558ns 0.437729mA
+ 0.56ns 0.435882mA
+ 0.562ns 0.434043mA
+ 0.564ns 0.432212mA
+ 0.566ns 0.430388mA
+ 0.568ns 0.428572mA
+ 0.57ns 0.426763mA
+ 0.572ns 0.424963mA
+ 0.574ns 0.42317mA
+ 0.576ns 0.421384mA
+ 0.578ns 0.419606mA
+ 0.58ns 0.417835mA
+ 0.582ns 0.416072mA
+ 0.584ns 0.414317mA
+ 0.586ns 0.412568mA
+ 0.588ns 0.410827mA
+ 0.59ns 0.409094mA
+ 0.592ns 0.407368mA
+ 0.594ns 0.405649mA
+ 0.596ns 0.403937mA
+ 0.598ns 0.402233mA
+ 0.6ns 0.400535mA
+ 0.602ns 0.398845mA
+ 0.604ns 0.397162mA
+ 0.606ns 0.395486mA
+ 0.608ns 0.393818mA
+ 0.61ns 0.392156mA
+ 0.612ns 0.390501mA
+ 0.614ns 0.388853mA
+ 0.616ns 0.387212mA
+ 0.618ns 0.385579mA
+ 0.62ns 0.383952mA
+ 0.622ns 0.382331mA
+ 0.624ns 0.380718mA
+ 0.626ns 0.379112mA
+ 0.628ns 0.377512mA
+ 0.63ns 0.375919mA
+ 0.632ns 0.374333mA
+ 0.634ns 0.372753mA
+ 0.636ns 0.37118mA
+ 0.638ns 0.369614mA
+ 0.64ns 0.368054mA
+ 0.642ns 0.366501mA
+ 0.644ns 0.364955mA
+ 0.646ns 0.363415mA
+ 0.648ns 0.361881mA
+ 0.65ns 0.360354mA
+ 0.652ns 0.358834mA
+ 0.654ns 0.357319mA
+ 0.656ns 0.355812mA
+ 0.658ns 0.35431mA
+ 0.66ns 0.352815mA
+ 0.662ns 0.351326mA
+ 0.664ns 0.349844mA
+ 0.666ns 0.348368mA
+ 0.668ns 0.346897mA
+ 0.67ns 0.345434mA
+ 0.672ns 0.343976mA
+ 0.674ns 0.342524mA
+ 0.676ns 0.341079mA
+ 0.678ns 0.33964mA
+ 0.68ns 0.338207mA
+ 0.682ns 0.336779mA
+ 0.684ns 0.335358mA
+ 0.686ns 0.333943mA
+ 0.688ns 0.332534mA
+ 0.69ns 0.331131mA
+ 0.692ns 0.329733mA
+ 0.694ns 0.328342mA
+ 0.696ns 0.326957mA
+ 0.698ns 0.325577mA
+ 0.7ns 0.324203mA
+ 0.702ns 0.322835mA
+ 0.704ns 0.321473mA
+ 0.706ns 0.320116mA
+ 0.708ns 0.318765mA
+ 0.71ns 0.31742mA
+ 0.712ns 0.316081mA
+ 0.714ns 0.314747mA
+ 0.716ns 0.313419mA
+ 0.718ns 0.312096mA
+ 0.72ns 0.310779mA
+ 0.722ns 0.309467mA
+ 0.724ns 0.308162mA
+ 0.726ns 0.306861mA
+ 0.728ns 0.305566mA
+ 0.73ns 0.304277mA
+ 0.732ns 0.302993mA
+ 0.734ns 0.301714mA
+ 0.736ns 0.300441mA
+ 0.738ns 0.299173mA
+ 0.74ns 0.297911mA
+ 0.742ns 0.296654mA
+ 0.744ns 0.295402mA
+ 0.746ns 0.294155mA
+ 0.748ns 0.292914mA
+ 0.75ns 0.291678mA
+ 0.752ns 0.290447mA
+ 0.754ns 0.289221mA
+ 0.756ns 0.288001mA
+ 0.758ns 0.286785mA
+ 0.76ns 0.285575mA
+ 0.762ns 0.28437mA
+ 0.764ns 0.28317mA
+ 0.766ns 0.281975mA
+ 0.768ns 0.280785mA
+ 0.77ns 0.2796mA
+ 0.772ns 0.27842mA
+ 0.774ns 0.277245mA
+ 0.776ns 0.276075mA
+ 0.778ns 0.27491mA
+ 0.78ns 0.27375mA
+ 0.782ns 0.272595mA
+ 0.784ns 0.271445mA
+ 0.786ns 0.270299mA
+ 0.788ns 0.269158mA
+ 0.79ns 0.268023mA
+ 0.792ns 0.266891mA
+ 0.794ns 0.265765mA
+ 0.796ns 0.264644mA
+ 0.798ns 0.263527mA
+ 0.8ns 0.262415mA
+ 0.802ns 0.261307mA
+ 0.804ns 0.260205mA
+ 0.806ns 0.259107mA
+ 0.808ns 0.258013mA
+ 0.81ns 0.256924mA
+ 0.812ns 0.25584mA
+ 0.814ns 0.25476mA
+ 0.816ns 0.253685mA
+ 0.818ns 0.252615mA
+ 0.82ns 0.251549mA
+ 0.822ns 0.250487mA
+ 0.824ns 0.24943mA
+ 0.826ns 0.248377mA
+ 0.828ns 0.247329mA
+ 0.83ns 0.246285mA
+ 0.832ns 0.245246mA
+ 0.834ns 0.244211mA
+ 0.836ns 0.243181mA
+ 0.838ns 0.242154mA
+ 0.84ns 0.241132mA
+ 0.842ns 0.240115mA
+ 0.844ns 0.239101mA
+ 0.846ns 0.238092mA
+ 0.848ns 0.237088mA
+ 0.85ns 0.236087mA
+ 0.852ns 0.235091mA
+ 0.854ns 0.234099mA
+ 0.856ns 0.233111mA
+ 0.858ns 0.232127mA
+ 0.86ns 0.231147mA
+ 0.862ns 0.230172mA
+ 0.864ns 0.2292mA
+ 0.866ns 0.228233mA
+ 0.868ns 0.22727mA
+ 0.87ns 0.226311mA
+ 0.872ns 0.225356mA
+ 0.874ns 0.224405mA
+ 0.876ns 0.223458mA
+ 0.878ns 0.222515mA
+ 0.88ns 0.221576mA
+ 0.882ns 0.22064mA
+ 0.884ns 0.219709mA
+ 0.886ns 0mA
+ 5.294ns 0mA
+ 5.296ns 0.00258257mA
+ 5.298ns 0.0085937mA
+ 5.3ns 0.0146063mA
+ 5.302ns 0.0206174mA
+ 5.304ns 0.0266285mA
+ 5.306ns 0.0326411mA
+ 5.308ns 0.0386522mA
+ 5.31ns 0.0446633mA
+ 5.312ns 0.0506759mA
+ 5.314ns 0.056687mA
+ 5.316ns 0.0626981mA
+ 5.318ns 0.0687092mA
+ 5.32ns 0.0747218mA
+ 5.322ns 0.0807329mA
+ 5.324ns 0.0867441mA
+ 5.326ns 0.0927566mA
+ 5.328ns 0.0987677mA
+ 5.33ns 0.104779mA
+ 5.332ns 0.110791mA
+ 5.334ns 0.116803mA
+ 5.336ns 0.122814mA
+ 5.338ns 0.128826mA
+ 5.34ns 0.134837mA
+ 5.342ns 0.140848mA
+ 5.344ns 0.14686mA
+ 5.346ns 0.152872mA
+ 5.348ns 0.158883mA
+ 5.35ns 0.164894mA
+ 5.352ns 0.170907mA
+ 5.354ns 0.176918mA
+ 5.356ns 0.182929mA
+ 5.358ns 0.188942mA
+ 5.36ns 0.194953mA
+ 5.362ns 0.200964mA
+ 5.364ns 0.206975mA
+ 5.366ns 0.212988mA
+ 5.368ns 0.218999mA
+ 5.37ns 0.22501mA
+ 5.372ns 0.231023mA
+ 5.374ns 0.237034mA
+ 5.376ns 0.243045mA
+ 5.378ns 0.249057mA
+ 5.38ns 0.255068mA
+ 5.382ns 0.26108mA
+ 5.384ns 0.267092mA
+ 5.386ns 0.273103mA
+ 5.388ns 0.279114mA
+ 5.39ns 0.285126mA
+ 5.392ns 0.291138mA
+ 5.394ns 0.297149mA
+ 5.396ns 0.30316mA
+ 5.398ns 0.309173mA
+ 5.4ns 0.315184mA
+ 5.402ns 0.321195mA
+ 5.404ns 0.327208mA
+ 5.406ns 0.333219mA
+ 5.408ns 0.33923mA
+ 5.41ns 0.345241mA
+ 5.412ns 0.351254mA
+ 5.414ns 0.357265mA
+ 5.416ns 0.363276mA
+ 5.418ns 0.369288mA
+ 5.42ns 0.3753mA
+ 5.422ns 0.381311mA
+ 5.424ns 0.387323mA
+ 5.426ns 0.393334mA
+ 5.428ns 0.399346mA
+ 5.43ns 0.405358mA
+ 5.432ns 0.411369mA
+ 5.434ns 0.41738mA
+ 5.436ns 0.423391mA
+ 5.438ns 0.429404mA
+ 5.44ns 0.435415mA
+ 5.442ns 0.441426mA
+ 5.444ns 0.447439mA
+ 5.446ns 0.45345mA
+ 5.448ns 0.459461mA
+ 5.45ns 0.465474mA
+ 5.452ns 0.471485mA
+ 5.454ns 0.477496mA
+ 5.456ns 0.483507mA
+ 5.458ns 0.48952mA
+ 5.46ns 0.495531mA
+ 5.462ns 0.501542mA
+ 5.464ns 0.507554mA
+ 5.466ns 0.513565mA
+ 5.468ns 0.519577mA
+ 5.47ns 0.525589mA
+ 5.472ns 0.525011mA
+ 5.474ns 0.522796mA
+ 5.476ns 0.52059mA
+ 5.478ns 0.518393mA
+ 5.48ns 0.516206mA
+ 5.482ns 0.514028mA
+ 5.484ns 0.511859mA
+ 5.486ns 0.5097mA
+ 5.488ns 0.507549mA
+ 5.49ns 0.505407mA
+ 5.492ns 0.503275mA
+ 5.494ns 0.501152mA
+ 5.496ns 0.499037mA
+ 5.498ns 0.496931mA
+ 5.5ns 0.494835mA
+ 5.502ns 0.492747mA
+ 5.504ns 0.490667mA
+ 5.506ns 0.488597mA
+ 5.508ns 0.486536mA
+ 5.51ns 0.484483mA
+ 5.512ns 0.482438mA
+ 5.514ns 0.480403mA
+ 5.516ns 0.478376mA
+ 5.518ns 0.476357mA
+ 5.52ns 0.474347mA
+ 5.522ns 0.472346mA
+ 5.524ns 0.470353mA
+ 5.526ns 0.468368mA
+ 5.528ns 0.466392mA
+ 5.53ns 0.464424mA
+ 5.532ns 0.462464mA
+ 5.534ns 0.460513mA
+ 5.536ns 0.45857mA
+ 5.538ns 0.456635mA
+ 5.54ns 0.454708mA
+ 5.542ns 0.452789mA
+ 5.544ns 0.450879mA
+ 5.546ns 0.448977mA
+ 5.548ns 0.447082mA
+ 5.55ns 0.445196mA
+ 5.552ns 0.443317mA
+ 5.554ns 0.441447mA
+ 5.556ns 0.439584mA
+ 5.558ns 0.437729mA
+ 5.56ns 0.435882mA
+ 5.562ns 0.434043mA
+ 5.564ns 0.432211mA
+ 5.566ns 0.430388mA
+ 5.568ns 0.428572mA
+ 5.57ns 0.426763mA
+ 5.572ns 0.424963mA
+ 5.574ns 0.42317mA
+ 5.576ns 0.421384mA
+ 5.578ns 0.419606mA
+ 5.58ns 0.417835mA
+ 5.582ns 0.416072mA
+ 5.584ns 0.414316mA
+ 5.586ns 0.412568mA
+ 5.588ns 0.410827mA
+ 5.59ns 0.409094mA
+ 5.592ns 0.407368mA
+ 5.594ns 0.405649mA
+ 5.596ns 0.403937mA
+ 5.598ns 0.402233mA
+ 5.6ns 0.400535mA
+ 5.602ns 0.398845mA
+ 5.604ns 0.397162mA
+ 5.606ns 0.395486mA
+ 5.608ns 0.393817mA
+ 5.61ns 0.392156mA
+ 5.612ns 0.390501mA
+ 5.614ns 0.388853mA
+ 5.616ns 0.387212mA
+ 5.618ns 0.385579mA
+ 5.62ns 0.383952mA
+ 5.622ns 0.382331mA
+ 5.624ns 0.380718mA
+ 5.626ns 0.379112mA
+ 5.628ns 0.377512mA
+ 5.63ns 0.375919mA
+ 5.632ns 0.374333mA
+ 5.634ns 0.372753mA
+ 5.636ns 0.37118mA
+ 5.638ns 0.369614mA
+ 5.64ns 0.368054mA
+ 5.642ns 0.366501mA
+ 5.644ns 0.364955mA
+ 5.646ns 0.363415mA
+ 5.648ns 0.361881mA
+ 5.65ns 0.360354mA
+ 5.652ns 0.358834mA
+ 5.654ns 0.357319mA
+ 5.656ns 0.355811mA
+ 5.658ns 0.35431mA
+ 5.66ns 0.352815mA
+ 5.662ns 0.351326mA
+ 5.664ns 0.349844mA
+ 5.666ns 0.348368mA
+ 5.668ns 0.346897mA
+ 5.67ns 0.345434mA
+ 5.672ns 0.343976mA
+ 5.674ns 0.342524mA
+ 5.676ns 0.341079mA
+ 5.678ns 0.33964mA
+ 5.68ns 0.338206mA
+ 5.682ns 0.336779mA
+ 5.684ns 0.335358mA
+ 5.686ns 0.333943mA
+ 5.688ns 0.332534mA
+ 5.69ns 0.331131mA
+ 5.692ns 0.329733mA
+ 5.694ns 0.328342mA
+ 5.696ns 0.326956mA
+ 5.698ns 0.325577mA
+ 5.7ns 0.324203mA
+ 5.702ns 0.322835mA
+ 5.704ns 0.321472mA
+ 5.706ns 0.320116mA
+ 5.708ns 0.318765mA
+ 5.71ns 0.31742mA
+ 5.712ns 0.316081mA
+ 5.714ns 0.314747mA
+ 5.716ns 0.313418mA
+ 5.718ns 0.312096mA
+ 5.72ns 0.310779mA
+ 5.722ns 0.309467mA
+ 5.724ns 0.308162mA
+ 5.726ns 0.306861mA
+ 5.728ns 0.305566mA
+ 5.73ns 0.304277mA
+ 5.732ns 0.302993mA
+ 5.734ns 0.301714mA
+ 5.736ns 0.300441mA
+ 5.738ns 0.299173mA
+ 5.74ns 0.29791mA
+ 5.742ns 0.296653mA
+ 5.744ns 0.295402mA
+ 5.746ns 0.294155mA
+ 5.748ns 0.292914mA
+ 5.75ns 0.291678mA
+ 5.752ns 0.290447mA
+ 5.754ns 0.289221mA
+ 5.756ns 0.288001mA
+ 5.758ns 0.286785mA
+ 5.76ns 0.285575mA
+ 5.762ns 0.28437mA
+ 5.764ns 0.28317mA
+ 5.766ns 0.281975mA
+ 5.768ns 0.280785mA
+ 5.77ns 0.2796mA
+ 5.772ns 0.27842mA
+ 5.774ns 0.277245mA
+ 5.776ns 0.276075mA
+ 5.778ns 0.27491mA
+ 5.78ns 0.27375mA
+ 5.782ns 0.272595mA
+ 5.784ns 0.271445mA
+ 5.786ns 0.270299mA
+ 5.788ns 0.269158mA
+ 5.79ns 0.268023mA
+ 5.792ns 0.266891mA
+ 5.794ns 0.265765mA
+ 5.796ns 0.264644mA
+ 5.798ns 0.263527mA
+ 5.8ns 0.262415mA
+ 5.802ns 0.261307mA
+ 5.804ns 0.260205mA
+ 5.806ns 0.259106mA
+ 5.808ns 0.258013mA
+ 5.81ns 0.256924mA
+ 5.812ns 0.25584mA
+ 5.814ns 0.25476mA
+ 5.816ns 0.253685mA
+ 5.818ns 0.252614mA
+ 5.82ns 0.251548mA
+ 5.822ns 0.250487mA
+ 5.824ns 0.24943mA
+ 5.826ns 0.248377mA
+ 5.828ns 0.247329mA
+ 5.83ns 0.246285mA
+ 5.832ns 0.245246mA
+ 5.834ns 0.244211mA
+ 5.836ns 0.24318mA
+ 5.838ns 0.242154mA
+ 5.84ns 0.241132mA
+ 5.842ns 0.240115mA
+ 5.844ns 0.239101mA
+ 5.846ns 0.238092mA
+ 5.848ns 0.237088mA
+ 5.85ns 0.236087mA
+ 5.852ns 0.235091mA
+ 5.854ns 0.234099mA
+ 5.856ns 0.233111mA
+ 5.858ns 0.232127mA
+ 5.86ns 0.231147mA
+ 5.862ns 0.230172mA
+ 5.864ns 0.2292mA
+ 5.866ns 0.228233mA
+ 5.868ns 0.22727mA
+ 5.87ns 0.226311mA
+ 5.872ns 0.225356mA
+ 5.874ns 0.224405mA
+ 5.876ns 0.223458mA
+ 5.878ns 0.222514mA
+ 5.88ns 0.221575mA
+ 5.882ns 0.22064mA
+ 5.884ns 0.219709mA
+ 5.886ns 0mA
I198 384 0 PWL 0 0
+ 5.796ns 0mA
+ 5.798ns 0.000802302mA
+ 5.8ns 0.00346232mA
+ 5.802ns 0.0061217mA
+ 5.804ns 0.00878108mA
+ 5.806ns 0.0114411mA
+ 5.808ns 0.0141005mA
+ 5.81ns 0.0167599mA
+ 5.812ns 0.0194199mA
+ 5.814ns 0.0220792mA
+ 5.816ns 0.0247386mA
+ 5.818ns 0.0273986mA
+ 5.82ns 0.030058mA
+ 5.822ns 0.0327174mA
+ 5.824ns 0.0353768mA
+ 5.826ns 0.0380368mA
+ 5.828ns 0.0378738mA
+ 5.83ns 0.0344987mA
+ 5.832ns 0.0314236mA
+ 5.834ns 0.0286231mA
+ 5.836ns 0.0260722mA
+ 5.838ns 0.0237481mA
+ 5.84ns 0.0216316mA
+ 5.842ns 0.0197036mA
+ 5.844ns 0.0179475mA
+ 5.846ns 0.0163475mA
+ 5.848ns 0.0148904mA
+ 5.85ns 0.0135631mA
+ 5.852ns 0.0123539mA
+ 5.854ns 0.0112527mA
+ 5.856ns 0.0102496mA
+ 5.858ns 0mA
I199 386 0 PWL 0 0
+ 0.25ns 0mA
+ 0.252ns 0.00201649mA
+ 0.254ns 0.00443572mA
+ 0.256ns 0.00685495mA
+ 0.258ns 0.00927418mA
+ 0.26ns 0.0116934mA
+ 0.262ns 0.0141126mA
+ 0.264ns 0.0165318mA
+ 0.266ns 0.0189511mA
+ 0.268ns 0.0213703mA
+ 0.27ns 0.0237895mA
+ 0.272ns 0.0262088mA
+ 0.274ns 0.028628mA
+ 0.276ns 0.0310472mA
+ 0.278ns 0.0334665mA
+ 0.28ns 0.0358857mA
+ 0.282ns 0.0383049mA
+ 0.284ns 0.0407241mA
+ 0.286ns 0.0400082mA
+ 0.288ns 0.0369244mA
+ 0.29ns 0.0340783mA
+ 0.292ns 0.0314515mA
+ 0.294ns 0.0290272mA
+ 0.296ns 0.0267897mA
+ 0.298ns 0.0247246mA
+ 0.3ns 0.0228186mA
+ 0.302ns 0.0210596mA
+ 0.304ns 0.0194361mA
+ 0.306ns 0.0179377mA
+ 0.308ns 0.0165549mA
+ 0.31ns 0.0152786mA
+ 0.312ns 0.0141007mA
+ 0.314ns 0.0130136mA
+ 0.316ns 0.0120102mA
+ 0.318ns 0.0110842mA
+ 0.32ns 0mA
I200 388 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00492941mA
+ 2.656ns 0.0155653mA
+ 2.658ns 0.0262mA
+ 2.66ns 0.0368359mA
+ 2.662ns 0.0474705mA
+ 2.664ns 0.0581064mA
+ 2.666ns 0.0687423mA
+ 2.668ns 0.079377mA
+ 2.67ns 0.0900129mA
+ 2.672ns 0.100648mA
+ 2.674ns 0.111283mA
+ 2.676ns 0.121919mA
+ 2.678ns 0.132554mA
+ 2.68ns 0.1186mA
+ 2.682ns 0.106116mA
+ 2.684ns 0.0949441mA
+ 2.686ns 0.0849484mA
+ 2.688ns 0.0760058mA
+ 2.69ns 0.0680035mA
+ 2.692ns 0.0608435mA
+ 2.694ns 0.054438mA
+ 2.696ns 0.048706mA
+ 2.698ns 0.043578mA
+ 2.7ns 0.0389893mA
+ 2.702ns 0.0348837mA
+ 2.704ns 0mA
I201 390 0 PWL 0 0
+ 5.154ns 0mA
+ 5.156ns 0.0087129mA
+ 5.158ns 0.018566mA
+ 5.16ns 0.0284191mA
+ 5.162ns 0.0382745mA
+ 5.164ns 0.0481276mA
+ 5.166ns 0.0579807mA
+ 5.168ns 0.0678362mA
+ 5.17ns 0.0776893mA
+ 5.172ns 0.0875423mA
+ 5.174ns 0.0973978mA
+ 5.176ns 0.107251mA
+ 5.178ns 0.117104mA
+ 5.18ns 0.126957mA
+ 5.182ns 0.136813mA
+ 5.184ns 0.146666mA
+ 5.186ns 0.142627mA
+ 5.188ns 0.130257mA
+ 5.19ns 0.118963mA
+ 5.192ns 0.108648mA
+ 5.194ns 0.0992245mA
+ 5.196ns 0.0906204mA
+ 5.198ns 0.0827622mA
+ 5.2ns 0.0755836mA
+ 5.202ns 0.069029mA
+ 5.204ns 0.0630427mA
+ 5.206ns 0.0575755mA
+ 5.208ns 0.0525811mA
+ 5.21ns 0.0480209mA
+ 5.212ns 0.0438561mA
+ 5.214ns 0.0400516mA
+ 5.216ns 0mA
I202 391 0 PWL 0 0
+ 8.016ns 0mA
+ 8.018ns 0.00642038mA
+ 8.02ns 0.0141925mA
+ 8.022ns 0.0219608mA
+ 8.024ns 0.0297292mA
+ 8.026ns 0.0374975mA
+ 8.028ns 0.0452659mA
+ 8.03ns 0.0530343mA
+ 8.032ns 0.0608026mA
+ 8.034ns 0.0685747mA
+ 8.036ns 0.0763431mA
+ 8.038ns 0.0841114mA
+ 8.04ns 0.0918798mA
+ 8.042ns 0.0996482mA
+ 8.044ns 0.107417mA
+ 8.046ns 0.115185mA
+ 8.048ns 0.122957mA
+ 8.05ns 0.130725mA
+ 8.052ns 0.138494mA
+ 8.054ns 0.146262mA
+ 8.056ns 0.15403mA
+ 8.058ns 0.161799mA
+ 8.06ns 0.169571mA
+ 8.062ns 0.177339mA
+ 8.064ns 0.185108mA
+ 8.066ns 0.192876mA
+ 8.068ns 0.200644mA
+ 8.07ns 0.208413mA
+ 8.072ns 0.216181mA
+ 8.074ns 0.223953mA
+ 8.076ns 0.231721mA
+ 8.078ns 0.23949mA
+ 8.08ns 0.247258mA
+ 8.082ns 0.255027mA
+ 8.084ns 0.262795mA
+ 8.086ns 0.270567mA
+ 8.088ns 0.278335mA
+ 8.09ns 0.286104mA
+ 8.092ns 0.293872mA
+ 8.094ns 0.30164mA
+ 8.096ns 0.309409mA
+ 8.098ns 0.317177mA
+ 8.1ns 0.324949mA
+ 8.102ns 0.332718mA
+ 8.104ns 0.340486mA
+ 8.106ns 0.348254mA
+ 8.108ns 0.356023mA
+ 8.11ns 0.363791mA
+ 8.112ns 0.371563mA
+ 8.114ns 0.379331mA
+ 8.116ns 0.3871mA
+ 8.118ns 0.394868mA
+ 8.12ns 0.402637mA
+ 8.122ns 0.410405mA
+ 8.124ns 0.418173mA
+ 8.126ns 0.425945mA
+ 8.128ns 0.433714mA
+ 8.13ns 0.441482mA
+ 8.132ns 0.44925mA
+ 8.134ns 0.457019mA
+ 8.136ns 0.464787mA
+ 8.138ns 0.472556mA
+ 8.14ns 0.480328mA
+ 8.142ns 0.488096mA
+ 8.144ns 0.495864mA
+ 8.146ns 0.503633mA
+ 8.148ns 0.511401mA
+ 8.15ns 0.519169mA
+ 8.152ns 0.526942mA
+ 8.154ns 0.53471mA
+ 8.156ns 0.542478mA
+ 8.158ns 0.544678mA
+ 8.16ns 0.542335mA
+ 8.162ns 0.540002mA
+ 8.164ns 0.53768mA
+ 8.166ns 0.535366mA
+ 8.168ns 0.533063mA
+ 8.17ns 0.53077mA
+ 8.172ns 0.528487mA
+ 8.174ns 0.526214mA
+ 8.176ns 0.52395mA
+ 8.178ns 0.521695mA
+ 8.18ns 0.519451mA
+ 8.182ns 0.517217mA
+ 8.184ns 0.514992mA
+ 8.186ns 0.512777mA
+ 8.188ns 0.510571mA
+ 8.19ns 0.508375mA
+ 8.192ns 0.506187mA
+ 8.194ns 0.50401mA
+ 8.196ns 0.501842mA
+ 8.198ns 0.499683mA
+ 8.2ns 0.497534mA
+ 8.202ns 0.495394mA
+ 8.204ns 0.493262mA
+ 8.206ns 0.49114mA
+ 8.208ns 0.489028mA
+ 8.21ns 0.486924mA
+ 8.212ns 0.484829mA
+ 8.214ns 0.482744mA
+ 8.216ns 0.480667mA
+ 8.218ns 0.478599mA
+ 8.22ns 0.47654mA
+ 8.222ns 0.47449mA
+ 8.224ns 0.472449mA
+ 8.226ns 0.470417mA
+ 8.228ns 0.468394mA
+ 8.23ns 0.466379mA
+ 8.232ns 0.464372mA
+ 8.234ns 0.462374mA
+ 8.236ns 0.460385mA
+ 8.238ns 0.458405mA
+ 8.24ns 0.456433mA
+ 8.242ns 0.45447mA
+ 8.244ns 0.452514mA
+ 8.246ns 0.450567mA
+ 8.248ns 0.448629mA
+ 8.25ns 0.446699mA
+ 8.252ns 0.444778mA
+ 8.254ns 0.442864mA
+ 8.256ns 0.440959mA
+ 8.258ns 0.439062mA
+ 8.26ns 0.437173mA
+ 8.262ns 0.435292mA
+ 8.264ns 0.43342mA
+ 8.266ns 0.431556mA
+ 8.268ns 0.429699mA
+ 8.27ns 0.42785mA
+ 8.272ns 0.426009mA
+ 8.274ns 0.424177mA
+ 8.276ns 0.422352mA
+ 8.278ns 0.420535mA
+ 8.28ns 0.418726mA
+ 8.282ns 0.416925mA
+ 8.284ns 0.415131mA
+ 8.286ns 0.413345mA
+ 8.288ns 0.411567mA
+ 8.29ns 0.409797mA
+ 8.292ns 0.408034mA
+ 8.294ns 0.406279mA
+ 8.296ns 0.40453mA
+ 8.298ns 0.40279mA
+ 8.3ns 0.401057mA
+ 8.302ns 0.399332mA
+ 8.304ns 0.397614mA
+ 8.306ns 0.395904mA
+ 8.308ns 0.394201mA
+ 8.31ns 0.392504mA
+ 8.312ns 0.390816mA
+ 8.314ns 0.389135mA
+ 8.316ns 0.387461mA
+ 8.318ns 0.385794mA
+ 8.32ns 0.384134mA
+ 8.322ns 0.382482mA
+ 8.324ns 0.380836mA
+ 8.326ns 0.379197mA
+ 8.328ns 0.377566mA
+ 8.33ns 0.375942mA
+ 8.332ns 0.374325mA
+ 8.334ns 0.372715mA
+ 8.336ns 0.37111mA
+ 8.338ns 0.369514mA
+ 8.34ns 0.367924mA
+ 8.342ns 0.366342mA
+ 8.344ns 0.364766mA
+ 8.346ns 0.363197mA
+ 8.348ns 0.361634mA
+ 8.35ns 0.360078mA
+ 8.352ns 0.358529mA
+ 8.354ns 0.356986mA
+ 8.356ns 0.355451mA
+ 8.358ns 0.353922mA
+ 8.36ns 0.352399mA
+ 8.362ns 0.350883mA
+ 8.364ns 0.349373mA
+ 8.366ns 0.34787mA
+ 8.368ns 0.346374mA
+ 8.37ns 0.344884mA
+ 8.372ns 0.3434mA
+ 8.374ns 0.341923mA
+ 8.376ns 0.340451mA
+ 8.378ns 0.338987mA
+ 8.38ns 0.337528mA
+ 8.382ns 0.336076mA
+ 8.384ns 0.33463mA
+ 8.386ns 0.333191mA
+ 8.388ns 0.331757mA
+ 8.39ns 0.33033mA
+ 8.392ns 0.328909mA
+ 8.394ns 0.327494mA
+ 8.396ns 0.326085mA
+ 8.398ns 0.324682mA
+ 8.4ns 0.323285mA
+ 8.402ns 0.321894mA
+ 8.404ns 0.320509mA
+ 8.406ns 0.31913mA
+ 8.408ns 0.317757mA
+ 8.41ns 0.31639mA
+ 8.412ns 0.315029mA
+ 8.414ns 0.313674mA
+ 8.416ns 0.312324mA
+ 8.418ns 0.31098mA
+ 8.42ns 0.309643mA
+ 8.422ns 0.308311mA
+ 8.424ns 0.306984mA
+ 8.426ns 0.305664mA
+ 8.428ns 0.304348mA
+ 8.43ns 0.303039mA
+ 8.432ns 0.301735mA
+ 8.434ns 0.300437mA
+ 8.436ns 0.299144mA
+ 8.438ns 0.297858mA
+ 8.44ns 0.296576mA
+ 8.442ns 0.2953mA
+ 8.444ns 0.294029mA
+ 8.446ns 0.292764mA
+ 8.448ns 0.291505mA
+ 8.45ns 0.290251mA
+ 8.452ns 0.289002mA
+ 8.454ns 0.287758mA
+ 8.456ns 0.28652mA
+ 8.458ns 0.285288mA
+ 8.46ns 0.28406mA
+ 8.462ns 0.282838mA
+ 8.464ns 0.281622mA
+ 8.466ns 0.28041mA
+ 8.468ns 0.279203mA
+ 8.47ns 0.278002mA
+ 8.472ns 0.276806mA
+ 8.474ns 0.275615mA
+ 8.476ns 0.274429mA
+ 8.478ns 0.273249mA
+ 8.48ns 0.272073mA
+ 8.482ns 0.270902mA
+ 8.484ns 0.269737mA
+ 8.486ns 0.268576mA
+ 8.488ns 0.267421mA
+ 8.49ns 0.26627mA
+ 8.492ns 0.265125mA
+ 8.494ns 0.263984mA
+ 8.496ns 0.262848mA
+ 8.498ns 0.261717mA
+ 8.5ns 0.260591mA
+ 8.502ns 0.25947mA
+ 8.504ns 0.258354mA
+ 8.506ns 0.257242mA
+ 8.508ns 0.256135mA
+ 8.51ns 0.255033mA
+ 8.512ns 0.253936mA
+ 8.514ns 0.252843mA
+ 8.516ns 0.251756mA
+ 8.518ns 0.250673mA
+ 8.52ns 0.249594mA
+ 8.522ns 0.24852mA
+ 8.524ns 0.247451mA
+ 8.526ns 0.246386mA
+ 8.528ns 0.245326mA
+ 8.53ns 0.244271mA
+ 8.532ns 0.24322mA
+ 8.534ns 0.242173mA
+ 8.536ns 0.241131mA
+ 8.538ns 0.240094mA
+ 8.54ns 0.239061mA
+ 8.542ns 0.238032mA
+ 8.544ns 0.237008mA
+ 8.546ns 0.235988mA
+ 8.548ns 0.234973mA
+ 8.55ns 0mA
I203 392 0 PWL 0 0
+ 5.372ns 0mA
+ 5.374ns 0.00343957mA
+ 5.376ns 0.0111743mA
+ 5.378ns 0.0189109mA
+ 5.38ns 0.0266457mA
+ 5.382ns 0.0343804mA
+ 5.384ns 0.042117mA
+ 5.386ns 0.0498517mA
+ 5.388ns 0.042665mA
+ 5.39ns 0.0345762mA
+ 5.392ns 0.0280192mA
+ 5.394ns 0.0227066mA
+ 5.396ns 0.0184011mA
+ 5.398ns 0.014911mA
+ 5.4ns 0mA
I204 393 0 PWL 0 0
+ 5.45ns 0mA
+ 5.452ns 0.00129139mA
+ 5.454ns 0.00868319mA
+ 5.456ns 0.016075mA
+ 5.458ns 0.0234686mA
+ 5.46ns 0.0308604mA
+ 5.462ns 0.0382522mA
+ 5.464ns 0.0456457mA
+ 5.466ns 0.0530375mA
+ 5.468ns 0.0604293mA
+ 5.47ns 0.0678229mA
+ 5.472ns 0.0615665mA
+ 5.474ns 0.0531035mA
+ 5.476ns 0.0458036mA
+ 5.478ns 0.0395056mA
+ 5.48ns 0.0340746mA
+ 5.482ns 0.0293901mA
+ 5.484ns 0.0253485mA
+ 5.486ns 0.0218634mA
+ 5.488ns 0.0188573mA
+ 5.49ns 0mA
I205 395 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00310058mA
+ 0.156ns 0.0139414mA
+ 0.158ns 0.0247823mA
+ 0.16ns 0.0356233mA
+ 0.162ns 0.0464641mA
+ 0.164ns 0.057305mA
+ 0.166ns 0.068146mA
+ 0.168ns 0.0789869mA
+ 0.17ns 0.0898277mA
+ 0.172ns 0.100669mA
+ 0.174ns 0.11151mA
+ 0.176ns 0.122351mA
+ 0.178ns 0.133191mA
+ 0.18ns 0.122629mA
+ 0.182ns 0.109693mA
+ 0.184ns 0.0981215mA
+ 0.186ns 0.0877702mA
+ 0.188ns 0.0785107mA
+ 0.19ns 0.0702278mA
+ 0.192ns 0.0628186mA
+ 0.194ns 0.0561908mA
+ 0.196ns 0.0502622mA
+ 0.198ns 0.044959mA
+ 0.2ns 0.0402152mA
+ 0.202ns 0.0359719mA
+ 0.204ns 0mA
+ 2.652ns 0mA
+ 2.654ns 0.00310122mA
+ 2.656ns 0.0139426mA
+ 2.658ns 0.0247828mA
+ 2.66ns 0.0356242mA
+ 2.662ns 0.0464643mA
+ 2.664ns 0.0573057mA
+ 2.666ns 0.0681471mA
+ 2.668ns 0.0789872mA
+ 2.67ns 0.0898286mA
+ 2.672ns 0.100669mA
+ 2.674ns 0.11151mA
+ 2.676ns 0.122352mA
+ 2.678ns 0.133192mA
+ 2.68ns 0.122628mA
+ 2.682ns 0.109693mA
+ 2.684ns 0.098121mA
+ 2.686ns 0.0877693mA
+ 2.688ns 0.0785105mA
+ 2.69ns 0.0702272mA
+ 2.692ns 0.0628177mA
+ 2.694ns 0.0561906mA
+ 2.696ns 0.0502617mA
+ 2.698ns 0.0449589mA
+ 2.7ns 0.0402149mA
+ 2.702ns 0.0359714mA
+ 2.704ns 0mA
I206 396 0 PWL 0 0
+ 2.634ns 0mA
+ 2.636ns 0.000259595mA
+ 2.638ns 0.0047391mA
+ 2.64ns 0.00921861mA
+ 2.642ns 0.0136976mA
+ 2.644ns 0.0181771mA
+ 2.646ns 0.0226566mA
+ 2.648ns 0.0271356mA
+ 2.65ns 0.0316151mA
+ 2.652ns 0.0360941mA
+ 2.654ns 0.0405736mA
+ 2.656ns 0.0450531mA
+ 2.658ns 0.049532mA
+ 2.66ns 0.0540115mA
+ 2.662ns 0.0584905mA
+ 2.664ns 0.06297mA
+ 2.666ns 0.0674495mA
+ 2.668ns 0.0719285mA
+ 2.67ns 0.076408mA
+ 2.672ns 0.080887mA
+ 2.674ns 0.0853665mA
+ 2.676ns 0.089846mA
+ 2.678ns 0.094325mA
+ 2.68ns 0.0988045mA
+ 2.682ns 0.103283mA
+ 2.684ns 0.107763mA
+ 2.686ns 0.110618mA
+ 2.688ns 0.107048mA
+ 2.69ns 0.103592mA
+ 2.692ns 0.100249mA
+ 2.694ns 0.0970129mA
+ 2.696ns 0.0938813mA
+ 2.698ns 0.0908511mA
+ 2.7ns 0.0879184mA
+ 2.702ns 0.0850803mA
+ 2.704ns 0.0823341mA
+ 2.706ns 0.0796763mA
+ 2.708ns 0.0771045mA
+ 2.71ns 0.0746154mA
+ 2.712ns 0.0722067mA
+ 2.714ns 0.069876mA
+ 2.716ns 0.0676202mA
+ 2.718ns 0.0654375mA
+ 2.72ns 0.0633249mA
+ 2.722ns 0.0612806mA
+ 2.724ns 0.0593025mA
+ 2.726ns 0.0573879mA
+ 2.728ns 0.0555354mA
+ 2.73ns 0.0537425mA
+ 2.732ns 0.0520074mA
+ 2.734ns 0.0503286mA
+ 2.736ns 0.0487037mA
+ 2.738ns 0.0471315mA
+ 2.74ns 0.0456098mA
+ 2.742ns 0.0441373mA
+ 2.744ns 0.0427124mA
+ 2.746ns 0.0413334mA
+ 2.748ns 0.0399988mA
+ 2.75ns 0.0387076mA
+ 2.752ns 0.0374578mA
+ 2.754ns 0mA
+ 5.134ns 0mA
+ 5.136ns 0.000260663mA
+ 5.138ns 0.00473964mA
+ 5.14ns 0.00921861mA
+ 5.142ns 0.0136987mA
+ 5.144ns 0.0181776mA
+ 5.146ns 0.0226566mA
+ 5.148ns 0.0271366mA
+ 5.15ns 0.0316156mA
+ 5.152ns 0.0360946mA
+ 5.154ns 0.0405746mA
+ 5.156ns 0.0450536mA
+ 5.158ns 0.0495326mA
+ 5.16ns 0.0540115mA
+ 5.162ns 0.0584916mA
+ 5.164ns 0.0629706mA
+ 5.166ns 0.0674495mA
+ 5.168ns 0.0719296mA
+ 5.17ns 0.0764086mA
+ 5.172ns 0.0808875mA
+ 5.174ns 0.0853676mA
+ 5.176ns 0.0898465mA
+ 5.178ns 0.0943255mA
+ 5.18ns 0.0988045mA
+ 5.182ns 0.103285mA
+ 5.184ns 0.107764mA
+ 5.186ns 0.110618mA
+ 5.188ns 0.107047mA
+ 5.19ns 0.103592mA
+ 5.192ns 0.100249mA
+ 5.194ns 0.0970121mA
+ 5.196ns 0.0938809mA
+ 5.198ns 0.0908508mA
+ 5.2ns 0.0879177mA
+ 5.202ns 0.08508mA
+ 5.204ns 0.0823338mA
+ 5.206ns 0.0796763mA
+ 5.208ns 0.0771039mA
+ 5.21ns 0.0746151mA
+ 5.212ns 0.0722067mA
+ 5.214ns 0.0698754mA
+ 5.216ns 0.0676199mA
+ 5.218ns 0.0654372mA
+ 5.22ns 0.0633244mA
+ 5.222ns 0.0612803mA
+ 5.224ns 0.0593022mA
+ 5.226ns 0.0573879mA
+ 5.228ns 0.055535mA
+ 5.23ns 0.0537423mA
+ 5.232ns 0.0520074mA
+ 5.234ns 0.0503282mA
+ 5.236ns 0.0487035mA
+ 5.238ns 0.0471313mA
+ 5.24ns 0.0456095mA
+ 5.242ns 0.0441371mA
+ 5.244ns 0.0427122mA
+ 5.246ns 0.041333mA
+ 5.248ns 0.0399987mA
+ 5.25ns 0.0387074mA
+ 5.252ns 0.0374578mA
+ 5.254ns 0mA
I207 397 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00351501mA
+ 0.156ns 0.0135043mA
+ 0.158ns 0.0234937mA
+ 0.16ns 0.0334831mA
+ 0.162ns 0.0434724mA
+ 0.164ns 0.0534618mA
+ 0.166ns 0.0634511mA
+ 0.168ns 0.0734405mA
+ 0.17ns 0.0834298mA
+ 0.172ns 0.0934192mA
+ 0.174ns 0.103409mA
+ 0.176ns 0.113398mA
+ 0.178ns 0.123387mA
+ 0.18ns 0.133377mA
+ 0.182ns 0.138625mA
+ 0.184ns 0.125689mA
+ 0.186ns 0.11396mA
+ 0.188ns 0.103326mA
+ 0.19ns 0.0936833mA
+ 0.192ns 0.0849405mA
+ 0.194ns 0.0770133mA
+ 0.196ns 0.0698258mA
+ 0.198ns 0.063309mA
+ 0.2ns 0.0574003mA
+ 0.202ns 0.0520429mA
+ 0.204ns 0.0471854mA
+ 0.206ns 0.0427812mA
+ 0.208ns 0.038788mA
+ 0.21ns 0mA
+ 5.152ns 0mA
+ 5.154ns 0.00351583mA
+ 5.156ns 0.0135045mA
+ 5.158ns 0.0234931mA
+ 5.16ns 0.0334817mA
+ 5.162ns 0.0434727mA
+ 5.164ns 0.0534614mA
+ 5.166ns 0.06345mA
+ 5.168ns 0.073441mA
+ 5.17ns 0.0834297mA
+ 5.172ns 0.0934183mA
+ 5.174ns 0.103409mA
+ 5.176ns 0.113398mA
+ 5.178ns 0.123387mA
+ 5.18ns 0.133375mA
+ 5.182ns 0.138625mA
+ 5.184ns 0.12569mA
+ 5.186ns 0.113962mA
+ 5.188ns 0.103325mA
+ 5.19ns 0.0936835mA
+ 5.192ns 0.0849413mA
+ 5.194ns 0.0770128mA
+ 5.196ns 0.0698259mA
+ 5.198ns 0.0633095mA
+ 5.2ns 0.0573998mA
+ 5.202ns 0.0520428mA
+ 5.204ns 0.0471857mA
+ 5.206ns 0.0427817mA
+ 5.208ns 0.0387878mA
+ 5.21ns 0mA
I208 398 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00357746mA
+ 0.156ns 0.0136364mA
+ 0.158ns 0.0236954mA
+ 0.16ns 0.0337544mA
+ 0.162ns 0.0438134mA
+ 0.164ns 0.0538724mA
+ 0.166ns 0.0639314mA
+ 0.168ns 0.0739904mA
+ 0.17ns 0.0840494mA
+ 0.172ns 0.0941084mA
+ 0.174ns 0.104167mA
+ 0.176ns 0.114226mA
+ 0.178ns 0.124285mA
+ 0.18ns 0.134344mA
+ 0.182ns 0.136085mA
+ 0.184ns 0.12326mA
+ 0.186ns 0.111644mA
+ 0.188ns 0.101122mA
+ 0.19ns 0.0915913mA
+ 0.192ns 0.0829588mA
+ 0.194ns 0.0751397mA
+ 0.196ns 0.0680574mA
+ 0.198ns 0.0616424mA
+ 0.2ns 0.0558321mA
+ 0.202ns 0.0505693mA
+ 0.204ns 0.0458024mA
+ 0.206ns 0.0414848mA
+ 0.208ns 0.0375741mA
+ 0.21ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00358038mA
+ 7.656ns 0.0136386mA
+ 7.658ns 0.0236969mA
+ 7.66ns 0.0337552mA
+ 7.662ns 0.0438158mA
+ 7.664ns 0.0538741mA
+ 7.666ns 0.0639324mA
+ 7.668ns 0.073993mA
+ 7.67ns 0.0840513mA
+ 7.672ns 0.0941096mA
+ 7.674ns 0.10417mA
+ 7.676ns 0.114229mA
+ 7.678ns 0.124287mA
+ 7.68ns 0.134347mA
+ 7.682ns 0.136082mA
+ 7.684ns 0.123259mA
+ 7.686ns 0.111643mA
+ 7.688ns 0.101119mA
+ 7.69ns 0.0915897mA
+ 7.692ns 0.0829579mA
+ 7.694ns 0.0751376mA
+ 7.696ns 0.068056mA
+ 7.698ns 0.0616417mA
+ 7.7ns 0.0558305mA
+ 7.702ns 0.0505681mA
+ 7.704ns 0.0458017mA
+ 7.706ns 0.0414845mA
+ 7.708ns 0.0375732mA
+ 7.71ns 0mA
I209 399 0 PWL 0 0
+ 5.508ns 0mA
+ 5.51ns 7.19375e-05mA
+ 5.512ns 0.00773431mA
+ 5.514ns 0.0153967mA
+ 5.516ns 0.0230609mA
+ 5.518ns 0.0307233mA
+ 5.52ns 0.0383856mA
+ 5.522ns 0.046048mA
+ 5.524ns 0.0537122mA
+ 5.526ns 0.0613746mA
+ 5.528ns 0.069037mA
+ 5.53ns 0.0767012mA
+ 5.532ns 0.0843635mA
+ 5.534ns 0.0920259mA
+ 5.536ns 0.0996901mA
+ 5.538ns 0.107352mA
+ 5.54ns 0.115015mA
+ 5.542ns 0.122679mA
+ 5.544ns 0.130341mA
+ 5.546ns 0.138004mA
+ 5.548ns 0.145666mA
+ 5.55ns 0.15333mA
+ 5.552ns 0.160993mA
+ 5.554ns 0.168655mA
+ 5.556ns 0.176319mA
+ 5.558ns 0.183982mA
+ 5.56ns 0.191644mA
+ 5.562ns 0.199308mA
+ 5.564ns 0.206971mA
+ 5.566ns 0.214633mA
+ 5.568ns 0.222295mA
+ 5.57ns 0.22996mA
+ 5.572ns 0.237622mA
+ 5.574ns 0.245284mA
+ 5.576ns 0.252949mA
+ 5.578ns 0.260611mA
+ 5.58ns 0.268273mA
+ 5.582ns 0.275938mA
+ 5.584ns 0.2836mA
+ 5.586ns 0.291262mA
+ 5.588ns 0.298926mA
+ 5.59ns 0.306589mA
+ 5.592ns 0.314251mA
+ 5.594ns 0.321914mA
+ 5.596ns 0.329578mA
+ 5.598ns 0.33724mA
+ 5.6ns 0.344903mA
+ 5.602ns 0.352567mA
+ 5.604ns 0.360229mA
+ 5.606ns 0.367891mA
+ 5.608ns 0.375556mA
+ 5.61ns 0.383218mA
+ 5.612ns 0.39088mA
+ 5.614ns 0.398543mA
+ 5.616ns 0.406207mA
+ 5.618ns 0.413869mA
+ 5.62ns 0.421532mA
+ 5.622ns 0.429196mA
+ 5.624ns 0.436858mA
+ 5.626ns 0.444521mA
+ 5.628ns 0.452185mA
+ 5.63ns 0.459847mA
+ 5.632ns 0.46751mA
+ 5.634ns 0.475174mA
+ 5.636ns 0.482836mA
+ 5.638ns 0.490499mA
+ 5.64ns 0.498161mA
+ 5.642ns 0.505825mA
+ 5.644ns 0.513488mA
+ 5.646ns 0.52115mA
+ 5.648ns 0.528814mA
+ 5.65ns 0.536477mA
+ 5.652ns 0.544139mA
+ 5.654ns 0.551803mA
+ 5.656ns 0.549888mA
+ 5.658ns 0.547481mA
+ 5.66ns 0.545085mA
+ 5.662ns 0.542699mA
+ 5.664ns 0.540323mA
+ 5.666ns 0.537958mA
+ 5.668ns 0.535603mA
+ 5.67ns 0.533259mA
+ 5.672ns 0.530925mA
+ 5.674ns 0.5286mA
+ 5.676ns 0.526287mA
+ 5.678ns 0.523983mA
+ 5.68ns 0.521689mA
+ 5.682ns 0.519406mA
+ 5.684ns 0.517132mA
+ 5.686ns 0.514869mA
+ 5.688ns 0.512615mA
+ 5.69ns 0.510371mA
+ 5.692ns 0.508137mA
+ 5.694ns 0.505912mA
+ 5.696ns 0.503698mA
+ 5.698ns 0.501493mA
+ 5.7ns 0.499298mA
+ 5.702ns 0.497112mA
+ 5.704ns 0.494936mA
+ 5.706ns 0.49277mA
+ 5.708ns 0.490613mA
+ 5.71ns 0.488465mA
+ 5.712ns 0.486327mA
+ 5.714ns 0.484198mA
+ 5.716ns 0.482079mA
+ 5.718ns 0.479969mA
+ 5.72ns 0.477867mA
+ 5.722ns 0.475776mA
+ 5.724ns 0.473693mA
+ 5.726ns 0.471619mA
+ 5.728ns 0.469555mA
+ 5.73ns 0.4675mA
+ 5.732ns 0.465453mA
+ 5.734ns 0.463415mA
+ 5.736ns 0.461387mA
+ 5.738ns 0.459367mA
+ 5.74ns 0.457356mA
+ 5.742ns 0.455354mA
+ 5.744ns 0.453361mA
+ 5.746ns 0.451376mA
+ 5.748ns 0.449401mA
+ 5.75ns 0.447434mA
+ 5.752ns 0.445475mA
+ 5.754ns 0.443525mA
+ 5.756ns 0.441583mA
+ 5.758ns 0.43965mA
+ 5.76ns 0.437726mA
+ 5.762ns 0.435809mA
+ 5.764ns 0.433902mA
+ 5.766ns 0.432002mA
+ 5.768ns 0.430111mA
+ 5.77ns 0.428229mA
+ 5.772ns 0.426354mA
+ 5.774ns 0.424487mA
+ 5.776ns 0.422629mA
+ 5.778ns 0.420779mA
+ 5.78ns 0.418937mA
+ 5.782ns 0.417103mA
+ 5.784ns 0.415278mA
+ 5.786ns 0.413459mA
+ 5.788ns 0.41165mA
+ 5.79ns 0.409848mA
+ 5.792ns 0.408053mA
+ 5.794ns 0.406267mA
+ 5.796ns 0.404489mA
+ 5.798ns 0.402718mA
+ 5.8ns 0.400955mA
+ 5.802ns 0.3992mA
+ 5.804ns 0.397452mA
+ 5.806ns 0.395712mA
+ 5.808ns 0.39398mA
+ 5.81ns 0.392256mA
+ 5.812ns 0.390538mA
+ 5.814ns 0.388829mA
+ 5.816ns 0.387127mA
+ 5.818ns 0.385432mA
+ 5.82ns 0.383745mA
+ 5.822ns 0.382065mA
+ 5.824ns 0.380392mA
+ 5.826ns 0.378727mA
+ 5.828ns 0.377069mA
+ 5.83ns 0.375418mA
+ 5.832ns 0.373775mA
+ 5.834ns 0.372139mA
+ 5.836ns 0.37051mA
+ 5.838ns 0.368887mA
+ 5.84ns 0.367273mA
+ 5.842ns 0.365665mA
+ 5.844ns 0.364064mA
+ 5.846ns 0.36247mA
+ 5.848ns 0.360884mA
+ 5.85ns 0.359304mA
+ 5.852ns 0.357731mA
+ 5.854ns 0.356165mA
+ 5.856ns 0.354606mA
+ 5.858ns 0.353053mA
+ 5.86ns 0.351508mA
+ 5.862ns 0.349969mA
+ 5.864ns 0.348437mA
+ 5.866ns 0.346911mA
+ 5.868ns 0.345393mA
+ 5.87ns 0.343881mA
+ 5.872ns 0.342375mA
+ 5.874ns 0.340876mA
+ 5.876ns 0.339384mA
+ 5.878ns 0.337898mA
+ 5.88ns 0.336419mA
+ 5.882ns 0.334946mA
+ 5.884ns 0.33348mA
+ 5.886ns 0.33202mA
+ 5.888ns 0.330567mA
+ 5.89ns 0.32912mA
+ 5.892ns 0.327679mA
+ 5.894ns 0.326244mA
+ 5.896ns 0.324816mA
+ 5.898ns 0.323394mA
+ 5.9ns 0.321978mA
+ 5.902ns 0.320569mA
+ 5.904ns 0.319165mA
+ 5.906ns 0.317768mA
+ 5.908ns 0.316377mA
+ 5.91ns 0.314992mA
+ 5.912ns 0.313613mA
+ 5.914ns 0.31224mA
+ 5.916ns 0.310873mA
+ 5.918ns 0.309512mA
+ 5.92ns 0.308157mA
+ 5.922ns 0.306808mA
+ 5.924ns 0.305465mA
+ 5.926ns 0.304127mA
+ 5.928ns 0.302796mA
+ 5.93ns 0.30147mA
+ 5.932ns 0.300151mA
+ 5.934ns 0.298837mA
+ 5.936ns 0.297528mA
+ 5.938ns 0.296226mA
+ 5.94ns 0.294929mA
+ 5.942ns 0.293638mA
+ 5.944ns 0.292352mA
+ 5.946ns 0.291072mA
+ 5.948ns 0.289798mA
+ 5.95ns 0.288529mA
+ 5.952ns 0.287266mA
+ 5.954ns 0.286009mA
+ 5.956ns 0.284756mA
+ 5.958ns 0.28351mA
+ 5.96ns 0.282269mA
+ 5.962ns 0.281033mA
+ 5.964ns 0.279802mA
+ 5.966ns 0.278577mA
+ 5.968ns 0.277358mA
+ 5.97ns 0.276143mA
+ 5.972ns 0.274935mA
+ 5.974ns 0.273731mA
+ 5.976ns 0.272532mA
+ 5.978ns 0.271339mA
+ 5.98ns 0.270152mA
+ 5.982ns 0.268969mA
+ 5.984ns 0.267791mA
+ 5.986ns 0.266619mA
+ 5.988ns 0.265452mA
+ 5.99ns 0.264289mA
+ 5.992ns 0.263132mA
+ 5.994ns 0.26198mA
+ 5.996ns 0.260833mA
+ 5.998ns 0.259691mA
+ 6ns 0.258555mA
+ 6.002ns 0.257423mA
+ 6.004ns 0.256295mA
+ 6.006ns 0.255173mA
+ 6.008ns 0.254056mA
+ 6.01ns 0.252944mA
+ 6.012ns 0.251837mA
+ 6.014ns 0.250734mA
+ 6.016ns 0.249636mA
+ 6.018ns 0.248543mA
+ 6.02ns 0.247455mA
+ 6.022ns 0.246372mA
+ 6.024ns 0.245293mA
+ 6.026ns 0.244219mA
+ 6.028ns 0.24315mA
+ 6.03ns 0.242085mA
+ 6.032ns 0.241026mA
+ 6.034ns 0.23997mA
+ 6.036ns 0.23892mA
+ 6.038ns 0.237874mA
+ 6.04ns 0.236832mA
+ 6.042ns 0.235796mA
+ 6.044ns 0mA
I210 400 0 PWL 0 0
+ 0.514ns 0mA
+ 0.516ns 0.000202576mA
+ 0.518ns 0.00784852mA
+ 0.52ns 0.0154947mA
+ 0.522ns 0.0231406mA
+ 0.524ns 0.0307868mA
+ 0.526ns 0.0384328mA
+ 0.528ns 0.0460787mA
+ 0.53ns 0.0537249mA
+ 0.532ns 0.0613708mA
+ 0.534ns 0.069017mA
+ 0.536ns 0.076663mA
+ 0.538ns 0.0843091mA
+ 0.54ns 0.0919551mA
+ 0.542ns 0.0996013mA
+ 0.544ns 0.107247mA
+ 0.546ns 0.114893mA
+ 0.548ns 0.122539mA
+ 0.55ns 0.130185mA
+ 0.552ns 0.137831mA
+ 0.554ns 0.145477mA
+ 0.556ns 0.153124mA
+ 0.558ns 0.16077mA
+ 0.56ns 0.168415mA
+ 0.562ns 0.176062mA
+ 0.564ns 0.183708mA
+ 0.566ns 0.191354mA
+ 0.568ns 0.199mA
+ 0.57ns 0.206646mA
+ 0.572ns 0.214292mA
+ 0.574ns 0.221938mA
+ 0.576ns 0.229584mA
+ 0.578ns 0.23723mA
+ 0.58ns 0.244876mA
+ 0.582ns 0.252522mA
+ 0.584ns 0.260168mA
+ 0.586ns 0.267814mA
+ 0.588ns 0.27546mA
+ 0.59ns 0.283106mA
+ 0.592ns 0.290752mA
+ 0.594ns 0.298398mA
+ 0.596ns 0.306044mA
+ 0.598ns 0.31369mA
+ 0.6ns 0.321336mA
+ 0.602ns 0.328983mA
+ 0.604ns 0.336629mA
+ 0.606ns 0.344275mA
+ 0.608ns 0.351921mA
+ 0.61ns 0.359567mA
+ 0.612ns 0.367213mA
+ 0.614ns 0.374859mA
+ 0.616ns 0.382505mA
+ 0.618ns 0.390151mA
+ 0.62ns 0.397797mA
+ 0.622ns 0.405443mA
+ 0.624ns 0.413089mA
+ 0.626ns 0.420735mA
+ 0.628ns 0.428381mA
+ 0.63ns 0.436027mA
+ 0.632ns 0.443673mA
+ 0.634ns 0.451319mA
+ 0.636ns 0.458965mA
+ 0.638ns 0.466611mA
+ 0.64ns 0.474257mA
+ 0.642ns 0.481903mA
+ 0.644ns 0.48955mA
+ 0.646ns 0.497195mA
+ 0.648ns 0.504841mA
+ 0.65ns 0.512488mA
+ 0.652ns 0.520134mA
+ 0.654ns 0.52778mA
+ 0.656ns 0.535426mA
+ 0.658ns 0.543072mA
+ 0.66ns 0.550718mA
+ 0.662ns 0.549811mA
+ 0.664ns 0.547406mA
+ 0.666ns 0.545011mA
+ 0.668ns 0.542626mA
+ 0.67ns 0.540252mA
+ 0.672ns 0.537889mA
+ 0.674ns 0.535535mA
+ 0.676ns 0.533192mA
+ 0.678ns 0.53086mA
+ 0.68ns 0.528537mA
+ 0.682ns 0.526224mA
+ 0.684ns 0.523922mA
+ 0.686ns 0.52163mA
+ 0.688ns 0.519348mA
+ 0.69ns 0.517075mA
+ 0.692ns 0.514813mA
+ 0.694ns 0.512561mA
+ 0.696ns 0.510318mA
+ 0.698ns 0.508086mA
+ 0.7ns 0.505863mA
+ 0.702ns 0.503649mA
+ 0.704ns 0.501446mA
+ 0.706ns 0.499252mA
+ 0.708ns 0.497067mA
+ 0.71ns 0.494893mA
+ 0.712ns 0.492727mA
+ 0.714ns 0.490572mA
+ 0.716ns 0.488425mA
+ 0.718ns 0.486288mA
+ 0.72ns 0.484161mA
+ 0.722ns 0.482042mA
+ 0.724ns 0.479933mA
+ 0.726ns 0.477833mA
+ 0.728ns 0.475743mA
+ 0.73ns 0.473661mA
+ 0.732ns 0.471589mA
+ 0.734ns 0.469526mA
+ 0.736ns 0.467471mA
+ 0.738ns 0.465426mA
+ 0.74ns 0.46339mA
+ 0.742ns 0.461362mA
+ 0.744ns 0.459343mA
+ 0.746ns 0.457334mA
+ 0.748ns 0.455333mA
+ 0.75ns 0.453341mA
+ 0.752ns 0.451357mA
+ 0.754ns 0.449382mA
+ 0.756ns 0.447416mA
+ 0.758ns 0.445458mA
+ 0.76ns 0.443509mA
+ 0.762ns 0.441569mA
+ 0.764ns 0.439637mA
+ 0.766ns 0.437713mA
+ 0.768ns 0.435798mA
+ 0.77ns 0.433891mA
+ 0.772ns 0.431993mA
+ 0.774ns 0.430103mA
+ 0.776ns 0.428221mA
+ 0.778ns 0.426347mA
+ 0.78ns 0.424482mA
+ 0.782ns 0.422625mA
+ 0.784ns 0.420775mA
+ 0.786ns 0.418934mA
+ 0.788ns 0.417101mA
+ 0.79ns 0.415276mA
+ 0.792ns 0.413459mA
+ 0.794ns 0.41165mA
+ 0.796ns 0.409849mA
+ 0.798ns 0.408056mA
+ 0.8ns 0.406271mA
+ 0.802ns 0.404493mA
+ 0.804ns 0.402723mA
+ 0.806ns 0.400961mA
+ 0.808ns 0.399207mA
+ 0.81ns 0.39746mA
+ 0.812ns 0.395721mA
+ 0.814ns 0.393989mA
+ 0.816ns 0.392265mA
+ 0.818ns 0.390549mA
+ 0.82ns 0.38884mA
+ 0.822ns 0.387139mA
+ 0.824ns 0.385445mA
+ 0.826ns 0.383758mA
+ 0.828ns 0.382079mA
+ 0.83ns 0.380408mA
+ 0.832ns 0.378743mA
+ 0.834ns 0.377086mA
+ 0.836ns 0.375436mA
+ 0.838ns 0.373793mA
+ 0.84ns 0.372158mA
+ 0.842ns 0.370529mA
+ 0.844ns 0.368908mA
+ 0.846ns 0.367294mA
+ 0.848ns 0.365687mA
+ 0.85ns 0.364087mA
+ 0.852ns 0.362494mA
+ 0.854ns 0.360907mA
+ 0.856ns 0.359328mA
+ 0.858ns 0.357756mA
+ 0.86ns 0.356191mA
+ 0.862ns 0.354632mA
+ 0.864ns 0.35308mA
+ 0.866ns 0.351535mA
+ 0.868ns 0.349997mA
+ 0.87ns 0.348466mA
+ 0.872ns 0.346941mA
+ 0.874ns 0.345423mA
+ 0.876ns 0.343912mA
+ 0.878ns 0.342407mA
+ 0.88ns 0.340908mA
+ 0.882ns 0.339417mA
+ 0.884ns 0.337932mA
+ 0.886ns 0.336453mA
+ 0.888ns 0.334981mA
+ 0.89ns 0.333515mA
+ 0.892ns 0.332056mA
+ 0.894ns 0.330603mA
+ 0.896ns 0.329156mA
+ 0.898ns 0.327716mA
+ 0.9ns 0.326282mA
+ 0.902ns 0.324854mA
+ 0.904ns 0.323433mA
+ 0.906ns 0.322017mA
+ 0.908ns 0.320608mA
+ 0.91ns 0.319206mA
+ 0.912ns 0.317809mA
+ 0.914ns 0.316418mA
+ 0.916ns 0.315034mA
+ 0.918ns 0.313655mA
+ 0.92ns 0.312283mA
+ 0.922ns 0.310916mA
+ 0.924ns 0.309556mA
+ 0.926ns 0.308201mA
+ 0.928ns 0.306853mA
+ 0.93ns 0.30551mA
+ 0.932ns 0.304173mA
+ 0.934ns 0.302842mA
+ 0.936ns 0.301517mA
+ 0.938ns 0.300198mA
+ 0.94ns 0.298884mA
+ 0.942ns 0.297576mA
+ 0.944ns 0.296274mA
+ 0.946ns 0.294978mA
+ 0.948ns 0.293687mA
+ 0.95ns 0.292402mA
+ 0.952ns 0.291122mA
+ 0.954ns 0.289848mA
+ 0.956ns 0.28858mA
+ 0.958ns 0.287317mA
+ 0.96ns 0.28606mA
+ 0.962ns 0.284808mA
+ 0.964ns 0.283562mA
+ 0.966ns 0.282321mA
+ 0.968ns 0.281086mA
+ 0.97ns 0.279856mA
+ 0.972ns 0.278631mA
+ 0.974ns 0.277412mA
+ 0.976ns 0.276198mA
+ 0.978ns 0.274989mA
+ 0.98ns 0.273786mA
+ 0.982ns 0.272588mA
+ 0.984ns 0.271395mA
+ 0.986ns 0.270208mA
+ 0.988ns 0.269025mA
+ 0.99ns 0.267848mA
+ 0.992ns 0.266676mA
+ 0.994ns 0.265509mA
+ 0.996ns 0.264347mA
+ 0.998ns 0.26319mA
+ 1ns 0.262039mA
+ 1.002ns 0.260892mA
+ 1.004ns 0.25975mA
+ 1.006ns 0.258614mA
+ 1.008ns 0.257482mA
+ 1.01ns 0.256355mA
+ 1.012ns 0.255234mA
+ 1.014ns 0.254117mA
+ 1.016ns 0.253005mA
+ 1.018ns 0.251898mA
+ 1.02ns 0.250795mA
+ 1.022ns 0.249698mA
+ 1.024ns 0.248605mA
+ 1.026ns 0.247517mA
+ 1.028ns 0.246434mA
+ 1.03ns 0.245356mA
+ 1.032ns 0.244282mA
+ 1.034ns 0.243213mA
+ 1.036ns 0.242149mA
+ 1.038ns 0.241089mA
+ 1.04ns 0.240034mA
+ 1.042ns 0.238984mA
+ 1.044ns 0.237938mA
+ 1.046ns 0.236897mA
+ 1.048ns 0.23586mA
+ 1.05ns 0mA
I211 401 0 PWL 0 0
+ 5.14ns 0mA
+ 5.142ns 0.000663272mA
+ 5.144ns 0.00521782mA
+ 5.146ns 0.00977237mA
+ 5.148ns 0.014328mA
+ 5.15ns 0.0188825mA
+ 5.152ns 0.0234371mA
+ 5.154ns 0.0279927mA
+ 5.156ns 0.0325473mA
+ 5.158ns 0.0371018mA
+ 5.16ns 0.0416564mA
+ 5.162ns 0.046212mA
+ 5.164ns 0.0507666mA
+ 5.166ns 0.0553211mA
+ 5.168ns 0.0598767mA
+ 5.17ns 0.0644313mA
+ 5.172ns 0.0689858mA
+ 5.174ns 0.0735415mA
+ 5.176ns 0.078096mA
+ 5.178ns 0.0826506mA
+ 5.18ns 0.0872051mA
+ 5.182ns 0.0917607mA
+ 5.184ns 0.0963153mA
+ 5.186ns 0.10087mA
+ 5.188ns 0.105425mA
+ 5.19ns 0.10998mA
+ 5.192ns 0.114535mA
+ 5.194ns 0.11909mA
+ 5.196ns 0.120152mA
+ 5.198ns 0.117009mA
+ 5.2ns 0.113947mA
+ 5.202ns 0.110966mA
+ 5.204ns 0.108062mA
+ 5.206ns 0.105235mA
+ 5.208ns 0.102481mA
+ 5.21ns 0.0998002mA
+ 5.212ns 0.0971892mA
+ 5.214ns 0.0946458mA
+ 5.216ns 0.0921696mA
+ 5.218ns 0.0897581mA
+ 5.22ns 0.0874091mA
+ 5.222ns 0.0851222mA
+ 5.224ns 0.0828951mA
+ 5.226ns 0.0807262mA
+ 5.228ns 0.0786135mA
+ 5.23ns 0.0765567mA
+ 5.232ns 0.0745536mA
+ 5.234ns 0.0726025mA
+ 5.236ns 0.0707028mA
+ 5.238ns 0.0688529mA
+ 5.24ns 0.0670509mA
+ 5.242ns 0.0652965mA
+ 5.244ns 0.0635879mA
+ 5.246ns 0.0619237mA
+ 5.248ns 0.0603034mA
+ 5.25ns 0.0587255mA
+ 5.252ns 0.0571889mA
+ 5.254ns 0.0556921mA
+ 5.256ns 0.0542348mA
+ 5.258ns 0.0528157mA
+ 5.26ns 0.0514333mA
+ 5.262ns 0.0500875mA
+ 5.264ns 0.0487768mA
+ 5.266ns 0.0475002mA
+ 5.268ns 0.0462572mA
+ 5.27ns 0.0450467mA
+ 5.272ns 0.043868mA
+ 5.274ns 0.0427198mA
+ 5.276ns 0mA
I212 402 0 PWL 0 0
+ 0.14ns 0mA
+ 0.142ns 0.00348381mA
+ 0.144ns 0.00802981mA
+ 0.146ns 0.0125758mA
+ 0.148ns 0.0171218mA
+ 0.15ns 0.0216678mA
+ 0.152ns 0.0262138mA
+ 0.154ns 0.0307598mA
+ 0.156ns 0.0353058mA
+ 0.158ns 0.0398518mA
+ 0.16ns 0.0443978mA
+ 0.162ns 0.0489437mA
+ 0.164ns 0.0534897mA
+ 0.166ns 0.0580357mA
+ 0.168ns 0.0625817mA
+ 0.17ns 0.0671277mA
+ 0.172ns 0.0716737mA
+ 0.174ns 0.0762197mA
+ 0.176ns 0.0807657mA
+ 0.178ns 0.0853117mA
+ 0.18ns 0.0898577mA
+ 0.182ns 0.0944037mA
+ 0.184ns 0.0989497mA
+ 0.186ns 0.103496mA
+ 0.188ns 0.108042mA
+ 0.19ns 0.112588mA
+ 0.192ns 0.117134mA
+ 0.194ns 0.11738mA
+ 0.196ns 0.114178mA
+ 0.198ns 0.111063mA
+ 0.2ns 0.108034mA
+ 0.202ns 0.105087mA
+ 0.204ns 0.10222mA
+ 0.206ns 0.0994314mA
+ 0.208ns 0.0967189mA
+ 0.21ns 0.0940804mA
+ 0.212ns 0.0915138mA
+ 0.214ns 0.0890173mA
+ 0.216ns 0.0865888mA
+ 0.218ns 0.0842266mA
+ 0.22ns 0.0819288mA
+ 0.222ns 0.0796937mA
+ 0.224ns 0.0775196mA
+ 0.226ns 0.0754047mA
+ 0.228ns 0.0733475mA
+ 0.23ns 0.0713465mA
+ 0.232ns 0.0694mA
+ 0.234ns 0.0675066mA
+ 0.236ns 0.0656648mA
+ 0.238ns 0.0638733mA
+ 0.24ns 0.0621307mA
+ 0.242ns 0.0604356mA
+ 0.244ns 0.0587867mA
+ 0.246ns 0.0571828mA
+ 0.248ns 0.0556226mA
+ 0.25ns 0.054105mA
+ 0.252ns 0.0526288mA
+ 0.254ns 0.0511929mA
+ 0.256ns 0.0497961mA
+ 0.258ns 0.0484375mA
+ 0.26ns 0.0471159mA
+ 0.262ns 0.0458303mA
+ 0.264ns 0.0445798mA
+ 0.266ns 0.0433635mA
+ 0.268ns 0.0421803mA
+ 0.27ns 0mA
I213 403 0 PWL 0 0
+ 5.154ns 0mA
+ 5.156ns 0.00628412mA
+ 5.158ns 0.0151229mA
+ 5.16ns 0.0239616mA
+ 5.162ns 0.0328025mA
+ 5.164ns 0.0416413mA
+ 5.166ns 0.05048mA
+ 5.168ns 0.0593209mA
+ 5.17ns 0.0681596mA
+ 5.172ns 0.0769984mA
+ 5.174ns 0.0858393mA
+ 5.176ns 0.094678mA
+ 5.178ns 0.103517mA
+ 5.18ns 0.112356mA
+ 5.182ns 0.121196mA
+ 5.184ns 0.130035mA
+ 5.186ns 0.138874mA
+ 5.188ns 0.147715mA
+ 5.19ns 0.153396mA
+ 5.192ns 0.141753mA
+ 5.194ns 0.130991mA
+ 5.196ns 0.121048mA
+ 5.198ns 0.111859mA
+ 5.2ns 0.103366mA
+ 5.202ns 0.0955197mA
+ 5.204ns 0.0882687mA
+ 5.206ns 0.0815679mA
+ 5.208ns 0.0753743mA
+ 5.21ns 0.0696522mA
+ 5.212ns 0.0643644mA
+ 5.214ns 0.0594769mA
+ 5.216ns 0.0549614mA
+ 5.218ns 0.0507886mA
+ 5.22ns 0.0469317mA
+ 5.222ns 0.0433685mA
+ 5.224ns 0.0400757mA
+ 5.226ns 0mA
I214 404 0 PWL 0 0
+ 5.57ns 0mA
+ 5.572ns 0.000659665mA
+ 5.574ns 0.00968391mA
+ 5.576ns 0.0187103mA
+ 5.578ns 0.0277346mA
+ 5.58ns 0.0367588mA
+ 5.582ns 0.0457852mA
+ 5.584ns 0.0548094mA
+ 5.586ns 0.0638337mA
+ 5.588ns 0.0717794mA
+ 5.59ns 0.0603895mA
+ 5.592ns 0.0508065mA
+ 5.594ns 0.0427439mA
+ 5.596ns 0.035959mA
+ 5.598ns 0.0302522mA
+ 5.6ns 0.0254508mA
+ 5.602ns 0.0214105mA
+ 5.604ns 0mA
I215 406 0 PWL 0 0
+ 7.65ns 0mA
+ 7.652ns 0.00419754mA
+ 7.654ns 0.0148233mA
+ 7.656ns 0.0254466mA
+ 7.658ns 0.0360699mA
+ 7.66ns 0.0466932mA
+ 7.662ns 0.057319mA
+ 7.664ns 0.0679422mA
+ 7.666ns 0.0785655mA
+ 7.668ns 0.0891913mA
+ 7.67ns 0.0960313mA
+ 7.672ns 0.0826595mA
+ 7.674ns 0.0711468mA
+ 7.676ns 0.0612393mA
+ 7.678ns 0.0527113mA
+ 7.68ns 0.0453689mA
+ 7.682ns 0.0390505mA
+ 7.684ns 0.0336119mA
+ 7.686ns 0.0289305mA
+ 7.688ns 0.0249001mA
+ 7.69ns 0mA
I216 407 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00427238mA
+ 5.156ns 0.0151797mA
+ 5.158ns 0.026087mA
+ 5.16ns 0.0369944mA
+ 5.162ns 0.0479043mA
+ 5.164ns 0.0588116mA
+ 5.166ns 0.0697189mA
+ 5.168ns 0.0806289mA
+ 5.17ns 0.0915362mA
+ 5.172ns 0.102444mA
+ 5.174ns 0.113353mA
+ 5.176ns 0.124261mA
+ 5.178ns 0.124892mA
+ 5.18ns 0.111258mA
+ 5.182ns 0.0991087mA
+ 5.184ns 0.0882884mA
+ 5.186ns 0.0786492mA
+ 5.188ns 0.0700602mA
+ 5.19ns 0.0624108mA
+ 5.192ns 0.0555963mA
+ 5.194ns 0.0495244mA
+ 5.196ns 0.0441166mA
+ 5.198ns 0.0392993mA
+ 5.2ns 0.0350069mA
+ 5.202ns 0mA
I217 408 0 PWL 0 0
+ 2.756ns 0mA
+ 2.758ns 0.000692282mA
+ 2.76ns 0.00312441mA
+ 2.762ns 0.00555683mA
+ 2.764ns 0.00798896mA
+ 2.766ns 0.0104214mA
+ 2.768ns 0.0128538mA
+ 2.77ns 0.0152859mA
+ 2.772ns 0.0177184mA
+ 2.774ns 0.0201505mA
+ 2.776ns 0.0225829mA
+ 2.778ns 0.0250153mA
+ 2.78ns 0.0274475mA
+ 2.782ns 0.0298799mA
+ 2.784ns 0.032312mA
+ 2.786ns 0.0347444mA
+ 2.788ns 0.0371768mA
+ 2.79ns 0.039609mA
+ 2.792ns 0.0420414mA
+ 2.794ns 0.0416037mA
+ 2.796ns 0.038484mA
+ 2.798ns 0.0355979mA
+ 2.8ns 0.0329285mA
+ 2.802ns 0.030459mA
+ 2.804ns 0.0281746mA
+ 2.806ns 0.0260617mA
+ 2.808ns 0.024107mA
+ 2.81ns 0.0222991mA
+ 2.812ns 0.0206266mA
+ 2.814ns 0.0190795mA
+ 2.816ns 0.0176485mA
+ 2.818ns 0.0163248mA
+ 2.82ns 0.0151004mA
+ 2.822ns 0.0139677mA
+ 2.824ns 0.0129199mA
+ 2.826ns 0.0119509mA
+ 2.828ns 0.0110544mA
+ 2.83ns 0mA
I218 410 0 PWL 0 0
+ 2.652ns 0mA
+ 2.654ns 0.00272119mA
+ 2.656ns 0.0136623mA
+ 2.658ns 0.0246022mA
+ 2.66ns 0.0355434mA
+ 2.662ns 0.0464832mA
+ 2.664ns 0.0574244mA
+ 2.666ns 0.0683655mA
+ 2.668ns 0.0793054mA
+ 2.67ns 0.0902466mA
+ 2.672ns 0.101186mA
+ 2.674ns 0.112128mA
+ 2.676ns 0.123069mA
+ 2.678ns 0.134009mA
+ 2.68ns 0.12335mA
+ 2.682ns 0.110302mA
+ 2.684ns 0.098632mA
+ 2.686ns 0.0881967mA
+ 2.688ns 0.0788664mA
+ 2.69ns 0.0705219mA
+ 2.692ns 0.0630601mA
+ 2.694ns 0.0563884mA
+ 2.696ns 0.0504218mA
+ 2.698ns 0.0450869mA
+ 2.7ns 0.0403159mA
+ 2.702ns 0.0360496mA
+ 2.704ns 0mA
I219 412 0 PWL 0 0
+ 0.136ns 0mA
+ 0.138ns 0.00359998mA
+ 0.14ns 0.00830734mA
+ 0.142ns 0.0130147mA
+ 0.144ns 0.0177221mA
+ 0.146ns 0.0224295mA
+ 0.148ns 0.0271369mA
+ 0.15ns 0.0318442mA
+ 0.152ns 0.0365516mA
+ 0.154ns 0.041259mA
+ 0.156ns 0.0459664mA
+ 0.158ns 0.0506738mA
+ 0.16ns 0.0553811mA
+ 0.162ns 0.0600885mA
+ 0.164ns 0.0647959mA
+ 0.166ns 0.0695033mA
+ 0.168ns 0.0742107mA
+ 0.17ns 0.078918mA
+ 0.172ns 0.0836254mA
+ 0.174ns 0.0883328mA
+ 0.176ns 0.0930402mA
+ 0.178ns 0.0977475mA
+ 0.18ns 0.102455mA
+ 0.182ns 0.102786mA
+ 0.184ns 0.0988579mA
+ 0.186ns 0.0950797mA
+ 0.188ns 0.0914458mA
+ 0.19ns 0.0879508mA
+ 0.192ns 0.0845893mA
+ 0.194ns 0.0813563mA
+ 0.196ns 0.0782468mA
+ 0.198ns 0.0752561mA
+ 0.2ns 0.0723797mA
+ 0.202ns 0.0696132mA
+ 0.204ns 0.0669525mA
+ 0.206ns 0.0643934mA
+ 0.208ns 0.0619321mA
+ 0.21ns 0.0595648mA
+ 0.212ns 0.0572881mA
+ 0.214ns 0.0550983mA
+ 0.216ns 0.0529922mA
+ 0.218ns 0.0509666mA
+ 0.22ns 0.0490184mA
+ 0.222ns 0.0471447mA
+ 0.224ns 0.0453425mA
+ 0.226ns 0.0436093mA
+ 0.228ns 0.0419422mA
+ 0.23ns 0.0403389mA
+ 0.232ns 0.0387969mA
+ 0.234ns 0.0373138mA
+ 0.236ns 0.0358873mA
+ 0.238ns 0.0345154mA
+ 0.24ns 0mA
+ 5.136ns 0mA
+ 5.138ns 0.00360055mA
+ 5.14ns 0.00830758mA
+ 5.142ns 0.0130157mA
+ 5.144ns 0.0177228mA
+ 5.146ns 0.0224298mA
+ 5.148ns 0.027138mA
+ 5.15ns 0.031845mA
+ 5.152ns 0.036552mA
+ 5.154ns 0.0412602mA
+ 5.156ns 0.0459672mA
+ 5.158ns 0.0506743mA
+ 5.16ns 0.0553813mA
+ 5.162ns 0.0600895mA
+ 5.164ns 0.0647965mA
+ 5.166ns 0.0695035mA
+ 5.168ns 0.0742117mA
+ 5.17ns 0.0789187mA
+ 5.172ns 0.0836258mA
+ 5.174ns 0.0883339mA
+ 5.176ns 0.093041mA
+ 5.178ns 0.097748mA
+ 5.18ns 0.102455mA
+ 5.182ns 0.102785mA
+ 5.184ns 0.0988574mA
+ 5.186ns 0.0950795mA
+ 5.188ns 0.091445mA
+ 5.19ns 0.0879503mA
+ 5.192ns 0.084589mA
+ 5.194ns 0.0813555mA
+ 5.196ns 0.0782463mA
+ 5.198ns 0.0752558mA
+ 5.2ns 0.072379mA
+ 5.202ns 0.0696127mA
+ 5.204ns 0.0669522mA
+ 5.206ns 0.0643933mA
+ 5.208ns 0.0619316mA
+ 5.21ns 0.0595645mA
+ 5.212ns 0.0572879mA
+ 5.214ns 0.0550978mA
+ 5.216ns 0.0529919mA
+ 5.218ns 0.0509664mA
+ 5.22ns 0.0490179mA
+ 5.222ns 0.0471443mA
+ 5.224ns 0.0453423mA
+ 5.226ns 0.0436092mA
+ 5.228ns 0.0419419mA
+ 5.23ns 0.0403387mA
+ 5.232ns 0.0387968mA
+ 5.234ns 0.0373135mA
+ 5.236ns 0.0358871mA
+ 5.238ns 0.0345153mA
+ 5.24ns 0mA
I220 413 0 PWL 0 0
+ 3.004ns 0mA
+ 3.006ns 0.000296638mA
+ 3.008ns 0.0075254mA
+ 3.01ns 0.0147533mA
+ 3.012ns 0.0219821mA
+ 3.014ns 0.0292099mA
+ 3.016ns 0.0364387mA
+ 3.018ns 0.0436675mA
+ 3.02ns 0.0508954mA
+ 3.022ns 0.0581241mA
+ 3.024ns 0.0653529mA
+ 3.026ns 0.0725808mA
+ 3.028ns 0.0798095mA
+ 3.03ns 0.0870374mA
+ 3.032ns 0.0942662mA
+ 3.034ns 0.101495mA
+ 3.036ns 0.108723mA
+ 3.038ns 0.115952mA
+ 3.04ns 0.123179mA
+ 3.042ns 0.130408mA
+ 3.044ns 0.137637mA
+ 3.046ns 0.144865mA
+ 3.048ns 0.152094mA
+ 3.05ns 0.159322mA
+ 3.052ns 0.16655mA
+ 3.054ns 0.173779mA
+ 3.056ns 0.181007mA
+ 3.058ns 0.188236mA
+ 3.06ns 0.195464mA
+ 3.062ns 0.202692mA
+ 3.064ns 0.209921mA
+ 3.066ns 0.217149mA
+ 3.068ns 0.224378mA
+ 3.07ns 0.231606mA
+ 3.072ns 0.238834mA
+ 3.074ns 0.246063mA
+ 3.076ns 0.253291mA
+ 3.078ns 0.26052mA
+ 3.08ns 0.267749mA
+ 3.082ns 0.274977mA
+ 3.084ns 0.282205mA
+ 3.086ns 0.289433mA
+ 3.088ns 0.296662mA
+ 3.09ns 0.303891mA
+ 3.092ns 0.311119mA
+ 3.094ns 0.318347mA
+ 3.096ns 0.325575mA
+ 3.098ns 0.332804mA
+ 3.1ns 0.340033mA
+ 3.102ns 0.347261mA
+ 3.104ns 0.354489mA
+ 3.106ns 0.361717mA
+ 3.108ns 0.368946mA
+ 3.11ns 0.376175mA
+ 3.112ns 0.383403mA
+ 3.114ns 0.390631mA
+ 3.116ns 0.397859mA
+ 3.118ns 0.405088mA
+ 3.12ns 0.412317mA
+ 3.122ns 0.419545mA
+ 3.124ns 0.426774mA
+ 3.126ns 0.434002mA
+ 3.128ns 0.44123mA
+ 3.13ns 0.448459mA
+ 3.132ns 0.455687mA
+ 3.134ns 0.462916mA
+ 3.136ns 0.470144mA
+ 3.138ns 0.477372mA
+ 3.14ns 0.484601mA
+ 3.142ns 0.491829mA
+ 3.144ns 0.499058mA
+ 3.146ns 0.506286mA
+ 3.148ns 0.513514mA
+ 3.15ns 0.520743mA
+ 3.152ns 0.527971mA
+ 3.154ns 0.5352mA
+ 3.156ns 0.540993mA
+ 3.158ns 0.538663mA
+ 3.16ns 0.536343mA
+ 3.162ns 0.534033mA
+ 3.164ns 0.531733mA
+ 3.166ns 0.529442mA
+ 3.168ns 0.527162mA
+ 3.17ns 0.524892mA
+ 3.172ns 0.522631mA
+ 3.174ns 0.52038mA
+ 3.176ns 0.518138mA
+ 3.178ns 0.515907mA
+ 3.18ns 0.513685mA
+ 3.182ns 0.511472mA
+ 3.184ns 0.509269mA
+ 3.186ns 0.507076mA
+ 3.188ns 0.504892mA
+ 3.19ns 0.502717mA
+ 3.192ns 0.500552mA
+ 3.194ns 0.498396mA
+ 3.196ns 0.496249mA
+ 3.198ns 0.494112mA
+ 3.2ns 0.491983mA
+ 3.202ns 0.489864mA
+ 3.204ns 0.487754mA
+ 3.206ns 0.485653mA
+ 3.208ns 0.483562mA
+ 3.21ns 0.481479mA
+ 3.212ns 0.479405mA
+ 3.214ns 0.47734mA
+ 3.216ns 0.475284mA
+ 3.218ns 0.473237mA
+ 3.22ns 0.471199mA
+ 3.222ns 0.469169mA
+ 3.224ns 0.467148mA
+ 3.226ns 0.465136mA
+ 3.228ns 0.463133mA
+ 3.23ns 0.461138mA
+ 3.232ns 0.459152mA
+ 3.234ns 0.457174mA
+ 3.236ns 0.455205mA
+ 3.238ns 0.453244mA
+ 3.24ns 0.451292mA
+ 3.242ns 0.449348mA
+ 3.244ns 0.447413mA
+ 3.246ns 0.445485mA
+ 3.248ns 0.443566mA
+ 3.25ns 0.441656mA
+ 3.252ns 0.439754mA
+ 3.254ns 0.43786mA
+ 3.256ns 0.435973mA
+ 3.258ns 0.434095mA
+ 3.26ns 0.432226mA
+ 3.262ns 0.430364mA
+ 3.264ns 0.42851mA
+ 3.266ns 0.426665mA
+ 3.268ns 0.424827mA
+ 3.27ns 0.422997mA
+ 3.272ns 0.421175mA
+ 3.274ns 0.419361mA
+ 3.276ns 0.417554mA
+ 3.278ns 0.415756mA
+ 3.28ns 0.413965mA
+ 3.282ns 0.412182mA
+ 3.284ns 0.410406mA
+ 3.286ns 0.408639mA
+ 3.288ns 0.406879mA
+ 3.29ns 0.405126mA
+ 3.292ns 0.403381mA
+ 3.294ns 0.401643mA
+ 3.296ns 0.399913mA
+ 3.298ns 0.398191mA
+ 3.3ns 0.396476mA
+ 3.302ns 0.394768mA
+ 3.304ns 0.393067mA
+ 3.306ns 0.391374mA
+ 3.308ns 0.389688mA
+ 3.31ns 0.38801mA
+ 3.312ns 0.386339mA
+ 3.314ns 0.384674mA
+ 3.316ns 0.383018mA
+ 3.318ns 0.381368mA
+ 3.32ns 0.379725mA
+ 3.322ns 0.378089mA
+ 3.324ns 0.376461mA
+ 3.326ns 0.374839mA
+ 3.328ns 0.373224mA
+ 3.33ns 0.371617mA
+ 3.332ns 0.370016mA
+ 3.334ns 0.368422mA
+ 3.336ns 0.366835mA
+ 3.338ns 0.365255mA
+ 3.34ns 0.363682mA
+ 3.342ns 0.362115mA
+ 3.344ns 0.360555mA
+ 3.346ns 0.359002mA
+ 3.348ns 0.357456mA
+ 3.35ns 0.355916mA
+ 3.352ns 0.354383mA
+ 3.354ns 0.352856mA
+ 3.356ns 0.351337mA
+ 3.358ns 0.349823mA
+ 3.36ns 0.348316mA
+ 3.362ns 0.346816mA
+ 3.364ns 0.345322mA
+ 3.366ns 0.343834mA
+ 3.368ns 0.342353mA
+ 3.37ns 0.340879mA
+ 3.372ns 0.33941mA
+ 3.374ns 0.337948mA
+ 3.376ns 0.336492mA
+ 3.378ns 0.335043mA
+ 3.38ns 0.3336mA
+ 3.382ns 0.332163mA
+ 3.384ns 0.330732mA
+ 3.386ns 0.329307mA
+ 3.388ns 0.327889mA
+ 3.39ns 0.326476mA
+ 3.392ns 0.32507mA
+ 3.394ns 0.32367mA
+ 3.396ns 0.322275mA
+ 3.398ns 0.320887mA
+ 3.4ns 0.319505mA
+ 3.402ns 0.318129mA
+ 3.404ns 0.316758mA
+ 3.406ns 0.315394mA
+ 3.408ns 0.314035mA
+ 3.41ns 0.312682mA
+ 3.412ns 0.311335mA
+ 3.414ns 0.309994mA
+ 3.416ns 0.308659mA
+ 3.418ns 0.307329mA
+ 3.42ns 0.306006mA
+ 3.422ns 0.304687mA
+ 3.424ns 0.303375mA
+ 3.426ns 0.302068mA
+ 3.428ns 0.300767mA
+ 3.43ns 0.299471mA
+ 3.432ns 0.298181mA
+ 3.434ns 0.296897mA
+ 3.436ns 0.295618mA
+ 3.438ns 0.294344mA
+ 3.44ns 0.293076mA
+ 3.442ns 0.291814mA
+ 3.444ns 0.290557mA
+ 3.446ns 0.289305mA
+ 3.448ns 0.288059mA
+ 3.45ns 0.286818mA
+ 3.452ns 0.285582mA
+ 3.454ns 0.284352mA
+ 3.456ns 0.283127mA
+ 3.458ns 0.281908mA
+ 3.46ns 0.280693mA
+ 3.462ns 0.279484mA
+ 3.464ns 0.27828mA
+ 3.466ns 0.277081mA
+ 3.468ns 0.275888mA
+ 3.47ns 0.274699mA
+ 3.472ns 0.273516mA
+ 3.474ns 0.272338mA
+ 3.476ns 0.271164mA
+ 3.478ns 0.269996mA
+ 3.48ns 0.268833mA
+ 3.482ns 0.267675mA
+ 3.484ns 0.266522mA
+ 3.486ns 0.265374mA
+ 3.488ns 0.264231mA
+ 3.49ns 0.263092mA
+ 3.492ns 0.261959mA
+ 3.494ns 0.260831mA
+ 3.496ns 0.259707mA
+ 3.498ns 0.258588mA
+ 3.5ns 0.257474mA
+ 3.502ns 0.256365mA
+ 3.504ns 0.255261mA
+ 3.506ns 0.254161mA
+ 3.508ns 0.253066mA
+ 3.51ns 0.251976mA
+ 3.512ns 0.25089mA
+ 3.514ns 0.24981mA
+ 3.516ns 0.248734mA
+ 3.518ns 0.247662mA
+ 3.52ns 0.246595mA
+ 3.522ns 0.245533mA
+ 3.524ns 0.244475mA
+ 3.526ns 0.243422mA
+ 3.528ns 0.242373mA
+ 3.53ns 0.241329mA
+ 3.532ns 0.240289mA
+ 3.534ns 0.239254mA
+ 3.536ns 0.238224mA
+ 3.538ns 0.237197mA
+ 3.54ns 0.236176mA
+ 3.542ns 0.235158mA
+ 3.544ns 0.234145mA
+ 3.546ns 0.233136mA
+ 3.548ns 0.232132mA
+ 3.55ns 0.231132mA
+ 3.552ns 0mA
I221 416 0 PWL 0 0
+ 5.52ns 0mA
+ 5.522ns 0.000616864mA
+ 5.524ns 0.0083675mA
+ 5.526ns 0.0161163mA
+ 5.528ns 0.0238651mA
+ 5.53ns 0.0316157mA
+ 5.532ns 0.0393645mA
+ 5.534ns 0.0471133mA
+ 5.536ns 0.0548639mA
+ 5.538ns 0.0626127mA
+ 5.54ns 0.0703615mA
+ 5.542ns 0.0781122mA
+ 5.544ns 0.0858609mA
+ 5.546ns 0.0936097mA
+ 5.548ns 0.101359mA
+ 5.55ns 0.109109mA
+ 5.552ns 0.116858mA
+ 5.554ns 0.124607mA
+ 5.556ns 0.132357mA
+ 5.558ns 0.140106mA
+ 5.56ns 0.147855mA
+ 5.562ns 0.155606mA
+ 5.564ns 0.163354mA
+ 5.566ns 0.171103mA
+ 5.568ns 0.178852mA
+ 5.57ns 0.186603mA
+ 5.572ns 0.194351mA
+ 5.574ns 0.2021mA
+ 5.576ns 0.209851mA
+ 5.578ns 0.2176mA
+ 5.58ns 0.225348mA
+ 5.582ns 0.233099mA
+ 5.584ns 0.240848mA
+ 5.586ns 0.248597mA
+ 5.588ns 0.256347mA
+ 5.59ns 0.264096mA
+ 5.592ns 0.271845mA
+ 5.594ns 0.279594mA
+ 5.596ns 0.287344mA
+ 5.598ns 0.295093mA
+ 5.6ns 0.302842mA
+ 5.602ns 0.310593mA
+ 5.604ns 0.318341mA
+ 5.606ns 0.32609mA
+ 5.608ns 0.333841mA
+ 5.61ns 0.34159mA
+ 5.612ns 0.349338mA
+ 5.614ns 0.357087mA
+ 5.616ns 0.364838mA
+ 5.618ns 0.372587mA
+ 5.62ns 0.380335mA
+ 5.622ns 0.388086mA
+ 5.624ns 0.395835mA
+ 5.626ns 0.403584mA
+ 5.628ns 0.411334mA
+ 5.63ns 0.419083mA
+ 5.632ns 0.426832mA
+ 5.634ns 0.434582mA
+ 5.636ns 0.442331mA
+ 5.638ns 0.45008mA
+ 5.64ns 0.457829mA
+ 5.642ns 0.465579mA
+ 5.644ns 0.473328mA
+ 5.646ns 0.481077mA
+ 5.648ns 0.488828mA
+ 5.65ns 0.496576mA
+ 5.652ns 0.504325mA
+ 5.654ns 0.512076mA
+ 5.656ns 0.519825mA
+ 5.658ns 0.527573mA
+ 5.66ns 0.535322mA
+ 5.662ns 0.543073mA
+ 5.664ns 0.543756mA
+ 5.666ns 0.541419mA
+ 5.668ns 0.539092mA
+ 5.67ns 0.536776mA
+ 5.672ns 0.534469mA
+ 5.674ns 0.532172mA
+ 5.676ns 0.529886mA
+ 5.678ns 0.527609mA
+ 5.68ns 0.525341mA
+ 5.682ns 0.523084mA
+ 5.684ns 0.520836mA
+ 5.686ns 0.518598mA
+ 5.688ns 0.51637mA
+ 5.69ns 0.514151mA
+ 5.692ns 0.511942mA
+ 5.694ns 0.509741mA
+ 5.696ns 0.507551mA
+ 5.698ns 0.50537mA
+ 5.7ns 0.503198mA
+ 5.702ns 0.501036mA
+ 5.704ns 0.498883mA
+ 5.706ns 0.496739mA
+ 5.708ns 0.494604mA
+ 5.71ns 0.492479mA
+ 5.712ns 0.490363mA
+ 5.714ns 0.488255mA
+ 5.716ns 0.486157mA
+ 5.718ns 0.484068mA
+ 5.72ns 0.481988mA
+ 5.722ns 0.479917mA
+ 5.724ns 0.477855mA
+ 5.726ns 0.475801mA
+ 5.728ns 0.473756mA
+ 5.73ns 0.471721mA
+ 5.732ns 0.469694mA
+ 5.734ns 0.467675mA
+ 5.736ns 0.465665mA
+ 5.738ns 0.463665mA
+ 5.74ns 0.461672mA
+ 5.742ns 0.459688mA
+ 5.744ns 0.457713mA
+ 5.746ns 0.455745mA
+ 5.748ns 0.453787mA
+ 5.75ns 0.451837mA
+ 5.752ns 0.449896mA
+ 5.754ns 0.447962mA
+ 5.756ns 0.446037mA
+ 5.758ns 0.44412mA
+ 5.76ns 0.442212mA
+ 5.762ns 0.440311mA
+ 5.764ns 0.438419mA
+ 5.766ns 0.436535mA
+ 5.768ns 0.434659mA
+ 5.77ns 0.432792mA
+ 5.772ns 0.430931mA
+ 5.774ns 0.42908mA
+ 5.776ns 0.427236mA
+ 5.778ns 0.4254mA
+ 5.78ns 0.423572mA
+ 5.782ns 0.421751mA
+ 5.784ns 0.419939mA
+ 5.786ns 0.418134mA
+ 5.788ns 0.416337mA
+ 5.79ns 0.414548mA
+ 5.792ns 0.412767mA
+ 5.794ns 0.410993mA
+ 5.796ns 0.409227mA
+ 5.798ns 0.407468mA
+ 5.8ns 0.405717mA
+ 5.802ns 0.403974mA
+ 5.804ns 0.402238mA
+ 5.806ns 0.400509mA
+ 5.808ns 0.398788mA
+ 5.81ns 0.397074mA
+ 5.812ns 0.395368mA
+ 5.814ns 0.393669mA
+ 5.816ns 0.391977mA
+ 5.818ns 0.390292mA
+ 5.82ns 0.388615mA
+ 5.822ns 0.386945mA
+ 5.824ns 0.385282mA
+ 5.826ns 0.383626mA
+ 5.828ns 0.381978mA
+ 5.83ns 0.380336mA
+ 5.832ns 0.378702mA
+ 5.834ns 0.377074mA
+ 5.836ns 0.375454mA
+ 5.838ns 0.37384mA
+ 5.84ns 0.372234mA
+ 5.842ns 0.370634mA
+ 5.844ns 0.369041mA
+ 5.846ns 0.367455mA
+ 5.848ns 0.365876mA
+ 5.85ns 0.364304mA
+ 5.852ns 0.362738mA
+ 5.854ns 0.361179mA
+ 5.856ns 0.359627mA
+ 5.858ns 0.358081mA
+ 5.86ns 0.356543mA
+ 5.862ns 0.355011mA
+ 5.864ns 0.353485mA
+ 5.866ns 0.351966mA
+ 5.868ns 0.350453mA
+ 5.87ns 0.348947mA
+ 5.872ns 0.347447mA
+ 5.874ns 0.345954mA
+ 5.876ns 0.344467mA
+ 5.878ns 0.342987mA
+ 5.88ns 0.341513mA
+ 5.882ns 0.340045mA
+ 5.884ns 0.338584mA
+ 5.886ns 0.337129mA
+ 5.888ns 0.33568mA
+ 5.89ns 0.334237mA
+ 5.892ns 0.332801mA
+ 5.894ns 0.331371mA
+ 5.896ns 0.329947mA
+ 5.898ns 0.328528mA
+ 5.9ns 0.327117mA
+ 5.902ns 0.325711mA
+ 5.904ns 0.324311mA
+ 5.906ns 0.322917mA
+ 5.908ns 0.32153mA
+ 5.91ns 0.320147mA
+ 5.912ns 0.318772mA
+ 5.914ns 0.317402mA
+ 5.916ns 0.316038mA
+ 5.918ns 0.314679mA
+ 5.92ns 0.313327mA
+ 5.922ns 0.311981mA
+ 5.924ns 0.31064mA
+ 5.926ns 0.309305mA
+ 5.928ns 0.307975mA
+ 5.93ns 0.306652mA
+ 5.932ns 0.305334mA
+ 5.934ns 0.304022mA
+ 5.936ns 0.302715mA
+ 5.938ns 0.301414mA
+ 5.94ns 0.300119mA
+ 5.942ns 0.298829mA
+ 5.944ns 0.297544mA
+ 5.946ns 0.296266mA
+ 5.948ns 0.294993mA
+ 5.95ns 0.293725mA
+ 5.952ns 0.292462mA
+ 5.954ns 0.291205mA
+ 5.956ns 0.289954mA
+ 5.958ns 0.288708mA
+ 5.96ns 0.287467mA
+ 5.962ns 0.286232mA
+ 5.964ns 0.285001mA
+ 5.966ns 0.283776mA
+ 5.968ns 0.282557mA
+ 5.97ns 0.281342mA
+ 5.972ns 0.280133mA
+ 5.974ns 0.278929mA
+ 5.976ns 0.27773mA
+ 5.978ns 0.276537mA
+ 5.98ns 0.275348mA
+ 5.982ns 0.274165mA
+ 5.984ns 0.272987mA
+ 5.986ns 0.271813mA
+ 5.988ns 0.270645mA
+ 5.99ns 0.269482mA
+ 5.992ns 0.268324mA
+ 5.994ns 0.267171mA
+ 5.996ns 0.266022mA
+ 5.998ns 0.264879mA
+ 6ns 0.263741mA
+ 6.002ns 0.262607mA
+ 6.004ns 0.261478mA
+ 6.006ns 0.260355mA
+ 6.008ns 0.259236mA
+ 6.01ns 0.258121mA
+ 6.012ns 0.257012mA
+ 6.014ns 0.255908mA
+ 6.016ns 0.254808mA
+ 6.018ns 0.253713mA
+ 6.02ns 0.252622mA
+ 6.022ns 0.251536mA
+ 6.024ns 0.250455mA
+ 6.026ns 0.249379mA
+ 6.028ns 0.248307mA
+ 6.03ns 0.24724mA
+ 6.032ns 0.246177mA
+ 6.034ns 0.245119mA
+ 6.036ns 0.244066mA
+ 6.038ns 0.243017mA
+ 6.04ns 0.241972mA
+ 6.042ns 0.240932mA
+ 6.044ns 0.239897mA
+ 6.046ns 0.238866mA
+ 6.048ns 0.237839mA
+ 6.05ns 0.236817mA
+ 6.052ns 0.235799mA
+ 6.054ns 0.234786mA
+ 6.056ns 0mA
I222 417 0 PWL 0 0
+ 0.152ns 0mA
+ 0.154ns 0.00997112mA
+ 0.156ns 0.0216282mA
+ 0.158ns 0.0332854mA
+ 0.16ns 0.0449426mA
+ 0.162ns 0.0565997mA
+ 0.164ns 0.0682569mA
+ 0.166ns 0.0799141mA
+ 0.168ns 0.0915713mA
+ 0.17ns 0.103228mA
+ 0.172ns 0.0946887mA
+ 0.174ns 0.0813155mA
+ 0.176ns 0.0698306mA
+ 0.178ns 0.0599676mA
+ 0.18ns 0.0514973mA
+ 0.182ns 0.0442232mA
+ 0.184ns 0.0379763mA
+ 0.186ns 0.0326118mA
+ 0.188ns 0.0280048mA
+ 0.19ns 0mA
I223 424 0 PWL 0 0
+ 5.136ns 0mA
+ 5.138ns 0.00160728mA
+ 5.14ns 0.006065mA
+ 5.142ns 0.0105238mA
+ 5.144ns 0.0149815mA
+ 5.146ns 0.0194392mA
+ 5.148ns 0.023898mA
+ 5.15ns 0.0283557mA
+ 5.152ns 0.0328135mA
+ 5.154ns 0.0372723mA
+ 5.156ns 0.04173mA
+ 5.158ns 0.0461877mA
+ 5.16ns 0.0506454mA
+ 5.162ns 0.0551042mA
+ 5.164ns 0.0595619mA
+ 5.166ns 0.0640197mA
+ 5.168ns 0.0684785mA
+ 5.17ns 0.0729362mA
+ 5.172ns 0.0773939mA
+ 5.174ns 0.0818527mA
+ 5.176ns 0.0863104mA
+ 5.178ns 0.0907682mA
+ 5.18ns 0.0952259mA
+ 5.182ns 0.0996847mA
+ 5.184ns 0.104142mA
+ 5.186ns 0.1086mA
+ 5.188ns 0.113059mA
+ 5.19ns 0.113218mA
+ 5.192ns 0.109936mA
+ 5.194ns 0.106748mA
+ 5.196ns 0.103654mA
+ 5.198ns 0.100649mA
+ 5.2ns 0.0977303mA
+ 5.202ns 0.0948971mA
+ 5.204ns 0.0921461mA
+ 5.206ns 0.0894748mA
+ 5.208ns 0.0868803mA
+ 5.21ns 0.0843616mA
+ 5.212ns 0.0819159mA
+ 5.214ns 0.0795406mA
+ 5.216ns 0.0772346mA
+ 5.218ns 0.0749955mA
+ 5.22ns 0.0728208mA
+ 5.222ns 0.0707096mA
+ 5.224ns 0.0686596mA
+ 5.226ns 0.066669mA
+ 5.228ns 0.0647357mA
+ 5.23ns 0.0628589mA
+ 5.232ns 0.0610364mA
+ 5.234ns 0.0592664mA
+ 5.236ns 0.0575481mA
+ 5.238ns 0.0558796mA
+ 5.24ns 0.0542591mA
+ 5.242ns 0.0526859mA
+ 5.244ns 0.0511584mA
+ 5.246ns 0.0496747mA
+ 5.248ns 0.0482344mA
+ 5.25ns 0.0468359mA
+ 5.252ns 0.0454779mA
+ 5.254ns 0.044159mA
+ 5.256ns 0.0428786mA
+ 5.258ns 0.0416353mA
+ 5.26ns 0.0404278mA
+ 5.262ns 0mA
I224 425 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00491946mA
+ 5.156ns 0.0151657mA
+ 5.158ns 0.0254119mA
+ 5.16ns 0.0356582mA
+ 5.162ns 0.0459069mA
+ 5.164ns 0.0561531mA
+ 5.166ns 0.0663993mA
+ 5.168ns 0.076648mA
+ 5.17ns 0.0868943mA
+ 5.172ns 0.0971405mA
+ 5.174ns 0.107389mA
+ 5.176ns 0.117635mA
+ 5.178ns 0.127882mA
+ 5.18ns 0.133266mA
+ 5.182ns 0.120054mA
+ 5.184ns 0.108153mA
+ 5.186ns 0.0974324mA
+ 5.188ns 0.0877719mA
+ 5.19ns 0.0790709mA
+ 5.192ns 0.0712323mA
+ 5.194ns 0.064169mA
+ 5.196ns 0.0578074mA
+ 5.198ns 0.0520763mA
+ 5.2ns 0.0469121mA
+ 5.202ns 0.042261mA
+ 5.204ns 0.0380709mA
+ 5.206ns 0.0342961mA
+ 5.208ns 0mA
I225 427 0 PWL 0 0
+ 5.512ns 0mA
+ 5.514ns 0.00497724mA
+ 5.516ns 0.0126567mA
+ 5.518ns 0.0203344mA
+ 5.52ns 0.028012mA
+ 5.522ns 0.0356897mA
+ 5.524ns 0.0433691mA
+ 5.526ns 0.0510468mA
+ 5.528ns 0.0587244mA
+ 5.53ns 0.0664039mA
+ 5.532ns 0.0740815mA
+ 5.534ns 0.0817592mA
+ 5.536ns 0.0894387mA
+ 5.538ns 0.0971163mA
+ 5.54ns 0.104794mA
+ 5.542ns 0.112473mA
+ 5.544ns 0.120151mA
+ 5.546ns 0.127829mA
+ 5.548ns 0.135506mA
+ 5.55ns 0.143186mA
+ 5.552ns 0.150863mA
+ 5.554ns 0.158541mA
+ 5.556ns 0.166221mA
+ 5.558ns 0.173898mA
+ 5.56ns 0.181576mA
+ 5.562ns 0.189255mA
+ 5.564ns 0.196933mA
+ 5.566ns 0.204611mA
+ 5.568ns 0.212288mA
+ 5.57ns 0.219968mA
+ 5.572ns 0.227645mA
+ 5.574ns 0.235323mA
+ 5.576ns 0.243003mA
+ 5.578ns 0.25068mA
+ 5.58ns 0.258358mA
+ 5.582ns 0.266037mA
+ 5.584ns 0.273715mA
+ 5.586ns 0.281393mA
+ 5.588ns 0.289072mA
+ 5.59ns 0.29675mA
+ 5.592ns 0.304427mA
+ 5.594ns 0.312105mA
+ 5.596ns 0.319784mA
+ 5.598ns 0.327462mA
+ 5.6ns 0.33514mA
+ 5.602ns 0.342819mA
+ 5.604ns 0.350497mA
+ 5.606ns 0.358175mA
+ 5.608ns 0.365854mA
+ 5.61ns 0.373532mA
+ 5.612ns 0.381209mA
+ 5.614ns 0.388887mA
+ 5.616ns 0.396566mA
+ 5.618ns 0.404244mA
+ 5.62ns 0.411922mA
+ 5.622ns 0.419601mA
+ 5.624ns 0.427279mA
+ 5.626ns 0.434956mA
+ 5.628ns 0.442636mA
+ 5.63ns 0.450314mA
+ 5.632ns 0.457991mA
+ 5.634ns 0.465671mA
+ 5.636ns 0.473348mA
+ 5.638ns 0.481026mA
+ 5.64ns 0.488704mA
+ 5.642ns 0.496383mA
+ 5.644ns 0.504061mA
+ 5.646ns 0.511738mA
+ 5.648ns 0.519418mA
+ 5.65ns 0.527095mA
+ 5.652ns 0.534773mA
+ 5.654ns 0.542453mA
+ 5.656ns 0.55013mA
+ 5.658ns 0.549734mA
+ 5.66ns 0.547332mA
+ 5.662ns 0.544939mA
+ 5.664ns 0.542558mA
+ 5.666ns 0.540187mA
+ 5.668ns 0.537826mA
+ 5.67ns 0.535475mA
+ 5.672ns 0.533135mA
+ 5.674ns 0.530805mA
+ 5.676ns 0.528485mA
+ 5.678ns 0.526175mA
+ 5.68ns 0.523875mA
+ 5.682ns 0.521586mA
+ 5.684ns 0.519306mA
+ 5.686ns 0.517037mA
+ 5.688ns 0.514777mA
+ 5.69ns 0.512527mA
+ 5.692ns 0.510287mA
+ 5.694ns 0.508057mA
+ 5.696ns 0.505836mA
+ 5.698ns 0.503626mA
+ 5.7ns 0.501424mA
+ 5.702ns 0.499233mA
+ 5.704ns 0.497051mA
+ 5.706ns 0.494879mA
+ 5.708ns 0.492715mA
+ 5.71ns 0.490562mA
+ 5.712ns 0.488418mA
+ 5.714ns 0.486283mA
+ 5.716ns 0.484158mA
+ 5.718ns 0.482042mA
+ 5.72ns 0.479935mA
+ 5.722ns 0.477837mA
+ 5.724ns 0.475749mA
+ 5.726ns 0.473669mA
+ 5.728ns 0.471599mA
+ 5.73ns 0.469538mA
+ 5.732ns 0.467486mA
+ 5.734ns 0.465443mA
+ 5.736ns 0.463409mA
+ 5.738ns 0.461383mA
+ 5.74ns 0.459366mA
+ 5.742ns 0.457359mA
+ 5.744ns 0.45536mA
+ 5.746ns 0.453369mA
+ 5.748ns 0.451388mA
+ 5.75ns 0.449415mA
+ 5.752ns 0.447451mA
+ 5.754ns 0.445495mA
+ 5.756ns 0.443548mA
+ 5.758ns 0.44161mA
+ 5.76ns 0.439679mA
+ 5.762ns 0.437758mA
+ 5.764ns 0.435844mA
+ 5.766ns 0.433939mA
+ 5.768ns 0.432043mA
+ 5.77ns 0.430155mA
+ 5.772ns 0.428274mA
+ 5.774ns 0.426402mA
+ 5.776ns 0.424539mA
+ 5.778ns 0.422683mA
+ 5.78ns 0.420836mA
+ 5.782ns 0.418996mA
+ 5.784ns 0.417165mA
+ 5.786ns 0.415341mA
+ 5.788ns 0.413526mA
+ 5.79ns 0.411719mA
+ 5.792ns 0.409919mA
+ 5.794ns 0.408128mA
+ 5.796ns 0.406344mA
+ 5.798ns 0.404568mA
+ 5.8ns 0.402799mA
+ 5.802ns 0.401039mA
+ 5.804ns 0.399286mA
+ 5.806ns 0.397541mA
+ 5.808ns 0.395803mA
+ 5.81ns 0.394073mA
+ 5.812ns 0.392351mA
+ 5.814ns 0.390636mA
+ 5.816ns 0.388929mA
+ 5.818ns 0.387228mA
+ 5.82ns 0.385536mA
+ 5.822ns 0.383851mA
+ 5.824ns 0.382173mA
+ 5.826ns 0.380503mA
+ 5.828ns 0.37884mA
+ 5.83ns 0.377184mA
+ 5.832ns 0.375535mA
+ 5.834ns 0.373894mA
+ 5.836ns 0.37226mA
+ 5.838ns 0.370632mA
+ 5.84ns 0.369012mA
+ 5.842ns 0.367399mA
+ 5.844ns 0.365794mA
+ 5.846ns 0.364195mA
+ 5.848ns 0.362603mA
+ 5.85ns 0.361018mA
+ 5.852ns 0.35944mA
+ 5.854ns 0.357869mA
+ 5.856ns 0.356305mA
+ 5.858ns 0.354747mA
+ 5.86ns 0.353197mA
+ 5.862ns 0.351653mA
+ 5.864ns 0.350116mA
+ 5.866ns 0.348585mA
+ 5.868ns 0.347062mA
+ 5.87ns 0.345545mA
+ 5.872ns 0.344034mA
+ 5.874ns 0.342531mA
+ 5.876ns 0.341034mA
+ 5.878ns 0.339543mA
+ 5.88ns 0.338059mA
+ 5.882ns 0.336581mA
+ 5.884ns 0.33511mA
+ 5.886ns 0.333645mA
+ 5.888ns 0.332187mA
+ 5.89ns 0.330735mA
+ 5.892ns 0.329289mA
+ 5.894ns 0.32785mA
+ 5.896ns 0.326417mA
+ 5.898ns 0.32499mA
+ 5.9ns 0.323569mA
+ 5.902ns 0.322155mA
+ 5.904ns 0.320747mA
+ 5.906ns 0.319345mA
+ 5.908ns 0.317949mA
+ 5.91ns 0.316559mA
+ 5.912ns 0.315175mA
+ 5.914ns 0.313798mA
+ 5.916ns 0.312426mA
+ 5.918ns 0.31106mA
+ 5.92ns 0.309701mA
+ 5.922ns 0.308347mA
+ 5.924ns 0.306999mA
+ 5.926ns 0.305657mA
+ 5.928ns 0.304321mA
+ 5.93ns 0.302991mA
+ 5.932ns 0.301667mA
+ 5.934ns 0.300348mA
+ 5.936ns 0.299035mA
+ 5.938ns 0.297728mA
+ 5.94ns 0.296427mA
+ 5.942ns 0.295131mA
+ 5.944ns 0.293841mA
+ 5.946ns 0.292556mA
+ 5.948ns 0.291278mA
+ 5.95ns 0.290004mA
+ 5.952ns 0.288737mA
+ 5.954ns 0.287475mA
+ 5.956ns 0.286218mA
+ 5.958ns 0.284967mA
+ 5.96ns 0.283721mA
+ 5.962ns 0.282481mA
+ 5.964ns 0.281246mA
+ 5.966ns 0.280017mA
+ 5.968ns 0.278793mA
+ 5.97ns 0.277574mA
+ 5.972ns 0.276361mA
+ 5.974ns 0.275153mA
+ 5.976ns 0.27395mA
+ 5.978ns 0.272753mA
+ 5.98ns 0.27156mA
+ 5.982ns 0.270373mA
+ 5.984ns 0.269191mA
+ 5.986ns 0.268015mA
+ 5.988ns 0.266843mA
+ 5.99ns 0.265677mA
+ 5.992ns 0.264515mA
+ 5.994ns 0.263359mA
+ 5.996ns 0.262208mA
+ 5.998ns 0.261062mA
+ 6ns 0.259921mA
+ 6.002ns 0.258785mA
+ 6.004ns 0.257653mA
+ 6.006ns 0.256527mA
+ 6.008ns 0.255406mA
+ 6.01ns 0.254289mA
+ 6.012ns 0.253177mA
+ 6.014ns 0.252071mA
+ 6.016ns 0.250969mA
+ 6.018ns 0.249872mA
+ 6.02ns 0.24878mA
+ 6.022ns 0.247692mA
+ 6.024ns 0.246609mA
+ 6.026ns 0.245531mA
+ 6.028ns 0.244458mA
+ 6.03ns 0.243389mA
+ 6.032ns 0.242325mA
+ 6.034ns 0.241266mA
+ 6.036ns 0.240212mA
+ 6.038ns 0.239161mA
+ 6.04ns 0.238116mA
+ 6.042ns 0.237075mA
+ 6.044ns 0.236039mA
+ 6.046ns 0mA
I226 432 0 PWL 0 0
+ 5.778ns 0mA
+ 5.78ns 0.00114371mA
+ 5.782ns 0.010035mA
+ 5.784ns 0.0189263mA
+ 5.786ns 0.0278198mA
+ 5.788ns 0.0367111mA
+ 5.79ns 0.0456024mA
+ 5.792ns 0.0544958mA
+ 5.794ns 0.0633871mA
+ 5.796ns 0.0649837mA
+ 5.798ns 0.0543759mA
+ 5.8ns 0.0454975mA
+ 5.802ns 0.03807mA
+ 5.804ns 0.0318548mA
+ 5.806ns 0.026653mA
+ 5.808ns 0.0223014mA
+ 5.81ns 0.0186601mA
+ 5.812ns 0mA
I227 436 0 PWL 0 0
+ 0.464ns 0mA
+ 0.466ns 0.00103542mA
+ 0.468ns 0.0058455mA
+ 0.47ns 0.0106556mA
+ 0.472ns 0.0154656mA
+ 0.474ns 0.0202757mA
+ 0.476ns 0.0250857mA
+ 0.478ns 0.0298958mA
+ 0.48ns 0.0347059mA
+ 0.482ns 0.0395159mA
+ 0.484ns 0.044326mA
+ 0.486ns 0.0491361mA
+ 0.488ns 0.0539462mA
+ 0.49ns 0.0587562mA
+ 0.492ns 0.0635663mA
+ 0.494ns 0.0683763mA
+ 0.496ns 0.0731864mA
+ 0.498ns 0.0779965mA
+ 0.5ns 0.0828065mA
+ 0.502ns 0.0876166mA
+ 0.504ns 0.0924266mA
+ 0.506ns 0.0972368mA
+ 0.508ns 0.102047mA
+ 0.51ns 0.106857mA
+ 0.512ns 0.111667mA
+ 0.514ns 0.116477mA
+ 0.516ns 0.121287mA
+ 0.518ns 0.126097mA
+ 0.52ns 0.130907mA
+ 0.522ns 0.135717mA
+ 0.524ns 0.140527mA
+ 0.526ns 0.145337mA
+ 0.528ns 0.150147mA
+ 0.53ns 0.154958mA
+ 0.532ns 0.159768mA
+ 0.534ns 0.164578mA
+ 0.536ns 0.169388mA
+ 0.538ns 0.174198mA
+ 0.54ns 0.179008mA
+ 0.542ns 0.183818mA
+ 0.544ns 0.188628mA
+ 0.546ns 0.193438mA
+ 0.548ns 0.198248mA
+ 0.55ns 0.203058mA
+ 0.552ns 0.207868mA
+ 0.554ns 0.212678mA
+ 0.556ns 0.217488mA
+ 0.558ns 0.222298mA
+ 0.56ns 0.227108mA
+ 0.562ns 0.231919mA
+ 0.564ns 0.236729mA
+ 0.566ns 0.241539mA
+ 0.568ns 0.246349mA
+ 0.57ns 0.251159mA
+ 0.572ns 0.255969mA
+ 0.574ns 0.260779mA
+ 0.576ns 0.265589mA
+ 0.578ns 0.270399mA
+ 0.58ns 0.275209mA
+ 0.582ns 0.280019mA
+ 0.584ns 0.284829mA
+ 0.586ns 0.289639mA
+ 0.588ns 0.294449mA
+ 0.59ns 0.299259mA
+ 0.592ns 0.304069mA
+ 0.594ns 0.30888mA
+ 0.596ns 0.31369mA
+ 0.598ns 0.3185mA
+ 0.6ns 0.32331mA
+ 0.602ns 0.32812mA
+ 0.604ns 0.33293mA
+ 0.606ns 0.33774mA
+ 0.608ns 0.34255mA
+ 0.61ns 0.34736mA
+ 0.612ns 0.35217mA
+ 0.614ns 0.35698mA
+ 0.616ns 0.36179mA
+ 0.618ns 0.3666mA
+ 0.62ns 0.37141mA
+ 0.622ns 0.376221mA
+ 0.624ns 0.381031mA
+ 0.626ns 0.385841mA
+ 0.628ns 0.390651mA
+ 0.63ns 0.395461mA
+ 0.632ns 0.400271mA
+ 0.634ns 0.405081mA
+ 0.636ns 0.409891mA
+ 0.638ns 0.414701mA
+ 0.64ns 0.419511mA
+ 0.642ns 0.424321mA
+ 0.644ns 0.429131mA
+ 0.646ns 0.433941mA
+ 0.648ns 0.438751mA
+ 0.65ns 0.443561mA
+ 0.652ns 0.446774mA
+ 0.654ns 0.445197mA
+ 0.656ns 0.443626mA
+ 0.658ns 0.442061mA
+ 0.66ns 0.440501mA
+ 0.662ns 0.438946mA
+ 0.664ns 0.437398mA
+ 0.666ns 0.435854mA
+ 0.668ns 0.434316mA
+ 0.67ns 0.432783mA
+ 0.672ns 0.431256mA
+ 0.674ns 0.429734mA
+ 0.676ns 0.428218mA
+ 0.678ns 0.426707mA
+ 0.68ns 0.425201mA
+ 0.682ns 0.423701mA
+ 0.684ns 0.422206mA
+ 0.686ns 0.420716mA
+ 0.688ns 0.419231mA
+ 0.69ns 0.417752mA
+ 0.692ns 0.416278mA
+ 0.694ns 0.414809mA
+ 0.696ns 0.413345mA
+ 0.698ns 0.411886mA
+ 0.7ns 0.410433mA
+ 0.702ns 0.408984mA
+ 0.704ns 0.407541mA
+ 0.706ns 0.406103mA
+ 0.708ns 0.40467mA
+ 0.71ns 0.403242mA
+ 0.712ns 0.401819mA
+ 0.714ns 0.400401mA
+ 0.716ns 0.398988mA
+ 0.718ns 0.39758mA
+ 0.72ns 0.396177mA
+ 0.722ns 0.394779mA
+ 0.724ns 0.393386mA
+ 0.726ns 0.391998mA
+ 0.728ns 0.390614mA
+ 0.73ns 0.389236mA
+ 0.732ns 0.387862mA
+ 0.734ns 0.386494mA
+ 0.736ns 0.38513mA
+ 0.738ns 0.383771mA
+ 0.74ns 0.382417mA
+ 0.742ns 0.381067mA
+ 0.744ns 0.379722mA
+ 0.746ns 0.378382mA
+ 0.748ns 0.377047mA
+ 0.75ns 0.375716mA
+ 0.752ns 0.374391mA
+ 0.754ns 0.373069mA
+ 0.756ns 0.371753mA
+ 0.758ns 0.370441mA
+ 0.76ns 0.369134mA
+ 0.762ns 0.367831mA
+ 0.764ns 0.366533mA
+ 0.766ns 0.36524mA
+ 0.768ns 0.363951mA
+ 0.77ns 0.362666mA
+ 0.772ns 0.361387mA
+ 0.774ns 0.360111mA
+ 0.776ns 0.35884mA
+ 0.778ns 0.357574mA
+ 0.78ns 0.356312mA
+ 0.782ns 0.355055mA
+ 0.784ns 0.353802mA
+ 0.786ns 0.352553mA
+ 0.788ns 0.351309mA
+ 0.79ns 0.350069mA
+ 0.792ns 0.348834mA
+ 0.794ns 0.347603mA
+ 0.796ns 0.346376mA
+ 0.798ns 0.345154mA
+ 0.8ns 0.343936mA
+ 0.802ns 0.342722mA
+ 0.804ns 0.341513mA
+ 0.806ns 0.340308mA
+ 0.808ns 0.339107mA
+ 0.81ns 0.33791mA
+ 0.812ns 0.336718mA
+ 0.814ns 0.335529mA
+ 0.816ns 0.334345mA
+ 0.818ns 0.333165mA
+ 0.82ns 0.33199mA
+ 0.822ns 0.330818mA
+ 0.824ns 0.32965mA
+ 0.826ns 0.328487mA
+ 0.828ns 0.327328mA
+ 0.83ns 0.326173mA
+ 0.832ns 0.325022mA
+ 0.834ns 0.323875mA
+ 0.836ns 0.322732mA
+ 0.838ns 0.321593mA
+ 0.84ns 0.320458mA
+ 0.842ns 0.319327mA
+ 0.844ns 0.3182mA
+ 0.846ns 0.317077mA
+ 0.848ns 0.315958mA
+ 0.85ns 0.314843mA
+ 0.852ns 0.313732mA
+ 0.854ns 0.312625mA
+ 0.856ns 0.311522mA
+ 0.858ns 0.310422mA
+ 0.86ns 0.309327mA
+ 0.862ns 0.308235mA
+ 0.864ns 0.307147mA
+ 0.866ns 0.306063mA
+ 0.868ns 0.304983mA
+ 0.87ns 0.303907mA
+ 0.872ns 0.302834mA
+ 0.874ns 0.301766mA
+ 0.876ns 0.300701mA
+ 0.878ns 0.29964mA
+ 0.88ns 0.298582mA
+ 0.882ns 0.297528mA
+ 0.884ns 0.296478mA
+ 0.886ns 0.295432mA
+ 0.888ns 0.294389mA
+ 0.89ns 0.293351mA
+ 0.892ns 0.292315mA
+ 0.894ns 0.291284mA
+ 0.896ns 0.290256mA
+ 0.898ns 0.289231mA
+ 0.9ns 0.288211mA
+ 0.902ns 0.287193mA
+ 0.904ns 0.28618mA
+ 0.906ns 0.28517mA
+ 0.908ns 0.284164mA
+ 0.91ns 0.283161mA
+ 0.912ns 0.282161mA
+ 0.914ns 0.281166mA
+ 0.916ns 0.280173mA
+ 0.918ns 0.279185mA
+ 0.92ns 0.278199mA
+ 0.922ns 0.277218mA
+ 0.924ns 0.276239mA
+ 0.926ns 0.275264mA
+ 0.928ns 0.274293mA
+ 0.93ns 0.273325mA
+ 0.932ns 0.27236mA
+ 0.934ns 0.271399mA
+ 0.936ns 0.270441mA
+ 0.938ns 0.269487mA
+ 0.94ns 0.268536mA
+ 0.942ns 0.267588mA
+ 0.944ns 0.266644mA
+ 0.946ns 0.265703mA
+ 0.948ns 0.264765mA
+ 0.95ns 0.26383mA
+ 0.952ns 0.262899mA
+ 0.954ns 0.261972mA
+ 0.956ns 0.261047mA
+ 0.958ns 0.260126mA
+ 0.96ns 0.259208mA
+ 0.962ns 0.258293mA
+ 0.964ns 0.257381mA
+ 0.966ns 0.256473mA
+ 0.968ns 0.255568mA
+ 0.97ns 0.254666mA
+ 0.972ns 0.253767mA
+ 0.974ns 0.252871mA
+ 0.976ns 0.251979mA
+ 0.978ns 0.25109mA
+ 0.98ns 0.250204mA
+ 0.982ns 0.249321mA
+ 0.984ns 0.248441mA
+ 0.986ns 0.247564mA
+ 0.988ns 0.24669mA
+ 0.99ns 0.245819mA
+ 0.992ns 0.244952mA
+ 0.994ns 0.244087mA
+ 0.996ns 0.243226mA
+ 0.998ns 0.242368mA
+ 1ns 0.241512mA
+ 1.002ns 0.24066mA
+ 1.004ns 0.23981mA
+ 1.006ns 0.238964mA
+ 1.008ns 0.238121mA
+ 1.01ns 0.23728mA
+ 1.012ns 0.236443mA
+ 1.014ns 0.235608mA
+ 1.016ns 0.234777mA
+ 1.018ns 0.233948mA
+ 1.02ns 0.233123mA
+ 1.022ns 0.2323mA
+ 1.024ns 0.23148mA
+ 1.026ns 0.230663mA
+ 1.028ns 0.229849mA
+ 1.03ns 0.229038mA
+ 1.032ns 0.228229mA
+ 1.034ns 0.227424mA
+ 1.036ns 0.226621mA
+ 1.038ns 0.225821mA
+ 1.04ns 0.225024mA
+ 1.042ns 0.22423mA
+ 1.044ns 0.223439mA
+ 1.046ns 0.22265mA
+ 1.048ns 0.221864mA
+ 1.05ns 0.221081mA
+ 1.052ns 0.220301mA
+ 1.054ns 0.219524mA
+ 1.056ns 0.218749mA
+ 1.058ns 0.217977mA
+ 1.06ns 0.217208mA
+ 1.062ns 0.216441mA
+ 1.064ns 0.215677mA
+ 1.066ns 0.214916mA
+ 1.068ns 0.214157mA
+ 1.07ns 0.213401mA
+ 1.072ns 0.212648mA
+ 1.074ns 0.211898mA
+ 1.076ns 0.21115mA
+ 1.078ns 0.210405mA
+ 1.08ns 0.209662mA
+ 1.082ns 0.208922mA
+ 1.084ns 0.208185mA
+ 1.086ns 0.20745mA
+ 1.088ns 0.206718mA
+ 1.09ns 0.205988mA
+ 1.092ns 0.205261mA
+ 1.094ns 0.204537mA
+ 1.096ns 0.203815mA
+ 1.098ns 0.203095mA
+ 1.1ns 0.202379mA
+ 1.102ns 0.201664mA
+ 1.104ns 0.200953mA
+ 1.106ns 0.200243mA
+ 1.108ns 0.199537mA
+ 1.11ns 0.198832mA
+ 1.112ns 0.198131mA
+ 1.114ns 0.197431mA
+ 1.116ns 0.196735mA
+ 1.118ns 0.19604mA
+ 1.12ns 0.195348mA
+ 1.122ns 0.194659mA
+ 1.124ns 0.193972mA
+ 1.126ns 0.193287mA
+ 1.128ns 0.192605mA
+ 1.13ns 0.191925mA
+ 1.132ns 0.191248mA
+ 1.134ns 0.190573mA
+ 1.136ns 0.1899mA
+ 1.138ns 0mA
+ 5.65ns 0mA
+ 5.652ns 0.00416234mA
+ 5.654ns 0.00897321mA
+ 5.656ns 0.0137829mA
+ 5.658ns 0.0185926mA
+ 5.66ns 0.0234024mA
+ 5.662ns 0.0282132mA
+ 5.664ns 0.0330229mA
+ 5.666ns 0.0378327mA
+ 5.668ns 0.0426435mA
+ 5.67ns 0.0474532mA
+ 5.672ns 0.0522629mA
+ 5.674ns 0.0570738mA
+ 5.676ns 0.0618835mA
+ 5.678ns 0.0666932mA
+ 5.68ns 0.0715041mA
+ 5.682ns 0.0763138mA
+ 5.684ns 0.0811235mA
+ 5.686ns 0.0859333mA
+ 5.688ns 0.0907441mA
+ 5.69ns 0.0955538mA
+ 5.692ns 0.100364mA
+ 5.694ns 0.105174mA
+ 5.696ns 0.109984mA
+ 5.698ns 0.114794mA
+ 5.7ns 0.119605mA
+ 5.702ns 0.124414mA
+ 5.704ns 0.129224mA
+ 5.706ns 0.134034mA
+ 5.708ns 0.138845mA
+ 5.71ns 0.143654mA
+ 5.712ns 0.148464mA
+ 5.714ns 0.153275mA
+ 5.716ns 0.158085mA
+ 5.718ns 0.162894mA
+ 5.72ns 0.167705mA
+ 5.722ns 0.172515mA
+ 5.724ns 0.177325mA
+ 5.726ns 0.182136mA
+ 5.728ns 0.186945mA
+ 5.73ns 0.191755mA
+ 5.732ns 0.196565mA
+ 5.734ns 0.201376mA
+ 5.736ns 0.206185mA
+ 5.738ns 0.210995mA
+ 5.74ns 0.215806mA
+ 5.742ns 0.220616mA
+ 5.744ns 0.225425mA
+ 5.746ns 0.230236mA
+ 5.748ns 0.235046mA
+ 5.75ns 0.239856mA
+ 5.752ns 0.244665mA
+ 5.754ns 0.249476mA
+ 5.756ns 0.254286mA
+ 5.758ns 0.259096mA
+ 5.76ns 0.263907mA
+ 5.762ns 0.268716mA
+ 5.764ns 0.273526mA
+ 5.766ns 0.278337mA
+ 5.768ns 0.283147mA
+ 5.77ns 0.287956mA
+ 5.772ns 0.292767mA
+ 5.774ns 0.297577mA
+ 5.776ns 0.302387mA
+ 5.778ns 0.307196mA
+ 5.78ns 0.312007mA
+ 5.782ns 0.316817mA
+ 5.784ns 0.321627mA
+ 5.786ns 0.326437mA
+ 5.788ns 0.331247mA
+ 5.79ns 0.336057mA
+ 5.792ns 0.340868mA
+ 5.794ns 0.345677mA
+ 5.796ns 0.350487mA
+ 5.798ns 0.355297mA
+ 5.8ns 0.360108mA
+ 5.802ns 0.364917mA
+ 5.804ns 0.369727mA
+ 5.806ns 0.374538mA
+ 5.808ns 0.379348mA
+ 5.81ns 0.384157mA
+ 5.812ns 0.388968mA
+ 5.814ns 0.393778mA
+ 5.816ns 0.398588mA
+ 5.818ns 0.403399mA
+ 5.82ns 0.408208mA
+ 5.822ns 0.413018mA
+ 5.824ns 0.417828mA
+ 5.826ns 0.422639mA
+ 5.828ns 0.427448mA
+ 5.83ns 0.432258mA
+ 5.832ns 0.437069mA
+ 5.834ns 0.441879mA
+ 5.836ns 0.446688mA
+ 5.838ns 0.445748mA
+ 5.84ns 0.444175mA
+ 5.842ns 0.442608mA
+ 5.844ns 0.441046mA
+ 5.846ns 0.43949mA
+ 5.848ns 0.437939mA
+ 5.85ns 0.436394mA
+ 5.852ns 0.434853mA
+ 5.854ns 0.433319mA
+ 5.856ns 0.43179mA
+ 5.858ns 0.430266mA
+ 5.86ns 0.428748mA
+ 5.862ns 0.427235mA
+ 5.864ns 0.425727mA
+ 5.866ns 0.424225mA
+ 5.868ns 0.422728mA
+ 5.87ns 0.421237mA
+ 5.872ns 0.41975mA
+ 5.874ns 0.418269mA
+ 5.876ns 0.416793mA
+ 5.878ns 0.415322mA
+ 5.88ns 0.413856mA
+ 5.882ns 0.412396mA
+ 5.884ns 0.41094mA
+ 5.886ns 0.40949mA
+ 5.888ns 0.408046mA
+ 5.89ns 0.406606mA
+ 5.892ns 0.405171mA
+ 5.894ns 0.403741mA
+ 5.896ns 0.402316mA
+ 5.898ns 0.400896mA
+ 5.9ns 0.399482mA
+ 5.902ns 0.398072mA
+ 5.904ns 0.396667mA
+ 5.906ns 0.395268mA
+ 5.908ns 0.393873mA
+ 5.91ns 0.392483mA
+ 5.912ns 0.391098mA
+ 5.914ns 0.389718mA
+ 5.916ns 0.388343mA
+ 5.918ns 0.386972mA
+ 5.92ns 0.385606mA
+ 5.922ns 0.384246mA
+ 5.924ns 0.38289mA
+ 5.926ns 0.381539mA
+ 5.928ns 0.380192mA
+ 5.93ns 0.37885mA
+ 5.932ns 0.377514mA
+ 5.934ns 0.376181mA
+ 5.936ns 0.374854mA
+ 5.938ns 0.373531mA
+ 5.94ns 0.372213mA
+ 5.942ns 0.3709mA
+ 5.944ns 0.36959mA
+ 5.946ns 0.368286mA
+ 5.948ns 0.366987mA
+ 5.95ns 0.365692mA
+ 5.952ns 0.364401mA
+ 5.954ns 0.363115mA
+ 5.956ns 0.361834mA
+ 5.958ns 0.360557mA
+ 5.96ns 0.359285mA
+ 5.962ns 0.358017mA
+ 5.964ns 0.356753mA
+ 5.966ns 0.355494mA
+ 5.968ns 0.35424mA
+ 5.97ns 0.35299mA
+ 5.972ns 0.351744mA
+ 5.974ns 0.350503mA
+ 5.976ns 0.349266mA
+ 5.978ns 0.348033mA
+ 5.98ns 0.346805mA
+ 5.982ns 0.345581mA
+ 5.984ns 0.344362mA
+ 5.986ns 0.343146mA
+ 5.988ns 0.341936mA
+ 5.99ns 0.340729mA
+ 5.992ns 0.339526mA
+ 5.994ns 0.338328mA
+ 5.996ns 0.337134mA
+ 5.998ns 0.335944mA
+ 6ns 0.334759mA
+ 6.002ns 0.333578mA
+ 6.004ns 0.3324mA
+ 6.006ns 0.331227mA
+ 6.008ns 0.330059mA
+ 6.01ns 0.328894mA
+ 6.012ns 0.327733mA
+ 6.014ns 0.326577mA
+ 6.016ns 0.325424mA
+ 6.018ns 0.324275mA
+ 6.02ns 0.323131mA
+ 6.022ns 0.321991mA
+ 6.024ns 0.320854mA
+ 6.026ns 0.319722mA
+ 6.028ns 0.318594mA
+ 6.03ns 0.31747mA
+ 6.032ns 0.316349mA
+ 6.034ns 0.315233mA
+ 6.036ns 0.314121mA
+ 6.038ns 0.313012mA
+ 6.04ns 0.311907mA
+ 6.042ns 0.310807mA
+ 6.044ns 0.30971mA
+ 6.046ns 0.308617mA
+ 6.048ns 0.307528mA
+ 6.05ns 0.306442mA
+ 6.052ns 0.305361mA
+ 6.054ns 0.304283mA
+ 6.056ns 0.303209mA
+ 6.058ns 0.302139mA
+ 6.06ns 0.301073mA
+ 6.062ns 0.300011mA
+ 6.064ns 0.298952mA
+ 6.066ns 0.297897mA
+ 6.068ns 0.296845mA
+ 6.07ns 0.295798mA
+ 6.072ns 0.294754mA
+ 6.074ns 0.293714mA
+ 6.076ns 0.292677mA
+ 6.078ns 0.291644mA
+ 6.08ns 0.290615mA
+ 6.082ns 0.289589mA
+ 6.084ns 0.288567mA
+ 6.086ns 0.287549mA
+ 6.088ns 0.286534mA
+ 6.09ns 0.285523mA
+ 6.092ns 0.284515mA
+ 6.094ns 0.283511mA
+ 6.096ns 0.282511mA
+ 6.098ns 0.281514mA
+ 6.1ns 0.28052mA
+ 6.102ns 0.27953mA
+ 6.104ns 0.278544mA
+ 6.106ns 0.277561mA
+ 6.108ns 0.276581mA
+ 6.11ns 0.275605mA
+ 6.112ns 0.274632mA
+ 6.114ns 0.273663mA
+ 6.116ns 0.272697mA
+ 6.118ns 0.271735mA
+ 6.12ns 0.270776mA
+ 6.122ns 0.26982mA
+ 6.124ns 0.268868mA
+ 6.126ns 0.267919mA
+ 6.128ns 0.266974mA
+ 6.13ns 0.266031mA
+ 6.132ns 0.265093mA
+ 6.134ns 0.264157mA
+ 6.136ns 0.263225mA
+ 6.138ns 0.262296mA
+ 6.14ns 0.26137mA
+ 6.142ns 0.260448mA
+ 6.144ns 0.259528mA
+ 6.146ns 0.258613mA
+ 6.148ns 0.2577mA
+ 6.15ns 0.25679mA
+ 6.152ns 0.255884mA
+ 6.154ns 0.254981mA
+ 6.156ns 0.254081mA
+ 6.158ns 0.253184mA
+ 6.16ns 0.252291mA
+ 6.162ns 0.2514mA
+ 6.164ns 0.250513mA
+ 6.166ns 0.249629mA
+ 6.168ns 0.248748mA
+ 6.17ns 0.24787mA
+ 6.172ns 0.246995mA
+ 6.174ns 0.246124mA
+ 6.176ns 0.245255mA
+ 6.178ns 0.24439mA
+ 6.18ns 0.243527mA
+ 6.182ns 0.242667mA
+ 6.184ns 0.241811mA
+ 6.186ns 0.240958mA
+ 6.188ns 0.240107mA
+ 6.19ns 0.23926mA
+ 6.192ns 0.238416mA
+ 6.194ns 0.237574mA
+ 6.196ns 0.236736mA
+ 6.198ns 0.2359mA
+ 6.2ns 0.235068mA
+ 6.202ns 0.234238mA
+ 6.204ns 0.233411mA
+ 6.206ns 0.232587mA
+ 6.208ns 0.231766mA
+ 6.21ns 0.230949mA
+ 6.212ns 0.230134mA
+ 6.214ns 0.229321mA
+ 6.216ns 0.228512mA
+ 6.218ns 0.227705mA
+ 6.22ns 0.226902mA
+ 6.222ns 0.226101mA
+ 6.224ns 0.225303mA
+ 6.226ns 0.224508mA
+ 6.228ns 0.223715mA
+ 6.23ns 0.222926mA
+ 6.232ns 0.222139mA
+ 6.234ns 0.221355mA
+ 6.236ns 0.220574mA
+ 6.238ns 0.219795mA
+ 6.24ns 0.21902mA
+ 6.242ns 0.218247mA
+ 6.244ns 0.217476mA
+ 6.246ns 0.216709mA
+ 6.248ns 0.215944mA
+ 6.25ns 0.215182mA
+ 6.252ns 0.214422mA
+ 6.254ns 0.213666mA
+ 6.256ns 0.212912mA
+ 6.258ns 0.21216mA
+ 6.26ns 0.211411mA
+ 6.262ns 0.210665mA
+ 6.264ns 0.209922mA
+ 6.266ns 0.209181mA
+ 6.268ns 0.208442mA
+ 6.27ns 0.207707mA
+ 6.272ns 0.206974mA
+ 6.274ns 0.206243mA
+ 6.276ns 0.205515mA
+ 6.278ns 0.20479mA
+ 6.28ns 0.204067mA
+ 6.282ns 0.203347mA
+ 6.284ns 0.202629mA
+ 6.286ns 0.201914mA
+ 6.288ns 0.201201mA
+ 6.29ns 0.200491mA
+ 6.292ns 0.199784mA
+ 6.294ns 0.199078mA
+ 6.296ns 0.198376mA
+ 6.298ns 0.197676mA
+ 6.3ns 0.196978mA
+ 6.302ns 0.196283mA
+ 6.304ns 0.19559mA
+ 6.306ns 0.1949mA
+ 6.308ns 0.194212mA
+ 6.31ns 0.193526mA
+ 6.312ns 0.192843mA
+ 6.314ns 0.192163mA
+ 6.316ns 0.191484mA
+ 6.318ns 0.190809mA
+ 6.32ns 0.190135mA
+ 6.322ns 0mA
I228 437 0 PWL 0 0
+ 0.468ns 0mA
+ 0.47ns 0.00114105mA
+ 0.472ns 0.00596924mA
+ 0.474ns 0.0107974mA
+ 0.476ns 0.0156255mA
+ 0.478ns 0.0204537mA
+ 0.48ns 0.0252819mA
+ 0.482ns 0.0301101mA
+ 0.484ns 0.0349383mA
+ 0.486ns 0.0397665mA
+ 0.488ns 0.0445947mA
+ 0.49ns 0.0494228mA
+ 0.492ns 0.054251mA
+ 0.494ns 0.0590791mA
+ 0.496ns 0.0639073mA
+ 0.498ns 0.0687355mA
+ 0.5ns 0.0735636mA
+ 0.502ns 0.0783919mA
+ 0.504ns 0.08322mA
+ 0.506ns 0.0880482mA
+ 0.508ns 0.0928764mA
+ 0.51ns 0.0977046mA
+ 0.512ns 0.102533mA
+ 0.514ns 0.107361mA
+ 0.516ns 0.112189mA
+ 0.518ns 0.117017mA
+ 0.52ns 0.121845mA
+ 0.522ns 0.126674mA
+ 0.524ns 0.131502mA
+ 0.526ns 0.13633mA
+ 0.528ns 0.141158mA
+ 0.53ns 0.145986mA
+ 0.532ns 0.150814mA
+ 0.534ns 0.155643mA
+ 0.536ns 0.160471mA
+ 0.538ns 0.165299mA
+ 0.54ns 0.170127mA
+ 0.542ns 0.174955mA
+ 0.544ns 0.179784mA
+ 0.546ns 0.184612mA
+ 0.548ns 0.18944mA
+ 0.55ns 0.194268mA
+ 0.552ns 0.199096mA
+ 0.554ns 0.203924mA
+ 0.556ns 0.208753mA
+ 0.558ns 0.213581mA
+ 0.56ns 0.218409mA
+ 0.562ns 0.223237mA
+ 0.564ns 0.228065mA
+ 0.566ns 0.232894mA
+ 0.568ns 0.237722mA
+ 0.57ns 0.24255mA
+ 0.572ns 0.247378mA
+ 0.574ns 0.252206mA
+ 0.576ns 0.257034mA
+ 0.578ns 0.261862mA
+ 0.58ns 0.266691mA
+ 0.582ns 0.271519mA
+ 0.584ns 0.276347mA
+ 0.586ns 0.281175mA
+ 0.588ns 0.286003mA
+ 0.59ns 0.290832mA
+ 0.592ns 0.29566mA
+ 0.594ns 0.300488mA
+ 0.596ns 0.305316mA
+ 0.598ns 0.310144mA
+ 0.6ns 0.314972mA
+ 0.602ns 0.319801mA
+ 0.604ns 0.324629mA
+ 0.606ns 0.329457mA
+ 0.608ns 0.334285mA
+ 0.61ns 0.339113mA
+ 0.612ns 0.343942mA
+ 0.614ns 0.34877mA
+ 0.616ns 0.353598mA
+ 0.618ns 0.358426mA
+ 0.62ns 0.363254mA
+ 0.622ns 0.368082mA
+ 0.624ns 0.372911mA
+ 0.626ns 0.377739mA
+ 0.628ns 0.382567mA
+ 0.63ns 0.387395mA
+ 0.632ns 0.392223mA
+ 0.634ns 0.397051mA
+ 0.636ns 0.40188mA
+ 0.638ns 0.406708mA
+ 0.64ns 0.411536mA
+ 0.642ns 0.416364mA
+ 0.644ns 0.421192mA
+ 0.646ns 0.426021mA
+ 0.648ns 0.430849mA
+ 0.65ns 0.435677mA
+ 0.652ns 0.440505mA
+ 0.654ns 0.445333mA
+ 0.656ns 0.444731mA
+ 0.658ns 0.443175mA
+ 0.66ns 0.441624mA
+ 0.662ns 0.440079mA
+ 0.664ns 0.43854mA
+ 0.666ns 0.437006mA
+ 0.668ns 0.435477mA
+ 0.67ns 0.433953mA
+ 0.672ns 0.432435mA
+ 0.674ns 0.430922mA
+ 0.676ns 0.429415mA
+ 0.678ns 0.427912mA
+ 0.68ns 0.426415mA
+ 0.682ns 0.424924mA
+ 0.684ns 0.423437mA
+ 0.686ns 0.421956mA
+ 0.688ns 0.42048mA
+ 0.69ns 0.419009mA
+ 0.692ns 0.417543mA
+ 0.694ns 0.416082mA
+ 0.696ns 0.414626mA
+ 0.698ns 0.413176mA
+ 0.7ns 0.41173mA
+ 0.702ns 0.41029mA
+ 0.704ns 0.408854mA
+ 0.706ns 0.407424mA
+ 0.708ns 0.405999mA
+ 0.71ns 0.404578mA
+ 0.712ns 0.403163mA
+ 0.714ns 0.401753mA
+ 0.716ns 0.400347mA
+ 0.718ns 0.398946mA
+ 0.72ns 0.397551mA
+ 0.722ns 0.39616mA
+ 0.724ns 0.394774mA
+ 0.726ns 0.393393mA
+ 0.728ns 0.392017mA
+ 0.73ns 0.390645mA
+ 0.732ns 0.389278mA
+ 0.734ns 0.387916mA
+ 0.736ns 0.386559mA
+ 0.738ns 0.385207mA
+ 0.74ns 0.383859mA
+ 0.742ns 0.382516mA
+ 0.744ns 0.381178mA
+ 0.746ns 0.379845mA
+ 0.748ns 0.378516mA
+ 0.75ns 0.377191mA
+ 0.752ns 0.375872mA
+ 0.754ns 0.374557mA
+ 0.756ns 0.373246mA
+ 0.758ns 0.371941mA
+ 0.76ns 0.370639mA
+ 0.762ns 0.369343mA
+ 0.764ns 0.36805mA
+ 0.766ns 0.366763mA
+ 0.768ns 0.36548mA
+ 0.77ns 0.364201mA
+ 0.772ns 0.362927mA
+ 0.774ns 0.361657mA
+ 0.776ns 0.360392mA
+ 0.778ns 0.359131mA
+ 0.78ns 0.357875mA
+ 0.782ns 0.356623mA
+ 0.784ns 0.355375mA
+ 0.786ns 0.354132mA
+ 0.788ns 0.352893mA
+ 0.79ns 0.351658mA
+ 0.792ns 0.350428mA
+ 0.794ns 0.349202mA
+ 0.796ns 0.34798mA
+ 0.798ns 0.346763mA
+ 0.8ns 0.345549mA
+ 0.802ns 0.34434mA
+ 0.804ns 0.343136mA
+ 0.806ns 0.341935mA
+ 0.808ns 0.340739mA
+ 0.81ns 0.339547mA
+ 0.812ns 0.338359mA
+ 0.814ns 0.337175mA
+ 0.816ns 0.335995mA
+ 0.818ns 0.33482mA
+ 0.82ns 0.333648mA
+ 0.822ns 0.332481mA
+ 0.824ns 0.331318mA
+ 0.826ns 0.330159mA
+ 0.828ns 0.329004mA
+ 0.83ns 0.327853mA
+ 0.832ns 0.326706mA
+ 0.834ns 0.325563mA
+ 0.836ns 0.324423mA
+ 0.838ns 0.323288mA
+ 0.84ns 0.322157mA
+ 0.842ns 0.32103mA
+ 0.844ns 0.319907mA
+ 0.846ns 0.318788mA
+ 0.848ns 0.317672mA
+ 0.85ns 0.316561mA
+ 0.852ns 0.315453mA
+ 0.854ns 0.31435mA
+ 0.856ns 0.31325mA
+ 0.858ns 0.312154mA
+ 0.86ns 0.311062mA
+ 0.862ns 0.309974mA
+ 0.864ns 0.308889mA
+ 0.866ns 0.307808mA
+ 0.868ns 0.306731mA
+ 0.87ns 0.305658mA
+ 0.872ns 0.304589mA
+ 0.874ns 0.303523mA
+ 0.876ns 0.302461mA
+ 0.878ns 0.301403mA
+ 0.88ns 0.300349mA
+ 0.882ns 0.299298mA
+ 0.884ns 0.298251mA
+ 0.886ns 0.297207mA
+ 0.888ns 0.296167mA
+ 0.89ns 0.295131mA
+ 0.892ns 0.294098mA
+ 0.894ns 0.293069mA
+ 0.896ns 0.292044mA
+ 0.898ns 0.291022mA
+ 0.9ns 0.290004mA
+ 0.902ns 0.288989mA
+ 0.904ns 0.287978mA
+ 0.906ns 0.286971mA
+ 0.908ns 0.285967mA
+ 0.91ns 0.284966mA
+ 0.912ns 0.283969mA
+ 0.914ns 0.282976mA
+ 0.916ns 0.281986mA
+ 0.918ns 0.280999mA
+ 0.92ns 0.280016mA
+ 0.922ns 0.279036mA
+ 0.924ns 0.27806mA
+ 0.926ns 0.277087mA
+ 0.928ns 0.276117mA
+ 0.93ns 0.275151mA
+ 0.932ns 0.274189mA
+ 0.934ns 0.273229mA
+ 0.936ns 0.272273mA
+ 0.938ns 0.271321mA
+ 0.94ns 0.270371mA
+ 0.942ns 0.269425mA
+ 0.944ns 0.268483mA
+ 0.946ns 0.267543mA
+ 0.948ns 0.266607mA
+ 0.95ns 0.265675mA
+ 0.952ns 0.264745mA
+ 0.954ns 0.263819mA
+ 0.956ns 0.262896mA
+ 0.958ns 0.261976mA
+ 0.96ns 0.261059mA
+ 0.962ns 0.260146mA
+ 0.964ns 0.259236mA
+ 0.966ns 0.258329mA
+ 0.968ns 0.257425mA
+ 0.97ns 0.256524mA
+ 0.972ns 0.255626mA
+ 0.974ns 0.254732mA
+ 0.976ns 0.253841mA
+ 0.978ns 0.252953mA
+ 0.98ns 0.252068mA
+ 0.982ns 0.251186mA
+ 0.984ns 0.250307mA
+ 0.986ns 0.249431mA
+ 0.988ns 0.248558mA
+ 0.99ns 0.247689mA
+ 0.992ns 0.246822mA
+ 0.994ns 0.245958mA
+ 0.996ns 0.245098mA
+ 0.998ns 0.24424mA
+ 1ns 0.243386mA
+ 1.002ns 0.242534mA
+ 1.004ns 0.241685mA
+ 1.006ns 0.24084mA
+ 1.008ns 0.239997mA
+ 1.01ns 0.239157mA
+ 1.012ns 0.238321mA
+ 1.014ns 0.237487mA
+ 1.016ns 0.236656mA
+ 1.018ns 0.235828mA
+ 1.02ns 0.235003mA
+ 1.022ns 0.23418mA
+ 1.024ns 0.233361mA
+ 1.026ns 0.232544mA
+ 1.028ns 0.231731mA
+ 1.03ns 0.23092mA
+ 1.032ns 0.230112mA
+ 1.034ns 0.229307mA
+ 1.036ns 0.228505mA
+ 1.038ns 0.227705mA
+ 1.04ns 0.226908mA
+ 1.042ns 0.226114mA
+ 1.044ns 0.225323mA
+ 1.046ns 0.224535mA
+ 1.048ns 0.223749mA
+ 1.05ns 0.222966mA
+ 1.052ns 0.222186mA
+ 1.054ns 0.221409mA
+ 1.056ns 0.220634mA
+ 1.058ns 0.219862mA
+ 1.06ns 0.219093mA
+ 1.062ns 0.218326mA
+ 1.064ns 0.217562mA
+ 1.066ns 0.216801mA
+ 1.068ns 0.216042mA
+ 1.07ns 0.215286mA
+ 1.072ns 0.214533mA
+ 1.074ns 0.213782mA
+ 1.076ns 0.213034mA
+ 1.078ns 0.212289mA
+ 1.08ns 0.211546mA
+ 1.082ns 0.210806mA
+ 1.084ns 0.210068mA
+ 1.086ns 0.209333mA
+ 1.088ns 0.208601mA
+ 1.09ns 0.207871mA
+ 1.092ns 0.207144mA
+ 1.094ns 0.206419mA
+ 1.096ns 0.205697mA
+ 1.098ns 0.204977mA
+ 1.1ns 0.20426mA
+ 1.102ns 0.203545mA
+ 1.104ns 0.202833mA
+ 1.106ns 0.202123mA
+ 1.108ns 0.201416mA
+ 1.11ns 0.200711mA
+ 1.112ns 0.200009mA
+ 1.114ns 0.199309mA
+ 1.116ns 0.198611mA
+ 1.118ns 0.197916mA
+ 1.12ns 0.197224mA
+ 1.122ns 0.196534mA
+ 1.124ns 0.195846mA
+ 1.126ns 0.195161mA
+ 1.128ns 0.194478mA
+ 1.13ns 0.193797mA
+ 1.132ns 0.193119mA
+ 1.134ns 0.192444mA
+ 1.136ns 0.19177mA
+ 1.138ns 0.191099mA
+ 1.14ns 0.19043mA
+ 1.142ns 0.189764mA
+ 1.144ns 0mA
+ 5.648ns 0mA
+ 5.65ns 0.00331438mA
+ 5.652ns 0.00814221mA
+ 5.654ns 0.0129712mA
+ 5.656ns 0.017799mA
+ 5.658ns 0.0226268mA
+ 5.66ns 0.0274547mA
+ 5.662ns 0.0322836mA
+ 5.664ns 0.0371115mA
+ 5.666ns 0.0419393mA
+ 5.668ns 0.0467683mA
+ 5.67ns 0.0515961mA
+ 5.672ns 0.0564239mA
+ 5.674ns 0.0612529mA
+ 5.676ns 0.0660807mA
+ 5.678ns 0.0709085mA
+ 5.68ns 0.0757375mA
+ 5.682ns 0.0805653mA
+ 5.684ns 0.0853932mA
+ 5.686ns 0.090221mA
+ 5.688ns 0.09505mA
+ 5.69ns 0.0998778mA
+ 5.692ns 0.104706mA
+ 5.694ns 0.109535mA
+ 5.696ns 0.114362mA
+ 5.698ns 0.11919mA
+ 5.7ns 0.124019mA
+ 5.702ns 0.128847mA
+ 5.704ns 0.133675mA
+ 5.706ns 0.138503mA
+ 5.708ns 0.143332mA
+ 5.71ns 0.14816mA
+ 5.712ns 0.152987mA
+ 5.714ns 0.157816mA
+ 5.716ns 0.162644mA
+ 5.718ns 0.167472mA
+ 5.72ns 0.172301mA
+ 5.722ns 0.177129mA
+ 5.724ns 0.181957mA
+ 5.726ns 0.186786mA
+ 5.728ns 0.191613mA
+ 5.73ns 0.196441mA
+ 5.732ns 0.201269mA
+ 5.734ns 0.206098mA
+ 5.736ns 0.210926mA
+ 5.738ns 0.215754mA
+ 5.74ns 0.220583mA
+ 5.742ns 0.22541mA
+ 5.744ns 0.230238mA
+ 5.746ns 0.235067mA
+ 5.748ns 0.239895mA
+ 5.75ns 0.244723mA
+ 5.752ns 0.249551mA
+ 5.754ns 0.25438mA
+ 5.756ns 0.259208mA
+ 5.758ns 0.264035mA
+ 5.76ns 0.268864mA
+ 5.762ns 0.273692mA
+ 5.764ns 0.27852mA
+ 5.766ns 0.283349mA
+ 5.768ns 0.288177mA
+ 5.77ns 0.293005mA
+ 5.772ns 0.297834mA
+ 5.774ns 0.302661mA
+ 5.776ns 0.307489mA
+ 5.778ns 0.312317mA
+ 5.78ns 0.317146mA
+ 5.782ns 0.321974mA
+ 5.784ns 0.326802mA
+ 5.786ns 0.331631mA
+ 5.788ns 0.336459mA
+ 5.79ns 0.341286mA
+ 5.792ns 0.346115mA
+ 5.794ns 0.350943mA
+ 5.796ns 0.355771mA
+ 5.798ns 0.360599mA
+ 5.8ns 0.365428mA
+ 5.802ns 0.370256mA
+ 5.804ns 0.375083mA
+ 5.806ns 0.379912mA
+ 5.808ns 0.38474mA
+ 5.81ns 0.389568mA
+ 5.812ns 0.394397mA
+ 5.814ns 0.399225mA
+ 5.816ns 0.404053mA
+ 5.818ns 0.408882mA
+ 5.82ns 0.413709mA
+ 5.822ns 0.418537mA
+ 5.824ns 0.423365mA
+ 5.826ns 0.428194mA
+ 5.828ns 0.433022mA
+ 5.83ns 0.43785mA
+ 5.832ns 0.442679mA
+ 5.834ns 0.445588mA
+ 5.836ns 0.44403mA
+ 5.838ns 0.442476mA
+ 5.84ns 0.440928mA
+ 5.842ns 0.439386mA
+ 5.844ns 0.437849mA
+ 5.846ns 0.436317mA
+ 5.848ns 0.43479mA
+ 5.85ns 0.433269mA
+ 5.852ns 0.431753mA
+ 5.854ns 0.430243mA
+ 5.856ns 0.428738mA
+ 5.858ns 0.427238mA
+ 5.86ns 0.425743mA
+ 5.862ns 0.424254mA
+ 5.864ns 0.422769mA
+ 5.866ns 0.421291mA
+ 5.868ns 0.419817mA
+ 5.87ns 0.418348mA
+ 5.872ns 0.416884mA
+ 5.874ns 0.415426mA
+ 5.876ns 0.413973mA
+ 5.878ns 0.412524mA
+ 5.88ns 0.411081mA
+ 5.882ns 0.409643mA
+ 5.884ns 0.40821mA
+ 5.886ns 0.406782mA
+ 5.888ns 0.405359mA
+ 5.89ns 0.403941mA
+ 5.892ns 0.402527mA
+ 5.894ns 0.401119mA
+ 5.896ns 0.399716mA
+ 5.898ns 0.398317mA
+ 5.9ns 0.396924mA
+ 5.902ns 0.395535mA
+ 5.904ns 0.394151mA
+ 5.906ns 0.392773mA
+ 5.908ns 0.391399mA
+ 5.91ns 0.390029mA
+ 5.912ns 0.388665mA
+ 5.914ns 0.387305mA
+ 5.916ns 0.38595mA
+ 5.918ns 0.3846mA
+ 5.92ns 0.383254mA
+ 5.922ns 0.381914mA
+ 5.924ns 0.380577mA
+ 5.926ns 0.379246mA
+ 5.928ns 0.377919mA
+ 5.93ns 0.376597mA
+ 5.932ns 0.375279mA
+ 5.934ns 0.373966mA
+ 5.936ns 0.372658mA
+ 5.938ns 0.371354mA
+ 5.94ns 0.370055mA
+ 5.942ns 0.368761mA
+ 5.944ns 0.36747mA
+ 5.946ns 0.366185mA
+ 5.948ns 0.364904mA
+ 5.95ns 0.363627mA
+ 5.952ns 0.362355mA
+ 5.954ns 0.361087mA
+ 5.956ns 0.359824mA
+ 5.958ns 0.358565mA
+ 5.96ns 0.357311mA
+ 5.962ns 0.356061mA
+ 5.964ns 0.354815mA
+ 5.966ns 0.353573mA
+ 5.968ns 0.352336mA
+ 5.97ns 0.351104mA
+ 5.972ns 0.349875mA
+ 5.974ns 0.348651mA
+ 5.976ns 0.347431mA
+ 5.978ns 0.346216mA
+ 5.98ns 0.345005mA
+ 5.982ns 0.343798mA
+ 5.984ns 0.342595mA
+ 5.986ns 0.341396mA
+ 5.988ns 0.340202mA
+ 5.99ns 0.339011mA
+ 5.992ns 0.337825mA
+ 5.994ns 0.336644mA
+ 5.996ns 0.335466mA
+ 5.998ns 0.334292mA
+ 6ns 0.333123mA
+ 6.002ns 0.331957mA
+ 6.004ns 0.330796mA
+ 6.006ns 0.329638mA
+ 6.008ns 0.328485mA
+ 6.01ns 0.327336mA
+ 6.012ns 0.326191mA
+ 6.014ns 0.325049mA
+ 6.016ns 0.323912mA
+ 6.018ns 0.322779mA
+ 6.02ns 0.32165mA
+ 6.022ns 0.320524mA
+ 6.024ns 0.319403mA
+ 6.026ns 0.318285mA
+ 6.028ns 0.317172mA
+ 6.03ns 0.316062mA
+ 6.032ns 0.314956mA
+ 6.034ns 0.313854mA
+ 6.036ns 0.312756mA
+ 6.038ns 0.311662mA
+ 6.04ns 0.310572mA
+ 6.042ns 0.309485mA
+ 6.044ns 0.308402mA
+ 6.046ns 0.307323mA
+ 6.048ns 0.306248mA
+ 6.05ns 0.305176mA
+ 6.052ns 0.304109mA
+ 6.054ns 0.303045mA
+ 6.056ns 0.301984mA
+ 6.058ns 0.300928mA
+ 6.06ns 0.299875mA
+ 6.062ns 0.298826mA
+ 6.064ns 0.29778mA
+ 6.066ns 0.296739mA
+ 6.068ns 0.2957mA
+ 6.07ns 0.294666mA
+ 6.072ns 0.293635mA
+ 6.074ns 0.292608mA
+ 6.076ns 0.291584mA
+ 6.078ns 0.290564mA
+ 6.08ns 0.289547mA
+ 6.082ns 0.288534mA
+ 6.084ns 0.287524mA
+ 6.086ns 0.286518mA
+ 6.088ns 0.285516mA
+ 6.09ns 0.284517mA
+ 6.092ns 0.283522mA
+ 6.094ns 0.28253mA
+ 6.096ns 0.281541mA
+ 6.098ns 0.280556mA
+ 6.1ns 0.279574mA
+ 6.102ns 0.278596mA
+ 6.104ns 0.277621mA
+ 6.106ns 0.27665mA
+ 6.108ns 0.275682mA
+ 6.11ns 0.274718mA
+ 6.112ns 0.273757mA
+ 6.114ns 0.272799mA
+ 6.116ns 0.271844mA
+ 6.118ns 0.270893mA
+ 6.12ns 0.269945mA
+ 6.122ns 0.269001mA
+ 6.124ns 0.26806mA
+ 6.126ns 0.267122mA
+ 6.128ns 0.266187mA
+ 6.13ns 0.265256mA
+ 6.132ns 0.264328mA
+ 6.134ns 0.263403mA
+ 6.136ns 0.262481mA
+ 6.138ns 0.261563mA
+ 6.14ns 0.260648mA
+ 6.142ns 0.259736mA
+ 6.144ns 0.258827mA
+ 6.146ns 0.257921mA
+ 6.148ns 0.257019mA
+ 6.15ns 0.25612mA
+ 6.152ns 0.255224mA
+ 6.154ns 0.254331mA
+ 6.156ns 0.253441mA
+ 6.158ns 0.252554mA
+ 6.16ns 0.25167mA
+ 6.162ns 0.25079mA
+ 6.164ns 0.249912mA
+ 6.166ns 0.249038mA
+ 6.168ns 0.248166mA
+ 6.17ns 0.247298mA
+ 6.172ns 0.246433mA
+ 6.174ns 0.245571mA
+ 6.176ns 0.244711mA
+ 6.178ns 0.243855mA
+ 6.18ns 0.243002mA
+ 6.182ns 0.242152mA
+ 6.184ns 0.241304mA
+ 6.186ns 0.24046mA
+ 6.188ns 0.239619mA
+ 6.19ns 0.23878mA
+ 6.192ns 0.237945mA
+ 6.194ns 0.237112mA
+ 6.196ns 0.236283mA
+ 6.198ns 0.235456mA
+ 6.2ns 0.234632mA
+ 6.202ns 0.233811mA
+ 6.204ns 0.232993mA
+ 6.206ns 0.232178mA
+ 6.208ns 0.231365mA
+ 6.21ns 0.230556mA
+ 6.212ns 0.229749mA
+ 6.214ns 0.228945mA
+ 6.216ns 0.228144mA
+ 6.218ns 0.227346mA
+ 6.22ns 0.226551mA
+ 6.222ns 0.225758mA
+ 6.224ns 0.224968mA
+ 6.226ns 0.224181mA
+ 6.228ns 0.223396mA
+ 6.23ns 0.222615mA
+ 6.232ns 0.221836mA
+ 6.234ns 0.22106mA
+ 6.236ns 0.220286mA
+ 6.238ns 0.219515mA
+ 6.24ns 0.218747mA
+ 6.242ns 0.217982mA
+ 6.244ns 0.217219mA
+ 6.246ns 0.216459mA
+ 6.248ns 0.215702mA
+ 6.25ns 0.214947mA
+ 6.252ns 0.214195mA
+ 6.254ns 0.213445mA
+ 6.256ns 0.212699mA
+ 6.258ns 0.211954mA
+ 6.26ns 0.211213mA
+ 6.262ns 0.210474mA
+ 6.264ns 0.209737mA
+ 6.266ns 0.209003mA
+ 6.268ns 0.208272mA
+ 6.27ns 0.207543mA
+ 6.272ns 0.206817mA
+ 6.274ns 0.206093mA
+ 6.276ns 0.205372mA
+ 6.278ns 0.204654mA
+ 6.28ns 0.203938mA
+ 6.282ns 0.203224mA
+ 6.284ns 0.202513mA
+ 6.286ns 0.201804mA
+ 6.288ns 0.201098mA
+ 6.29ns 0.200395mA
+ 6.292ns 0.199693mA
+ 6.294ns 0.198995mA
+ 6.296ns 0.198298mA
+ 6.298ns 0.197604mA
+ 6.3ns 0.196913mA
+ 6.302ns 0.196224mA
+ 6.304ns 0.195537mA
+ 6.306ns 0.194853mA
+ 6.308ns 0.194171mA
+ 6.31ns 0.193492mA
+ 6.312ns 0.192815mA
+ 6.314ns 0.19214mA
+ 6.316ns 0.191468mA
+ 6.318ns 0.190798mA
+ 6.32ns 0.19013mA
+ 6.322ns 0mA
I229 438 0 PWL 0 0
+ 0.57ns 0mA
+ 0.572ns 0.00377457mA
+ 0.574ns 0.0107519mA
+ 0.576ns 0.0177294mA
+ 0.578ns 0.0247067mA
+ 0.58ns 0.0316842mA
+ 0.582ns 0.0386614mA
+ 0.584ns 0.0456389mA
+ 0.586ns 0.0526162mA
+ 0.588ns 0.0595935mA
+ 0.59ns 0.066571mA
+ 0.592ns 0.0735483mA
+ 0.594ns 0.0805258mA
+ 0.596ns 0.0875031mA
+ 0.598ns 0.0944806mA
+ 0.6ns 0.101458mA
+ 0.602ns 0.108435mA
+ 0.604ns 0.115413mA
+ 0.606ns 0.12239mA
+ 0.608ns 0.129368mA
+ 0.61ns 0.136345mA
+ 0.612ns 0.143322mA
+ 0.614ns 0.1503mA
+ 0.616ns 0.157277mA
+ 0.618ns 0.164254mA
+ 0.62ns 0.171232mA
+ 0.622ns 0.178209mA
+ 0.624ns 0.185186mA
+ 0.626ns 0.192164mA
+ 0.628ns 0.199141mA
+ 0.63ns 0.206119mA
+ 0.632ns 0.213096mA
+ 0.634ns 0.220073mA
+ 0.636ns 0.227051mA
+ 0.638ns 0.234028mA
+ 0.64ns 0.241006mA
+ 0.642ns 0.247983mA
+ 0.644ns 0.25496mA
+ 0.646ns 0.261938mA
+ 0.648ns 0.268915mA
+ 0.65ns 0.275893mA
+ 0.652ns 0.28287mA
+ 0.654ns 0.289847mA
+ 0.656ns 0.296825mA
+ 0.658ns 0.303802mA
+ 0.66ns 0.310779mA
+ 0.662ns 0.317757mA
+ 0.664ns 0.324734mA
+ 0.666ns 0.331711mA
+ 0.668ns 0.338689mA
+ 0.67ns 0.345666mA
+ 0.672ns 0.352644mA
+ 0.674ns 0.359621mA
+ 0.676ns 0.366599mA
+ 0.678ns 0.373576mA
+ 0.68ns 0.380553mA
+ 0.682ns 0.387531mA
+ 0.684ns 0.394508mA
+ 0.686ns 0.401485mA
+ 0.688ns 0.408463mA
+ 0.69ns 0.41544mA
+ 0.692ns 0.422418mA
+ 0.694ns 0.429395mA
+ 0.696ns 0.436372mA
+ 0.698ns 0.44335mA
+ 0.7ns 0.450327mA
+ 0.702ns 0.457304mA
+ 0.704ns 0.464282mA
+ 0.706ns 0.471259mA
+ 0.708ns 0.478236mA
+ 0.71ns 0.485214mA
+ 0.712ns 0.492191mA
+ 0.714ns 0.499169mA
+ 0.716ns 0.506146mA
+ 0.718ns 0.513124mA
+ 0.72ns 0.520101mA
+ 0.722ns 0.527078mA
+ 0.724ns 0.534056mA
+ 0.726ns 0.54059mA
+ 0.728ns 0.53872mA
+ 0.73ns 0.536856mA
+ 0.732ns 0.534999mA
+ 0.734ns 0.533148mA
+ 0.736ns 0.531303mA
+ 0.738ns 0.529465mA
+ 0.74ns 0.527634mA
+ 0.742ns 0.525808mA
+ 0.744ns 0.523989mA
+ 0.746ns 0.522176mA
+ 0.748ns 0.52037mA
+ 0.75ns 0.518569mA
+ 0.752ns 0.516775mA
+ 0.754ns 0.514987mA
+ 0.756ns 0.513206mA
+ 0.758ns 0.51143mA
+ 0.76ns 0.509661mA
+ 0.762ns 0.507897mA
+ 0.764ns 0.50614mA
+ 0.766ns 0.504389mA
+ 0.768ns 0.502644mA
+ 0.77ns 0.500905mA
+ 0.772ns 0.499172mA
+ 0.774ns 0.497445mA
+ 0.776ns 0.495724mA
+ 0.778ns 0.494009mA
+ 0.78ns 0.4923mA
+ 0.782ns 0.490596mA
+ 0.784ns 0.488899mA
+ 0.786ns 0.487208mA
+ 0.788ns 0.485522mA
+ 0.79ns 0.483842mA
+ 0.792ns 0.482168mA
+ 0.794ns 0.4805mA
+ 0.796ns 0.478838mA
+ 0.798ns 0.477181mA
+ 0.8ns 0.47553mA
+ 0.802ns 0.473885mA
+ 0.804ns 0.472245mA
+ 0.806ns 0.470611mA
+ 0.808ns 0.468983mA
+ 0.81ns 0.467361mA
+ 0.812ns 0.465744mA
+ 0.814ns 0.464132mA
+ 0.816ns 0.462526mA
+ 0.818ns 0.460926mA
+ 0.82ns 0.459331mA
+ 0.822ns 0.457742mA
+ 0.824ns 0.456159mA
+ 0.826ns 0.45458mA
+ 0.828ns 0.453008mA
+ 0.83ns 0.45144mA
+ 0.832ns 0.449878mA
+ 0.834ns 0.448322mA
+ 0.836ns 0.446771mA
+ 0.838ns 0.445225mA
+ 0.84ns 0.443685mA
+ 0.842ns 0.442149mA
+ 0.844ns 0.44062mA
+ 0.846ns 0.439095mA
+ 0.848ns 0.437576mA
+ 0.85ns 0.436062mA
+ 0.852ns 0.434553mA
+ 0.854ns 0.43305mA
+ 0.856ns 0.431552mA
+ 0.858ns 0.430059mA
+ 0.86ns 0.428571mA
+ 0.862ns 0.427088mA
+ 0.864ns 0.42561mA
+ 0.866ns 0.424138mA
+ 0.868ns 0.42267mA
+ 0.87ns 0.421208mA
+ 0.872ns 0.41975mA
+ 0.874ns 0.418298mA
+ 0.876ns 0.416851mA
+ 0.878ns 0.415409mA
+ 0.88ns 0.413971mA
+ 0.882ns 0.412539mA
+ 0.884ns 0.411112mA
+ 0.886ns 0.409689mA
+ 0.888ns 0.408272mA
+ 0.89ns 0.406859mA
+ 0.892ns 0.405451mA
+ 0.894ns 0.404049mA
+ 0.896ns 0.402651mA
+ 0.898ns 0.401258mA
+ 0.9ns 0.399869mA
+ 0.902ns 0.398486mA
+ 0.904ns 0.397107mA
+ 0.906ns 0.395733mA
+ 0.908ns 0.394364mA
+ 0.91ns 0.392999mA
+ 0.912ns 0.39164mA
+ 0.914ns 0.390285mA
+ 0.916ns 0.388934mA
+ 0.918ns 0.387588mA
+ 0.92ns 0.386247mA
+ 0.922ns 0.384911mA
+ 0.924ns 0.383579mA
+ 0.926ns 0.382252mA
+ 0.928ns 0.380929mA
+ 0.93ns 0.379611mA
+ 0.932ns 0.378298mA
+ 0.934ns 0.376989mA
+ 0.936ns 0.375685mA
+ 0.938ns 0.374385mA
+ 0.94ns 0.37309mA
+ 0.942ns 0.371799mA
+ 0.944ns 0.370512mA
+ 0.946ns 0.36923mA
+ 0.948ns 0.367953mA
+ 0.95ns 0.36668mA
+ 0.952ns 0.365411mA
+ 0.954ns 0.364147mA
+ 0.956ns 0.362887mA
+ 0.958ns 0.361631mA
+ 0.96ns 0.36038mA
+ 0.962ns 0.359133mA
+ 0.964ns 0.35789mA
+ 0.966ns 0.356652mA
+ 0.968ns 0.355418mA
+ 0.97ns 0.354188mA
+ 0.972ns 0.352963mA
+ 0.974ns 0.351741mA
+ 0.976ns 0.350524mA
+ 0.978ns 0.349312mA
+ 0.98ns 0.348103mA
+ 0.982ns 0.346898mA
+ 0.984ns 0.345698mA
+ 0.986ns 0.344502mA
+ 0.988ns 0.34331mA
+ 0.99ns 0.342122mA
+ 0.992ns 0.340938mA
+ 0.994ns 0.339759mA
+ 0.996ns 0.338583mA
+ 0.998ns 0.337412mA
+ 1ns 0.336244mA
+ 1.002ns 0.335081mA
+ 1.004ns 0.333921mA
+ 1.006ns 0.332766mA
+ 1.008ns 0.331615mA
+ 1.01ns 0.330467mA
+ 1.012ns 0.329324mA
+ 1.014ns 0.328184mA
+ 1.016ns 0.327049mA
+ 1.018ns 0.325917mA
+ 1.02ns 0.324789mA
+ 1.022ns 0.323666mA
+ 1.024ns 0.322546mA
+ 1.026ns 0.32143mA
+ 1.028ns 0.320317mA
+ 1.03ns 0.319209mA
+ 1.032ns 0.318105mA
+ 1.034ns 0.317004mA
+ 1.036ns 0.315907mA
+ 1.038ns 0.314814mA
+ 1.04ns 0.313725mA
+ 1.042ns 0.312639mA
+ 1.044ns 0.311557mA
+ 1.046ns 0.310479mA
+ 1.048ns 0.309405mA
+ 1.05ns 0.308334mA
+ 1.052ns 0.307268mA
+ 1.054ns 0.306204mA
+ 1.056ns 0.305145mA
+ 1.058ns 0.304089mA
+ 1.06ns 0.303037mA
+ 1.062ns 0.301988mA
+ 1.064ns 0.300943mA
+ 1.066ns 0.299902mA
+ 1.068ns 0.298864mA
+ 1.07ns 0.29783mA
+ 1.072ns 0.2968mA
+ 1.074ns 0.295773mA
+ 1.076ns 0.294749mA
+ 1.078ns 0.293729mA
+ 1.08ns 0.292713mA
+ 1.082ns 0.2917mA
+ 1.084ns 0.290691mA
+ 1.086ns 0.289685mA
+ 1.088ns 0.288683mA
+ 1.09ns 0.287684mA
+ 1.092ns 0.286688mA
+ 1.094ns 0.285696mA
+ 1.096ns 0.284708mA
+ 1.098ns 0.283723mA
+ 1.1ns 0.282741mA
+ 1.102ns 0.281762mA
+ 1.104ns 0.280787mA
+ 1.106ns 0.279816mA
+ 1.108ns 0.278848mA
+ 1.11ns 0.277883mA
+ 1.112ns 0.276921mA
+ 1.114ns 0.275963mA
+ 1.116ns 0.275008mA
+ 1.118ns 0.274057mA
+ 1.12ns 0.273108mA
+ 1.122ns 0.272163mA
+ 1.124ns 0.271221mA
+ 1.126ns 0.270283mA
+ 1.128ns 0.269348mA
+ 1.13ns 0.268416mA
+ 1.132ns 0.267487mA
+ 1.134ns 0.266561mA
+ 1.136ns 0.265639mA
+ 1.138ns 0.26472mA
+ 1.14ns 0.263804mA
+ 1.142ns 0.262891mA
+ 1.144ns 0.261981mA
+ 1.146ns 0.261075mA
+ 1.148ns 0.260171mA
+ 1.15ns 0.259271mA
+ 1.152ns 0.258374mA
+ 1.154ns 0.25748mA
+ 1.156ns 0.256589mA
+ 1.158ns 0.255701mA
+ 1.16ns 0.254816mA
+ 1.162ns 0.253935mA
+ 1.164ns 0.253056mA
+ 1.166ns 0.25218mA
+ 1.168ns 0.251308mA
+ 1.17ns 0.250438mA
+ 1.172ns 0.249571mA
+ 1.174ns 0.248708mA
+ 1.176ns 0.247847mA
+ 1.178ns 0.246989mA
+ 1.18ns 0.246135mA
+ 1.182ns 0.245283mA
+ 1.184ns 0.244434mA
+ 1.186ns 0.243589mA
+ 1.188ns 0.242746mA
+ 1.19ns 0.241906mA
+ 1.192ns 0.241069mA
+ 1.194ns 0.240234mA
+ 1.196ns 0.239403mA
+ 1.198ns 0.238575mA
+ 1.2ns 0.237749mA
+ 1.202ns 0.236926mA
+ 1.204ns 0mA
+ 5.57ns 0mA
+ 5.572ns 0.00377561mA
+ 5.574ns 0.0107525mA
+ 5.576ns 0.017731mA
+ 5.578ns 0.0247079mA
+ 5.58ns 0.0316848mA
+ 5.582ns 0.0386633mA
+ 5.584ns 0.0456402mA
+ 5.586ns 0.0526171mA
+ 5.588ns 0.0595956mA
+ 5.59ns 0.0665725mA
+ 5.592ns 0.0735494mA
+ 5.594ns 0.0805262mA
+ 5.596ns 0.0875048mA
+ 5.598ns 0.0944817mA
+ 5.6ns 0.101459mA
+ 5.602ns 0.108437mA
+ 5.604ns 0.115414mA
+ 5.606ns 0.122391mA
+ 5.608ns 0.129369mA
+ 5.61ns 0.136346mA
+ 5.612ns 0.143323mA
+ 5.614ns 0.1503mA
+ 5.616ns 0.157279mA
+ 5.618ns 0.164255mA
+ 5.62ns 0.171232mA
+ 5.622ns 0.178211mA
+ 5.624ns 0.185188mA
+ 5.626ns 0.192165mA
+ 5.628ns 0.199143mA
+ 5.63ns 0.20612mA
+ 5.632ns 0.213097mA
+ 5.634ns 0.220075mA
+ 5.636ns 0.227052mA
+ 5.638ns 0.234029mA
+ 5.64ns 0.241006mA
+ 5.642ns 0.247985mA
+ 5.644ns 0.254961mA
+ 5.646ns 0.261938mA
+ 5.648ns 0.268917mA
+ 5.65ns 0.275894mA
+ 5.652ns 0.282871mA
+ 5.654ns 0.289849mA
+ 5.656ns 0.296826mA
+ 5.658ns 0.303803mA
+ 5.66ns 0.31078mA
+ 5.662ns 0.317758mA
+ 5.664ns 0.324735mA
+ 5.666ns 0.331712mA
+ 5.668ns 0.338691mA
+ 5.67ns 0.345668mA
+ 5.672ns 0.352644mA
+ 5.674ns 0.359623mA
+ 5.676ns 0.3666mA
+ 5.678ns 0.373577mA
+ 5.68ns 0.380555mA
+ 5.682ns 0.387532mA
+ 5.684ns 0.394509mA
+ 5.686ns 0.401486mA
+ 5.688ns 0.408464mA
+ 5.69ns 0.415441mA
+ 5.692ns 0.422418mA
+ 5.694ns 0.429397mA
+ 5.696ns 0.436374mA
+ 5.698ns 0.44335mA
+ 5.7ns 0.450329mA
+ 5.702ns 0.457306mA
+ 5.704ns 0.464283mA
+ 5.706ns 0.47126mA
+ 5.708ns 0.478238mA
+ 5.71ns 0.485215mA
+ 5.712ns 0.492192mA
+ 5.714ns 0.49917mA
+ 5.716ns 0.506147mA
+ 5.718ns 0.513124mA
+ 5.72ns 0.520103mA
+ 5.722ns 0.52708mA
+ 5.724ns 0.534056mA
+ 5.726ns 0.54059mA
+ 5.728ns 0.53872mA
+ 5.73ns 0.536856mA
+ 5.732ns 0.534999mA
+ 5.734ns 0.533148mA
+ 5.736ns 0.531303mA
+ 5.738ns 0.529465mA
+ 5.74ns 0.527633mA
+ 5.742ns 0.525808mA
+ 5.744ns 0.523989mA
+ 5.746ns 0.522176mA
+ 5.748ns 0.520369mA
+ 5.75ns 0.518569mA
+ 5.752ns 0.516775mA
+ 5.754ns 0.514987mA
+ 5.756ns 0.513205mA
+ 5.758ns 0.51143mA
+ 5.76ns 0.50966mA
+ 5.762ns 0.507897mA
+ 5.764ns 0.50614mA
+ 5.766ns 0.504389mA
+ 5.768ns 0.502644mA
+ 5.77ns 0.500905mA
+ 5.772ns 0.499171mA
+ 5.774ns 0.497445mA
+ 5.776ns 0.495724mA
+ 5.778ns 0.494009mA
+ 5.78ns 0.492299mA
+ 5.782ns 0.490596mA
+ 5.784ns 0.488899mA
+ 5.786ns 0.487207mA
+ 5.788ns 0.485522mA
+ 5.79ns 0.483842mA
+ 5.792ns 0.482168mA
+ 5.794ns 0.4805mA
+ 5.796ns 0.478837mA
+ 5.798ns 0.477181mA
+ 5.8ns 0.47553mA
+ 5.802ns 0.473885mA
+ 5.804ns 0.472245mA
+ 5.806ns 0.470611mA
+ 5.808ns 0.468983mA
+ 5.81ns 0.46736mA
+ 5.812ns 0.465743mA
+ 5.814ns 0.464132mA
+ 5.816ns 0.462526mA
+ 5.818ns 0.460926mA
+ 5.82ns 0.459331mA
+ 5.822ns 0.457742mA
+ 5.824ns 0.456158mA
+ 5.826ns 0.45458mA
+ 5.828ns 0.453007mA
+ 5.83ns 0.45144mA
+ 5.832ns 0.449878mA
+ 5.834ns 0.448322mA
+ 5.836ns 0.446771mA
+ 5.838ns 0.445225mA
+ 5.84ns 0.443684mA
+ 5.842ns 0.442149mA
+ 5.844ns 0.44062mA
+ 5.846ns 0.439095mA
+ 5.848ns 0.437576mA
+ 5.85ns 0.436062mA
+ 5.852ns 0.434553mA
+ 5.854ns 0.43305mA
+ 5.856ns 0.431551mA
+ 5.858ns 0.430058mA
+ 5.86ns 0.42857mA
+ 5.862ns 0.427088mA
+ 5.864ns 0.42561mA
+ 5.866ns 0.424137mA
+ 5.868ns 0.42267mA
+ 5.87ns 0.421208mA
+ 5.872ns 0.41975mA
+ 5.874ns 0.418298mA
+ 5.876ns 0.416851mA
+ 5.878ns 0.415408mA
+ 5.88ns 0.413971mA
+ 5.882ns 0.412539mA
+ 5.884ns 0.411111mA
+ 5.886ns 0.409689mA
+ 5.888ns 0.408272mA
+ 5.89ns 0.406859mA
+ 5.892ns 0.405451mA
+ 5.894ns 0.404048mA
+ 5.896ns 0.402651mA
+ 5.898ns 0.401257mA
+ 5.9ns 0.399869mA
+ 5.902ns 0.398486mA
+ 5.904ns 0.397107mA
+ 5.906ns 0.395733mA
+ 5.908ns 0.394364mA
+ 5.91ns 0.392999mA
+ 5.912ns 0.391639mA
+ 5.914ns 0.390284mA
+ 5.916ns 0.388934mA
+ 5.918ns 0.387588mA
+ 5.92ns 0.386247mA
+ 5.922ns 0.384911mA
+ 5.924ns 0.383579mA
+ 5.926ns 0.382252mA
+ 5.928ns 0.380929mA
+ 5.93ns 0.379611mA
+ 5.932ns 0.378298mA
+ 5.934ns 0.376989mA
+ 5.936ns 0.375685mA
+ 5.938ns 0.374385mA
+ 5.94ns 0.373089mA
+ 5.942ns 0.371799mA
+ 5.944ns 0.370512mA
+ 5.946ns 0.36923mA
+ 5.948ns 0.367953mA
+ 5.95ns 0.366679mA
+ 5.952ns 0.365411mA
+ 5.954ns 0.364146mA
+ 5.956ns 0.362886mA
+ 5.958ns 0.361631mA
+ 5.96ns 0.36038mA
+ 5.962ns 0.359133mA
+ 5.964ns 0.35789mA
+ 5.966ns 0.356652mA
+ 5.968ns 0.355418mA
+ 5.97ns 0.354188mA
+ 5.972ns 0.352962mA
+ 5.974ns 0.351741mA
+ 5.976ns 0.350524mA
+ 5.978ns 0.349311mA
+ 5.98ns 0.348103mA
+ 5.982ns 0.346898mA
+ 5.984ns 0.345698mA
+ 5.986ns 0.344502mA
+ 5.988ns 0.34331mA
+ 5.99ns 0.342122mA
+ 5.992ns 0.340938mA
+ 5.994ns 0.339759mA
+ 5.996ns 0.338583mA
+ 5.998ns 0.337411mA
+ 6ns 0.336244mA
+ 6.002ns 0.335081mA
+ 6.004ns 0.333921mA
+ 6.006ns 0.332766mA
+ 6.008ns 0.331614mA
+ 6.01ns 0.330467mA
+ 6.012ns 0.329324mA
+ 6.014ns 0.328184mA
+ 6.016ns 0.327049mA
+ 6.018ns 0.325917mA
+ 6.02ns 0.324789mA
+ 6.022ns 0.323665mA
+ 6.024ns 0.322545mA
+ 6.026ns 0.321429mA
+ 6.028ns 0.320317mA
+ 6.03ns 0.319209mA
+ 6.032ns 0.318104mA
+ 6.034ns 0.317004mA
+ 6.036ns 0.315907mA
+ 6.038ns 0.314814mA
+ 6.04ns 0.313725mA
+ 6.042ns 0.312639mA
+ 6.044ns 0.311557mA
+ 6.046ns 0.310479mA
+ 6.048ns 0.309405mA
+ 6.05ns 0.308334mA
+ 6.052ns 0.307267mA
+ 6.054ns 0.306204mA
+ 6.056ns 0.305145mA
+ 6.058ns 0.304089mA
+ 6.06ns 0.303037mA
+ 6.062ns 0.301988mA
+ 6.064ns 0.300943mA
+ 6.066ns 0.299902mA
+ 6.068ns 0.298864mA
+ 6.07ns 0.29783mA
+ 6.072ns 0.296799mA
+ 6.074ns 0.295773mA
+ 6.076ns 0.294749mA
+ 6.078ns 0.293729mA
+ 6.08ns 0.292713mA
+ 6.082ns 0.2917mA
+ 6.084ns 0.290691mA
+ 6.086ns 0.289685mA
+ 6.088ns 0.288683mA
+ 6.09ns 0.287683mA
+ 6.092ns 0.286688mA
+ 6.094ns 0.285696mA
+ 6.096ns 0.284707mA
+ 6.098ns 0.283722mA
+ 6.1ns 0.282741mA
+ 6.102ns 0.281762mA
+ 6.104ns 0.280787mA
+ 6.106ns 0.279816mA
+ 6.108ns 0.278848mA
+ 6.11ns 0.277883mA
+ 6.112ns 0.276921mA
+ 6.114ns 0.275963mA
+ 6.116ns 0.275008mA
+ 6.118ns 0.274056mA
+ 6.12ns 0.273108mA
+ 6.122ns 0.272163mA
+ 6.124ns 0.271221mA
+ 6.126ns 0.270283mA
+ 6.128ns 0.269348mA
+ 6.13ns 0.268416mA
+ 6.132ns 0.267487mA
+ 6.134ns 0.266561mA
+ 6.136ns 0.265639mA
+ 6.138ns 0.26472mA
+ 6.14ns 0.263804mA
+ 6.142ns 0.262891mA
+ 6.144ns 0.261981mA
+ 6.146ns 0.261075mA
+ 6.148ns 0.260171mA
+ 6.15ns 0.259271mA
+ 6.152ns 0.258374mA
+ 6.154ns 0.25748mA
+ 6.156ns 0.256589mA
+ 6.158ns 0.255701mA
+ 6.16ns 0.254816mA
+ 6.162ns 0.253934mA
+ 6.164ns 0.253056mA
+ 6.166ns 0.25218mA
+ 6.168ns 0.251307mA
+ 6.17ns 0.250438mA
+ 6.172ns 0.249571mA
+ 6.174ns 0.248708mA
+ 6.176ns 0.247847mA
+ 6.178ns 0.246989mA
+ 6.18ns 0.246135mA
+ 6.182ns 0.245283mA
+ 6.184ns 0.244434mA
+ 6.186ns 0.243589mA
+ 6.188ns 0.242745mA
+ 6.19ns 0.241906mA
+ 6.192ns 0.241069mA
+ 6.194ns 0.240234mA
+ 6.196ns 0.239403mA
+ 6.198ns 0.238575mA
+ 6.2ns 0.237749mA
+ 6.202ns 0.236926mA
+ 6.204ns 0mA
I230 439 0 PWL 0 0
+ 5.514ns 0mA
+ 5.516ns 0.00566721mA
+ 5.518ns 0.0134384mA
+ 5.52ns 0.0212097mA
+ 5.522ns 0.0289809mA
+ 5.524ns 0.0367539mA
+ 5.526ns 0.0445252mA
+ 5.528ns 0.0522964mA
+ 5.53ns 0.0600695mA
+ 5.532ns 0.0678407mA
+ 5.534ns 0.0756119mA
+ 5.536ns 0.083385mA
+ 5.538ns 0.0911562mA
+ 5.54ns 0.0989274mA
+ 5.542ns 0.1067mA
+ 5.544ns 0.114472mA
+ 5.546ns 0.122243mA
+ 5.548ns 0.130014mA
+ 5.55ns 0.137787mA
+ 5.552ns 0.145558mA
+ 5.554ns 0.15333mA
+ 5.556ns 0.161103mA
+ 5.558ns 0.168874mA
+ 5.56ns 0.176645mA
+ 5.562ns 0.184418mA
+ 5.564ns 0.192189mA
+ 5.566ns 0.199961mA
+ 5.568ns 0.207732mA
+ 5.57ns 0.215505mA
+ 5.572ns 0.223276mA
+ 5.574ns 0.231047mA
+ 5.576ns 0.238821mA
+ 5.578ns 0.246592mA
+ 5.58ns 0.254363mA
+ 5.582ns 0.262136mA
+ 5.584ns 0.269907mA
+ 5.586ns 0.277678mA
+ 5.588ns 0.285452mA
+ 5.59ns 0.293223mA
+ 5.592ns 0.300994mA
+ 5.594ns 0.308765mA
+ 5.596ns 0.316538mA
+ 5.598ns 0.324309mA
+ 5.6ns 0.332081mA
+ 5.602ns 0.339854mA
+ 5.604ns 0.347625mA
+ 5.606ns 0.355396mA
+ 5.608ns 0.363169mA
+ 5.61ns 0.370941mA
+ 5.612ns 0.378712mA
+ 5.614ns 0.386483mA
+ 5.616ns 0.394256mA
+ 5.618ns 0.402027mA
+ 5.62ns 0.409799mA
+ 5.622ns 0.417572mA
+ 5.624ns 0.425343mA
+ 5.626ns 0.433114mA
+ 5.628ns 0.440887mA
+ 5.63ns 0.448658mA
+ 5.632ns 0.45643mA
+ 5.634ns 0.464203mA
+ 5.636ns 0.471974mA
+ 5.638ns 0.479745mA
+ 5.64ns 0.487516mA
+ 5.642ns 0.495289mA
+ 5.644ns 0.503061mA
+ 5.646ns 0.510832mA
+ 5.648ns 0.518605mA
+ 5.65ns 0.526376mA
+ 5.652ns 0.534147mA
+ 5.654ns 0.54192mA
+ 5.656ns 0.545135mA
+ 5.658ns 0.54279mA
+ 5.66ns 0.540456mA
+ 5.662ns 0.538132mA
+ 5.664ns 0.535818mA
+ 5.666ns 0.533514mA
+ 5.668ns 0.531219mA
+ 5.67ns 0.528934mA
+ 5.672ns 0.52666mA
+ 5.674ns 0.524395mA
+ 5.676ns 0.52214mA
+ 5.678ns 0.519894mA
+ 5.68ns 0.517658mA
+ 5.682ns 0.515432mA
+ 5.684ns 0.513216mA
+ 5.686ns 0.511009mA
+ 5.688ns 0.508811mA
+ 5.69ns 0.506623mA
+ 5.692ns 0.504444mA
+ 5.694ns 0.502274mA
+ 5.696ns 0.500114mA
+ 5.698ns 0.497964mA
+ 5.7ns 0.495822mA
+ 5.702ns 0.49369mA
+ 5.704ns 0.491567mA
+ 5.706ns 0.489453mA
+ 5.708ns 0.487347mA
+ 5.71ns 0.485252mA
+ 5.712ns 0.483165mA
+ 5.714ns 0.481087mA
+ 5.716ns 0.479018mA
+ 5.718ns 0.476958mA
+ 5.72ns 0.474906mA
+ 5.722ns 0.472864mA
+ 5.724ns 0.470831mA
+ 5.726ns 0.468805mA
+ 5.728ns 0.466789mA
+ 5.73ns 0.464782mA
+ 5.732ns 0.462783mA
+ 5.734ns 0.460793mA
+ 5.736ns 0.458811mA
+ 5.738ns 0.456838mA
+ 5.74ns 0.454873mA
+ 5.742ns 0.452917mA
+ 5.744ns 0.450969mA
+ 5.746ns 0.449029mA
+ 5.748ns 0.447098mA
+ 5.75ns 0.445176mA
+ 5.752ns 0.443261mA
+ 5.754ns 0.441355mA
+ 5.756ns 0.439457mA
+ 5.758ns 0.437567mA
+ 5.76ns 0.435685mA
+ 5.762ns 0.433811mA
+ 5.764ns 0.431945mA
+ 5.766ns 0.430087mA
+ 5.768ns 0.428238mA
+ 5.77ns 0.426396mA
+ 5.772ns 0.424562mA
+ 5.774ns 0.422736mA
+ 5.776ns 0.420918mA
+ 5.778ns 0.419108mA
+ 5.78ns 0.417305mA
+ 5.782ns 0.415511mA
+ 5.784ns 0.413724mA
+ 5.786ns 0.411944mA
+ 5.788ns 0.410173mA
+ 5.79ns 0.408409mA
+ 5.792ns 0.406652mA
+ 5.794ns 0.404903mA
+ 5.796ns 0.403162mA
+ 5.798ns 0.401428mA
+ 5.8ns 0.399701mA
+ 5.802ns 0.397982mA
+ 5.804ns 0.396271mA
+ 5.806ns 0.394566mA
+ 5.808ns 0.392869mA
+ 5.81ns 0.39118mA
+ 5.812ns 0.389497mA
+ 5.814ns 0.387822mA
+ 5.816ns 0.386154mA
+ 5.818ns 0.384493mA
+ 5.82ns 0.38284mA
+ 5.822ns 0.381193mA
+ 5.824ns 0.379554mA
+ 5.826ns 0.377921mA
+ 5.828ns 0.376296mA
+ 5.83ns 0.374678mA
+ 5.832ns 0.373066mA
+ 5.834ns 0.371462mA
+ 5.836ns 0.369864mA
+ 5.838ns 0.368273mA
+ 5.84ns 0.366689mA
+ 5.842ns 0.365112mA
+ 5.844ns 0.363542mA
+ 5.846ns 0.361978mA
+ 5.848ns 0.360422mA
+ 5.85ns 0.358871mA
+ 5.852ns 0.357328mA
+ 5.854ns 0.355791mA
+ 5.856ns 0.354261mA
+ 5.858ns 0.352737mA
+ 5.86ns 0.35122mA
+ 5.862ns 0.34971mA
+ 5.864ns 0.348205mA
+ 5.866ns 0.346708mA
+ 5.868ns 0.345217mA
+ 5.87ns 0.343732mA
+ 5.872ns 0.342253mA
+ 5.874ns 0.340781mA
+ 5.876ns 0.339316mA
+ 5.878ns 0.337856mA
+ 5.88ns 0.336403mA
+ 5.882ns 0.334956mA
+ 5.884ns 0.333515mA
+ 5.886ns 0.332081mA
+ 5.888ns 0.330653mA
+ 5.89ns 0.329231mA
+ 5.892ns 0.327815mA
+ 5.894ns 0.326405mA
+ 5.896ns 0.325001mA
+ 5.898ns 0.323603mA
+ 5.9ns 0.322211mA
+ 5.902ns 0.320825mA
+ 5.904ns 0.319445mA
+ 5.906ns 0.318072mA
+ 5.908ns 0.316704mA
+ 5.91ns 0.315341mA
+ 5.912ns 0.313985mA
+ 5.914ns 0.312635mA
+ 5.916ns 0.31129mA
+ 5.918ns 0.309951mA
+ 5.92ns 0.308618mA
+ 5.922ns 0.307291mA
+ 5.924ns 0.305969mA
+ 5.926ns 0.304653mA
+ 5.928ns 0.303343mA
+ 5.93ns 0.302038mA
+ 5.932ns 0.300739mA
+ 5.934ns 0.299445mA
+ 5.936ns 0.298157mA
+ 5.938ns 0.296875mA
+ 5.94ns 0.295598mA
+ 5.942ns 0.294327mA
+ 5.944ns 0.29306mA
+ 5.946ns 0.2918mA
+ 5.948ns 0.290545mA
+ 5.95ns 0.289295mA
+ 5.952ns 0.288051mA
+ 5.954ns 0.286812mA
+ 5.956ns 0.285578mA
+ 5.958ns 0.28435mA
+ 5.96ns 0.283127mA
+ 5.962ns 0.281909mA
+ 5.964ns 0.280697mA
+ 5.966ns 0.279489mA
+ 5.968ns 0.278287mA
+ 5.97ns 0.27709mA
+ 5.972ns 0.275898mA
+ 5.974ns 0.274712mA
+ 5.976ns 0.27353mA
+ 5.978ns 0.272354mA
+ 5.98ns 0.271182mA
+ 5.982ns 0.270016mA
+ 5.984ns 0.268854mA
+ 5.986ns 0.267698mA
+ 5.988ns 0.266547mA
+ 5.99ns 0.2654mA
+ 5.992ns 0.264258mA
+ 5.994ns 0.263122mA
+ 5.996ns 0.26199mA
+ 5.998ns 0.260863mA
+ 6ns 0.259741mA
+ 6.002ns 0.258624mA
+ 6.004ns 0.257511mA
+ 6.006ns 0.256404mA
+ 6.008ns 0.255301mA
+ 6.01ns 0.254203mA
+ 6.012ns 0.253109mA
+ 6.014ns 0.252021mA
+ 6.016ns 0.250937mA
+ 6.018ns 0.249857mA
+ 6.02ns 0.248783mA
+ 6.022ns 0.247713mA
+ 6.024ns 0.246647mA
+ 6.026ns 0.245586mA
+ 6.028ns 0.24453mA
+ 6.03ns 0.243478mA
+ 6.032ns 0.242431mA
+ 6.034ns 0.241388mA
+ 6.036ns 0.24035mA
+ 6.038ns 0.239316mA
+ 6.04ns 0.238287mA
+ 6.042ns 0.237262mA
+ 6.044ns 0.236241mA
+ 6.046ns 0.235225mA
+ 6.048ns 0mA
I231 440 0 PWL 0 0
+ 2.636ns 0mA
+ 2.638ns 0.0026245mA
+ 2.64ns 0.00711002mA
+ 2.642ns 0.011595mA
+ 2.644ns 0.0160805mA
+ 2.646ns 0.0205661mA
+ 2.648ns 0.025051mA
+ 2.65ns 0.0295366mA
+ 2.652ns 0.0340215mA
+ 2.654ns 0.0385071mA
+ 2.656ns 0.0429926mA
+ 2.658ns 0.0474776mA
+ 2.66ns 0.0519631mA
+ 2.662ns 0.0564481mA
+ 2.664ns 0.0609336mA
+ 2.666ns 0.0654191mA
+ 2.668ns 0.0699041mA
+ 2.67ns 0.0743896mA
+ 2.672ns 0.0788746mA
+ 2.674ns 0.0833602mA
+ 2.676ns 0.0878457mA
+ 2.678ns 0.0923307mA
+ 2.68ns 0.0968162mA
+ 2.682ns 0.101301mA
+ 2.684ns 0.105787mA
+ 2.686ns 0.110272mA
+ 2.688ns 0.112358mA
+ 2.69ns 0.108917mA
+ 2.692ns 0.105582mA
+ 2.694ns 0.102349mA
+ 2.696ns 0.0992145mA
+ 2.698ns 0.0961765mA
+ 2.7ns 0.0932311mA
+ 2.702ns 0.090376mA
+ 2.704ns 0.0876085mA
+ 2.706ns 0.0849255mA
+ 2.708ns 0.0823249mA
+ 2.71ns 0.0798037mA
+ 2.712ns 0.0773596mA
+ 2.714ns 0.0749907mA
+ 2.716ns 0.072694mA
+ 2.718ns 0.0704679mA
+ 2.72ns 0.0683097mA
+ 2.722ns 0.0662176mA
+ 2.724ns 0.0641897mA
+ 2.726ns 0.0622238mA
+ 2.728ns 0.0603182mA
+ 2.73ns 0.0584708mA
+ 2.732ns 0.05668mA
+ 2.734ns 0.0549442mA
+ 2.736ns 0.0532613mA
+ 2.738ns 0.0516301mA
+ 2.74ns 0.0500488mA
+ 2.742ns 0.0485158mA
+ 2.744ns 0.04703mA
+ 2.746ns 0.0455895mA
+ 2.748ns 0.044193mA
+ 2.75ns 0.0428396mA
+ 2.752ns 0.0415274mA
+ 2.754ns 0.0402555mA
+ 2.756ns 0.0390224mA
+ 2.758ns 0mA
I232 441 0 PWL 0 0
+ 5.152ns 0mA
+ 5.154ns 0.00255816mA
+ 5.156ns 0.0125872mA
+ 5.158ns 0.0226163mA
+ 5.16ns 0.0326453mA
+ 5.162ns 0.0426768mA
+ 5.164ns 0.0527058mA
+ 5.166ns 0.0627349mA
+ 5.168ns 0.0727663mA
+ 5.17ns 0.0827954mA
+ 5.172ns 0.0928244mA
+ 5.174ns 0.102856mA
+ 5.176ns 0.112885mA
+ 5.178ns 0.122914mA
+ 5.18ns 0.132943mA
+ 5.182ns 0.141778mA
+ 5.184ns 0.128596mA
+ 5.186ns 0.116639mA
+ 5.188ns 0.105792mA
+ 5.19ns 0.0959548mA
+ 5.192ns 0.0870325mA
+ 5.194ns 0.0789378mA
+ 5.196ns 0.0715974mA
+ 5.198ns 0.0649395mA
+ 5.2ns 0.0588992mA
+ 5.202ns 0.0534219mA
+ 5.204ns 0.0484538mA
+ 5.206ns 0.0439476mA
+ 5.208ns 0.0398595mA
+ 5.21ns 0.0361524mA
+ 5.212ns 0mA
+ 7.652ns 0mA
+ 7.654ns 0.00255816mA
+ 7.656ns 0.0125872mA
+ 7.658ns 0.0226163mA
+ 7.66ns 0.0326453mA
+ 7.662ns 0.0426768mA
+ 7.664ns 0.0527058mA
+ 7.666ns 0.0627349mA
+ 7.668ns 0.0727663mA
+ 7.67ns 0.0827954mA
+ 7.672ns 0.0928244mA
+ 7.674ns 0.102856mA
+ 7.676ns 0.112885mA
+ 7.678ns 0.122914mA
+ 7.68ns 0.132945mA
+ 7.682ns 0.141778mA
+ 7.684ns 0.128596mA
+ 7.686ns 0.116639mA
+ 7.688ns 0.105792mA
+ 7.69ns 0.0959548mA
+ 7.692ns 0.0870325mA
+ 7.694ns 0.0789378mA
+ 7.696ns 0.0715974mA
+ 7.698ns 0.0649395mA
+ 7.7ns 0.0588992mA
+ 7.702ns 0.0534219mA
+ 7.704ns 0.0484538mA
+ 7.706ns 0.0439476mA
+ 7.708ns 0.0398595mA
+ 7.71ns 0.0361524mA
+ 7.712ns 0mA
I233 442 0 PWL 0 0
+ 3.006ns 0mA
+ 3.008ns 0.00640158mA
+ 3.01ns 0.0136468mA
+ 3.012ns 0.020893mA
+ 3.014ns 0.0281382mA
+ 3.016ns 0.0353843mA
+ 3.018ns 0.0426305mA
+ 3.02ns 0.0498757mA
+ 3.022ns 0.0571219mA
+ 3.024ns 0.064368mA
+ 3.026ns 0.0716132mA
+ 3.028ns 0.0788594mA
+ 3.03ns 0.0861046mA
+ 3.032ns 0.0933507mA
+ 3.034ns 0.100597mA
+ 3.036ns 0.107842mA
+ 3.038ns 0.115088mA
+ 3.04ns 0.122334mA
+ 3.042ns 0.12958mA
+ 3.044ns 0.136826mA
+ 3.046ns 0.144071mA
+ 3.048ns 0.151317mA
+ 3.05ns 0.158562mA
+ 3.052ns 0.165809mA
+ 3.054ns 0.173055mA
+ 3.056ns 0.1803mA
+ 3.058ns 0.187546mA
+ 3.06ns 0.194791mA
+ 3.062ns 0.202037mA
+ 3.064ns 0.209284mA
+ 3.066ns 0.216529mA
+ 3.068ns 0.223775mA
+ 3.07ns 0.23102mA
+ 3.072ns 0.238266mA
+ 3.074ns 0.245512mA
+ 3.076ns 0.252758mA
+ 3.078ns 0.260004mA
+ 3.08ns 0.26725mA
+ 3.082ns 0.274495mA
+ 3.084ns 0.281741mA
+ 3.086ns 0.288987mA
+ 3.088ns 0.296233mA
+ 3.09ns 0.303479mA
+ 3.092ns 0.310724mA
+ 3.094ns 0.31797mA
+ 3.096ns 0.325215mA
+ 3.098ns 0.332462mA
+ 3.1ns 0.339708mA
+ 3.102ns 0.346953mA
+ 3.104ns 0.354199mA
+ 3.106ns 0.361444mA
+ 3.108ns 0.368691mA
+ 3.11ns 0.375937mA
+ 3.112ns 0.383182mA
+ 3.114ns 0.390428mA
+ 3.116ns 0.397673mA
+ 3.118ns 0.404919mA
+ 3.12ns 0.412166mA
+ 3.122ns 0.419411mA
+ 3.124ns 0.426657mA
+ 3.126ns 0.433903mA
+ 3.128ns 0.441148mA
+ 3.13ns 0.448394mA
+ 3.132ns 0.45564mA
+ 3.134ns 0.462886mA
+ 3.136ns 0.470132mA
+ 3.138ns 0.477377mA
+ 3.14ns 0.484623mA
+ 3.142ns 0.491869mA
+ 3.144ns 0.499115mA
+ 3.146ns 0.506361mA
+ 3.148ns 0.513606mA
+ 3.15ns 0.520852mA
+ 3.152ns 0.528097mA
+ 3.154ns 0.535344mA
+ 3.156ns 0.541151mA
+ 3.158ns 0.538819mA
+ 3.16ns 0.536496mA
+ 3.162ns 0.534184mA
+ 3.164ns 0.531881mA
+ 3.166ns 0.529589mA
+ 3.168ns 0.527306mA
+ 3.17ns 0.525033mA
+ 3.172ns 0.52277mA
+ 3.174ns 0.520517mA
+ 3.176ns 0.518273mA
+ 3.178ns 0.516039mA
+ 3.18ns 0.513815mA
+ 3.182ns 0.5116mA
+ 3.184ns 0.509395mA
+ 3.186ns 0.507199mA
+ 3.188ns 0.505013mA
+ 3.19ns 0.502836mA
+ 3.192ns 0.500669mA
+ 3.194ns 0.498511mA
+ 3.196ns 0.496362mA
+ 3.198ns 0.494222mA
+ 3.2ns 0.492092mA
+ 3.202ns 0.489971mA
+ 3.204ns 0.487859mA
+ 3.206ns 0.485756mA
+ 3.208ns 0.483662mA
+ 3.21ns 0.481577mA
+ 3.212ns 0.479501mA
+ 3.214ns 0.477435mA
+ 3.216ns 0.475377mA
+ 3.218ns 0.473327mA
+ 3.22ns 0.471287mA
+ 3.222ns 0.469256mA
+ 3.224ns 0.467233mA
+ 3.226ns 0.465219mA
+ 3.228ns 0.463214mA
+ 3.23ns 0.461217mA
+ 3.232ns 0.459229mA
+ 3.234ns 0.45725mA
+ 3.236ns 0.455279mA
+ 3.238ns 0.453316mA
+ 3.24ns 0.451362mA
+ 3.242ns 0.449416mA
+ 3.244ns 0.447479mA
+ 3.246ns 0.44555mA
+ 3.248ns 0.44363mA
+ 3.25ns 0.441718mA
+ 3.252ns 0.439813mA
+ 3.254ns 0.437918mA
+ 3.256ns 0.43603mA
+ 3.258ns 0.43415mA
+ 3.26ns 0.432279mA
+ 3.262ns 0.430416mA
+ 3.264ns 0.42856mA
+ 3.266ns 0.426713mA
+ 3.268ns 0.424873mA
+ 3.27ns 0.423042mA
+ 3.272ns 0.421218mA
+ 3.274ns 0.419403mA
+ 3.276ns 0.417595mA
+ 3.278ns 0.415795mA
+ 3.28ns 0.414003mA
+ 3.282ns 0.412218mA
+ 3.284ns 0.410441mA
+ 3.286ns 0.408672mA
+ 3.288ns 0.40691mA
+ 3.29ns 0.405156mA
+ 3.292ns 0.40341mA
+ 3.294ns 0.401671mA
+ 3.296ns 0.399939mA
+ 3.298ns 0.398215mA
+ 3.3ns 0.396499mA
+ 3.302ns 0.394789mA
+ 3.304ns 0.393088mA
+ 3.306ns 0.391393mA
+ 3.308ns 0.389706mA
+ 3.31ns 0.388026mA
+ 3.312ns 0.386353mA
+ 3.314ns 0.384688mA
+ 3.316ns 0.38303mA
+ 3.318ns 0.381379mA
+ 3.32ns 0.379734mA
+ 3.322ns 0.378098mA
+ 3.324ns 0.376468mA
+ 3.326ns 0.374845mA
+ 3.328ns 0.373229mA
+ 3.33ns 0.37162mA
+ 3.332ns 0.370018mA
+ 3.334ns 0.368423mA
+ 3.336ns 0.366835mA
+ 3.338ns 0.365254mA
+ 3.34ns 0.363679mA
+ 3.342ns 0.362111mA
+ 3.344ns 0.36055mA
+ 3.346ns 0.358996mA
+ 3.348ns 0.357449mA
+ 3.35ns 0.355908mA
+ 3.352ns 0.354374mA
+ 3.354ns 0.352846mA
+ 3.356ns 0.351325mA
+ 3.358ns 0.34981mA
+ 3.36ns 0.348302mA
+ 3.362ns 0.346801mA
+ 3.364ns 0.345306mA
+ 3.366ns 0.343817mA
+ 3.368ns 0.342335mA
+ 3.37ns 0.340859mA
+ 3.372ns 0.33939mA
+ 3.374ns 0.337927mA
+ 3.376ns 0.33647mA
+ 3.378ns 0.33502mA
+ 3.38ns 0.333576mA
+ 3.382ns 0.332138mA
+ 3.384ns 0.330706mA
+ 3.386ns 0.32928mA
+ 3.388ns 0.327861mA
+ 3.39ns 0.326447mA
+ 3.392ns 0.32504mA
+ 3.394ns 0.323639mA
+ 3.396ns 0.322244mA
+ 3.398ns 0.320855mA
+ 3.4ns 0.319471mA
+ 3.402ns 0.318094mA
+ 3.404ns 0.316723mA
+ 3.406ns 0.315358mA
+ 3.408ns 0.313998mA
+ 3.41ns 0.312644mA
+ 3.412ns 0.311297mA
+ 3.414ns 0.309955mA
+ 3.416ns 0.308618mA
+ 3.418ns 0.307288mA
+ 3.42ns 0.305963mA
+ 3.422ns 0.304644mA
+ 3.424ns 0.303331mA
+ 3.426ns 0.302023mA
+ 3.428ns 0.300722mA
+ 3.43ns 0.299425mA
+ 3.432ns 0.298134mA
+ 3.434ns 0.296849mA
+ 3.436ns 0.295569mA
+ 3.438ns 0.294295mA
+ 3.44ns 0.293026mA
+ 3.442ns 0.291763mA
+ 3.444ns 0.290505mA
+ 3.446ns 0.289253mA
+ 3.448ns 0.288006mA
+ 3.45ns 0.286764mA
+ 3.452ns 0.285528mA
+ 3.454ns 0.284297mA
+ 3.456ns 0.283072mA
+ 3.458ns 0.281851mA
+ 3.46ns 0.280636mA
+ 3.462ns 0.279426mA
+ 3.464ns 0.278222mA
+ 3.466ns 0.277022mA
+ 3.468ns 0.275828mA
+ 3.47ns 0.274639mA
+ 3.472ns 0.273455mA
+ 3.474ns 0.272276mA
+ 3.476ns 0.271102mA
+ 3.478ns 0.269934mA
+ 3.48ns 0.26877mA
+ 3.482ns 0.267611mA
+ 3.484ns 0.266458mA
+ 3.486ns 0.265309mA
+ 3.488ns 0.264165mA
+ 3.49ns 0.263026mA
+ 3.492ns 0.261892mA
+ 3.494ns 0.260763mA
+ 3.496ns 0.259639mA
+ 3.498ns 0.25852mA
+ 3.5ns 0.257405mA
+ 3.502ns 0.256296mA
+ 3.504ns 0.255191mA
+ 3.506ns 0.254091mA
+ 3.508ns 0.252995mA
+ 3.51ns 0.251904mA
+ 3.512ns 0.250818mA
+ 3.514ns 0.249737mA
+ 3.516ns 0.24866mA
+ 3.518ns 0.247588mA
+ 3.52ns 0.246521mA
+ 3.522ns 0.245458mA
+ 3.524ns 0.2444mA
+ 3.526ns 0.243346mA
+ 3.528ns 0.242297mA
+ 3.53ns 0.241253mA
+ 3.532ns 0.240213mA
+ 3.534ns 0.239177mA
+ 3.536ns 0.238146mA
+ 3.538ns 0.237119mA
+ 3.54ns 0.236097mA
+ 3.542ns 0.235079mA
+ 3.544ns 0.234065mA
+ 3.546ns 0.233056mA
+ 3.548ns 0.232052mA
+ 3.55ns 0.231051mA
+ 3.552ns 0mA
I234 444 0 PWL 0 0
+ 5.516ns 0mA
+ 5.518ns 0.00683631mA
+ 5.52ns 0.0143636mA
+ 5.522ns 0.0218909mA
+ 5.524ns 0.02942mA
+ 5.526ns 0.0369473mA
+ 5.528ns 0.0444746mA
+ 5.53ns 0.0520037mA
+ 5.532ns 0.059531mA
+ 5.534ns 0.0670583mA
+ 5.536ns 0.0745874mA
+ 5.538ns 0.0821147mA
+ 5.54ns 0.089642mA
+ 5.542ns 0.0971711mA
+ 5.544ns 0.104698mA
+ 5.546ns 0.112226mA
+ 5.548ns 0.119753mA
+ 5.55ns 0.127282mA
+ 5.552ns 0.134809mA
+ 5.554ns 0.142337mA
+ 5.556ns 0.149866mA
+ 5.558ns 0.157393mA
+ 5.56ns 0.16492mA
+ 5.562ns 0.172449mA
+ 5.564ns 0.179977mA
+ 5.566ns 0.187504mA
+ 5.568ns 0.195031mA
+ 5.57ns 0.20256mA
+ 5.572ns 0.210088mA
+ 5.574ns 0.217615mA
+ 5.576ns 0.225144mA
+ 5.578ns 0.232671mA
+ 5.58ns 0.240199mA
+ 5.582ns 0.247728mA
+ 5.584ns 0.255255mA
+ 5.586ns 0.262782mA
+ 5.588ns 0.270312mA
+ 5.59ns 0.277839mA
+ 5.592ns 0.285366mA
+ 5.594ns 0.292893mA
+ 5.596ns 0.300423mA
+ 5.598ns 0.30795mA
+ 5.6ns 0.315477mA
+ 5.602ns 0.323006mA
+ 5.604ns 0.330534mA
+ 5.606ns 0.338061mA
+ 5.608ns 0.34559mA
+ 5.61ns 0.353117mA
+ 5.612ns 0.360645mA
+ 5.614ns 0.368172mA
+ 5.616ns 0.375701mA
+ 5.618ns 0.383228mA
+ 5.62ns 0.390756mA
+ 5.622ns 0.398285mA
+ 5.624ns 0.405812mA
+ 5.626ns 0.413339mA
+ 5.628ns 0.420868mA
+ 5.63ns 0.428396mA
+ 5.632ns 0.435923mA
+ 5.634ns 0.443452mA
+ 5.636ns 0.450979mA
+ 5.638ns 0.458507mA
+ 5.64ns 0.466034mA
+ 5.642ns 0.473563mA
+ 5.644ns 0.48109mA
+ 5.646ns 0.488618mA
+ 5.648ns 0.496147mA
+ 5.65ns 0.503674mA
+ 5.652ns 0.511201mA
+ 5.654ns 0.51873mA
+ 5.656ns 0.526258mA
+ 5.658ns 0.533785mA
+ 5.66ns 0.541312mA
+ 5.662ns 0.542413mA
+ 5.664ns 0.540063mA
+ 5.666ns 0.537723mA
+ 5.668ns 0.535393mA
+ 5.67ns 0.533073mA
+ 5.672ns 0.530763mA
+ 5.674ns 0.528463mA
+ 5.676ns 0.526173mA
+ 5.678ns 0.523893mA
+ 5.68ns 0.521622mA
+ 5.682ns 0.519362mA
+ 5.684ns 0.517112mA
+ 5.686ns 0.514871mA
+ 5.688ns 0.51264mA
+ 5.69ns 0.510419mA
+ 5.692ns 0.508207mA
+ 5.694ns 0.506004mA
+ 5.696ns 0.503812mA
+ 5.698ns 0.501629mA
+ 5.7ns 0.499455mA
+ 5.702ns 0.497291mA
+ 5.704ns 0.495136mA
+ 5.706ns 0.49299mA
+ 5.708ns 0.490854mA
+ 5.71ns 0.488727mA
+ 5.712ns 0.486609mA
+ 5.714ns 0.4845mA
+ 5.716ns 0.482401mA
+ 5.718ns 0.48031mA
+ 5.72ns 0.478229mA
+ 5.722ns 0.476157mA
+ 5.724ns 0.474093mA
+ 5.726ns 0.472039mA
+ 5.728ns 0.469993mA
+ 5.73ns 0.467957mA
+ 5.732ns 0.465929mA
+ 5.734ns 0.46391mA
+ 5.736ns 0.461899mA
+ 5.738ns 0.459898mA
+ 5.74ns 0.457905mA
+ 5.742ns 0.455921mA
+ 5.744ns 0.453945mA
+ 5.746ns 0.451978mA
+ 5.748ns 0.450019mA
+ 5.75ns 0.448069mA
+ 5.752ns 0.446128mA
+ 5.754ns 0.444194mA
+ 5.756ns 0.442269mA
+ 5.758ns 0.440353mA
+ 5.76ns 0.438444mA
+ 5.762ns 0.436544mA
+ 5.764ns 0.434653mA
+ 5.766ns 0.432769mA
+ 5.768ns 0.430894mA
+ 5.77ns 0.429026mA
+ 5.772ns 0.427167mA
+ 5.774ns 0.425316mA
+ 5.776ns 0.423473mA
+ 5.778ns 0.421638mA
+ 5.78ns 0.419811mA
+ 5.782ns 0.417991mA
+ 5.784ns 0.41618mA
+ 5.786ns 0.414376mA
+ 5.788ns 0.412581mA
+ 5.79ns 0.410793mA
+ 5.792ns 0.409013mA
+ 5.794ns 0.40724mA
+ 5.796ns 0.405475mA
+ 5.798ns 0.403719mA
+ 5.8ns 0.401969mA
+ 5.802ns 0.400227mA
+ 5.804ns 0.398493mA
+ 5.806ns 0.396765mA
+ 5.808ns 0.395046mA
+ 5.81ns 0.393334mA
+ 5.812ns 0.391629mA
+ 5.814ns 0.389932mA
+ 5.816ns 0.388243mA
+ 5.818ns 0.38656mA
+ 5.82ns 0.384885mA
+ 5.822ns 0.383217mA
+ 5.824ns 0.381556mA
+ 5.826ns 0.379903mA
+ 5.828ns 0.378256mA
+ 5.83ns 0.376617mA
+ 5.832ns 0.374985mA
+ 5.834ns 0.37336mA
+ 5.836ns 0.371742mA
+ 5.838ns 0.370131mA
+ 5.84ns 0.368527mA
+ 5.842ns 0.36693mA
+ 5.844ns 0.36534mA
+ 5.846ns 0.363756mA
+ 5.848ns 0.36218mA
+ 5.85ns 0.360611mA
+ 5.852ns 0.359048mA
+ 5.854ns 0.357492mA
+ 5.856ns 0.355943mA
+ 5.858ns 0.3544mA
+ 5.86ns 0.352864mA
+ 5.862ns 0.351335mA
+ 5.864ns 0.349812mA
+ 5.866ns 0.348296mA
+ 5.868ns 0.346787mA
+ 5.87ns 0.345284mA
+ 5.872ns 0.343788mA
+ 5.874ns 0.342298mA
+ 5.876ns 0.340815mA
+ 5.878ns 0.339337mA
+ 5.88ns 0.337867mA
+ 5.882ns 0.336403mA
+ 5.884ns 0.334945mA
+ 5.886ns 0.333493mA
+ 5.888ns 0.332048mA
+ 5.89ns 0.330609mA
+ 5.892ns 0.329176mA
+ 5.894ns 0.327749mA
+ 5.896ns 0.326329mA
+ 5.898ns 0.324915mA
+ 5.9ns 0.323507mA
+ 5.902ns 0.322105mA
+ 5.904ns 0.320709mA
+ 5.906ns 0.319319mA
+ 5.908ns 0.317935mA
+ 5.91ns 0.316557mA
+ 5.912ns 0.315185mA
+ 5.914ns 0.313819mA
+ 5.916ns 0.312459mA
+ 5.918ns 0.311105mA
+ 5.92ns 0.309757mA
+ 5.922ns 0.308415mA
+ 5.924ns 0.307078mA
+ 5.926ns 0.305747mA
+ 5.928ns 0.304422mA
+ 5.93ns 0.303102mA
+ 5.932ns 0.301789mA
+ 5.934ns 0.300481mA
+ 5.936ns 0.299179mA
+ 5.938ns 0.297882mA
+ 5.94ns 0.296591mA
+ 5.942ns 0.295306mA
+ 5.944ns 0.294026mA
+ 5.946ns 0.292752mA
+ 5.948ns 0.291483mA
+ 5.95ns 0.29022mA
+ 5.952ns 0.288962mA
+ 5.954ns 0.28771mA
+ 5.956ns 0.286463mA
+ 5.958ns 0.285221mA
+ 5.96ns 0.283985mA
+ 5.962ns 0.282754mA
+ 5.964ns 0.281529mA
+ 5.966ns 0.280309mA
+ 5.968ns 0.279094mA
+ 5.97ns 0.277884mA
+ 5.972ns 0.27668mA
+ 5.974ns 0.275481mA
+ 5.976ns 0.274287mA
+ 5.978ns 0.273098mA
+ 5.98ns 0.271915mA
+ 5.982ns 0.270736mA
+ 5.984ns 0.269563mA
+ 5.986ns 0.268394mA
+ 5.988ns 0.267231mA
+ 5.99ns 0.266073mA
+ 5.992ns 0.26492mA
+ 5.994ns 0.263772mA
+ 5.996ns 0.262628mA
+ 5.998ns 0.26149mA
+ 6ns 0.260357mA
+ 6.002ns 0.259229mA
+ 6.004ns 0.258105mA
+ 6.006ns 0.256987mA
+ 6.008ns 0.255873mA
+ 6.01ns 0.254764mA
+ 6.012ns 0.25366mA
+ 6.014ns 0.25256mA
+ 6.016ns 0.251466mA
+ 6.018ns 0.250376mA
+ 6.02ns 0.249291mA
+ 6.022ns 0.24821mA
+ 6.024ns 0.247134mA
+ 6.026ns 0.246063mA
+ 6.028ns 0.244997mA
+ 6.03ns 0.243935mA
+ 6.032ns 0.242878mA
+ 6.034ns 0.241825mA
+ 6.036ns 0.240777mA
+ 6.038ns 0.239733mA
+ 6.04ns 0.238695mA
+ 6.042ns 0.23766mA
+ 6.044ns 0.23663mA
+ 6.046ns 0.235604mA
+ 6.048ns 0.234583mA
+ 6.05ns 0.233566mA
+ 6.052ns 0.232554mA
+ 6.054ns 0mA
I235 446 0 PWL 0 0
+ 2.65ns 0mA
+ 2.652ns 0.00843304mA
+ 2.654ns 0.0196634mA
+ 2.656ns 0.0308938mA
+ 2.658ns 0.0421229mA
+ 2.66ns 0.0533533mA
+ 2.662ns 0.0645824mA
+ 2.664ns 0.0758128mA
+ 2.666ns 0.0817361mA
+ 2.668ns 0.0680273mA
+ 2.67ns 0.0566161mA
+ 2.672ns 0.0471197mA
+ 2.674ns 0.0392149mA
+ 2.676ns 0.032636mA
+ 2.678ns 0.0271612mA
+ 2.68ns 0.0226041mA
+ 2.682ns 0mA
I236 447 0 PWL 0 0
+ 3.072ns 0mA
+ 3.074ns 0.000184237mA
+ 3.076ns 0.00724078mA
+ 3.078ns 0.0142982mA
+ 3.08ns 0.0213555mA
+ 3.082ns 0.0284121mA
+ 3.084ns 0.0354695mA
+ 3.086ns 0.042526mA
+ 3.088ns 0.0495834mA
+ 3.09ns 0.0566408mA
+ 3.092ns 0.0636973mA
+ 3.094ns 0.0707547mA
+ 3.096ns 0.0778112mA
+ 3.098ns 0.0848686mA
+ 3.1ns 0.091926mA
+ 3.102ns 0.0989825mA
+ 3.104ns 0.10604mA
+ 3.106ns 0.113096mA
+ 3.108ns 0.120154mA
+ 3.11ns 0.127211mA
+ 3.112ns 0.134268mA
+ 3.114ns 0.141325mA
+ 3.116ns 0.148382mA
+ 3.118ns 0.155439mA
+ 3.12ns 0.162496mA
+ 3.122ns 0.169553mA
+ 3.124ns 0.17661mA
+ 3.126ns 0.183668mA
+ 3.128ns 0.190724mA
+ 3.13ns 0.197782mA
+ 3.132ns 0.204838mA
+ 3.134ns 0.211896mA
+ 3.136ns 0.218953mA
+ 3.138ns 0.22601mA
+ 3.14ns 0.233067mA
+ 3.142ns 0.240123mA
+ 3.144ns 0.247181mA
+ 3.146ns 0.254238mA
+ 3.148ns 0.261295mA
+ 3.15ns 0.268352mA
+ 3.152ns 0.275409mA
+ 3.154ns 0.282466mA
+ 3.156ns 0.289523mA
+ 3.158ns 0.29658mA
+ 3.16ns 0.303637mA
+ 3.162ns 0.310694mA
+ 3.164ns 0.317751mA
+ 3.166ns 0.324809mA
+ 3.168ns 0.331865mA
+ 3.17ns 0.338923mA
+ 3.172ns 0.34598mA
+ 3.174ns 0.353037mA
+ 3.176ns 0.360094mA
+ 3.178ns 0.36715mA
+ 3.18ns 0.374208mA
+ 3.182ns 0.381265mA
+ 3.184ns 0.388322mA
+ 3.186ns 0.395379mA
+ 3.188ns 0.402436mA
+ 3.19ns 0.409493mA
+ 3.192ns 0.41655mA
+ 3.194ns 0.423607mA
+ 3.196ns 0.430664mA
+ 3.198ns 0.437721mA
+ 3.2ns 0.444778mA
+ 3.202ns 0.451836mA
+ 3.204ns 0.458892mA
+ 3.206ns 0.46595mA
+ 3.208ns 0.473006mA
+ 3.21ns 0.480063mA
+ 3.212ns 0.487121mA
+ 3.214ns 0.494177mA
+ 3.216ns 0.501235mA
+ 3.218ns 0.508292mA
+ 3.22ns 0.515349mA
+ 3.222ns 0.522406mA
+ 3.224ns 0.529463mA
+ 3.226ns 0.534295mA
+ 3.228ns 0.532459mA
+ 3.23ns 0.530629mA
+ 3.232ns 0.528805mA
+ 3.234ns 0.526988mA
+ 3.236ns 0.525177mA
+ 3.238ns 0.523372mA
+ 3.24ns 0.521574mA
+ 3.242ns 0.519781mA
+ 3.244ns 0.517995mA
+ 3.246ns 0.516215mA
+ 3.248ns 0.514441mA
+ 3.25ns 0.512673mA
+ 3.252ns 0.510911mA
+ 3.254ns 0.509156mA
+ 3.256ns 0.507406mA
+ 3.258ns 0.505662mA
+ 3.26ns 0.503925mA
+ 3.262ns 0.502193mA
+ 3.264ns 0.500467mA
+ 3.266ns 0.498747mA
+ 3.268ns 0.497033mA
+ 3.27ns 0.495325mA
+ 3.272ns 0.493623mA
+ 3.274ns 0.491926mA
+ 3.276ns 0.490236mA
+ 3.278ns 0.488551mA
+ 3.28ns 0.486872mA
+ 3.282ns 0.485199mA
+ 3.284ns 0.483532mA
+ 3.286ns 0.48187mA
+ 3.288ns 0.480214mA
+ 3.29ns 0.478564mA
+ 3.292ns 0.476919mA
+ 3.294ns 0.47528mA
+ 3.296ns 0.473647mA
+ 3.298ns 0.472019mA
+ 3.3ns 0.470397mA
+ 3.302ns 0.46878mA
+ 3.304ns 0.467169mA
+ 3.306ns 0.465564mA
+ 3.308ns 0.463964mA
+ 3.31ns 0.462369mA
+ 3.312ns 0.46078mA
+ 3.314ns 0.459197mA
+ 3.316ns 0.457619mA
+ 3.318ns 0.456046mA
+ 3.32ns 0.454479mA
+ 3.322ns 0.452917mA
+ 3.324ns 0.45136mA
+ 3.326ns 0.449809mA
+ 3.328ns 0.448264mA
+ 3.33ns 0.446723mA
+ 3.332ns 0.445188mA
+ 3.334ns 0.443658mA
+ 3.336ns 0.442133mA
+ 3.338ns 0.440614mA
+ 3.34ns 0.439099mA
+ 3.342ns 0.43759mA
+ 3.344ns 0.436087mA
+ 3.346ns 0.434588mA
+ 3.348ns 0.433094mA
+ 3.35ns 0.431606mA
+ 3.352ns 0.430123mA
+ 3.354ns 0.428644mA
+ 3.356ns 0.427171mA
+ 3.358ns 0.425703mA
+ 3.36ns 0.42424mA
+ 3.362ns 0.422782mA
+ 3.364ns 0.421329mA
+ 3.366ns 0.419881mA
+ 3.368ns 0.418438mA
+ 3.37ns 0.417mA
+ 3.372ns 0.415567mA
+ 3.374ns 0.414139mA
+ 3.376ns 0.412716mA
+ 3.378ns 0.411297mA
+ 3.38ns 0.409884mA
+ 3.382ns 0.408475mA
+ 3.384ns 0.407071mA
+ 3.386ns 0.405672mA
+ 3.388ns 0.404278mA
+ 3.39ns 0.402889mA
+ 3.392ns 0.401504mA
+ 3.394ns 0.400124mA
+ 3.396ns 0.398749mA
+ 3.398ns 0.397379mA
+ 3.4ns 0.396013mA
+ 3.402ns 0.394652mA
+ 3.404ns 0.393296mA
+ 3.406ns 0.391944mA
+ 3.408ns 0.390597mA
+ 3.41ns 0.389255mA
+ 3.412ns 0.387917mA
+ 3.414ns 0.386584mA
+ 3.416ns 0.385255mA
+ 3.418ns 0.383931mA
+ 3.42ns 0.382612mA
+ 3.422ns 0.381297mA
+ 3.424ns 0.379986mA
+ 3.426ns 0.37868mA
+ 3.428ns 0.377379mA
+ 3.43ns 0.376082mA
+ 3.432ns 0.374789mA
+ 3.434ns 0.373502mA
+ 3.436ns 0.372218mA
+ 3.438ns 0.370939mA
+ 3.44ns 0.369664mA
+ 3.442ns 0.368393mA
+ 3.444ns 0.367127mA
+ 3.446ns 0.365865mA
+ 3.448ns 0.364608mA
+ 3.45ns 0.363355mA
+ 3.452ns 0.362106mA
+ 3.454ns 0.360862mA
+ 3.456ns 0.359621mA
+ 3.458ns 0.358385mA
+ 3.46ns 0.357154mA
+ 3.462ns 0.355926mA
+ 3.464ns 0.354703mA
+ 3.466ns 0.353484mA
+ 3.468ns 0.352269mA
+ 3.47ns 0.351058mA
+ 3.472ns 0.349852mA
+ 3.474ns 0.34865mA
+ 3.476ns 0.347451mA
+ 3.478ns 0.346257mA
+ 3.48ns 0.345067mA
+ 3.482ns 0.343881mA
+ 3.484ns 0.342699mA
+ 3.486ns 0.341521mA
+ 3.488ns 0.340348mA
+ 3.49ns 0.339178mA
+ 3.492ns 0.338012mA
+ 3.494ns 0.336851mA
+ 3.496ns 0.335693mA
+ 3.498ns 0.334539mA
+ 3.5ns 0.333389mA
+ 3.502ns 0.332244mA
+ 3.504ns 0.331102mA
+ 3.506ns 0.329964mA
+ 3.508ns 0.32883mA
+ 3.51ns 0.3277mA
+ 3.512ns 0.326573mA
+ 3.514ns 0.325451mA
+ 3.516ns 0.324332mA
+ 3.518ns 0.323218mA
+ 3.52ns 0.322107mA
+ 3.522ns 0.321mA
+ 3.524ns 0.319896mA
+ 3.526ns 0.318797mA
+ 3.528ns 0.317701mA
+ 3.53ns 0.316609mA
+ 3.532ns 0.315521mA
+ 3.534ns 0.314437mA
+ 3.536ns 0.313356mA
+ 3.538ns 0.312279mA
+ 3.54ns 0.311206mA
+ 3.542ns 0.310136mA
+ 3.544ns 0.30907mA
+ 3.546ns 0.308008mA
+ 3.548ns 0.306949mA
+ 3.55ns 0.305894mA
+ 3.552ns 0.304843mA
+ 3.554ns 0.303795mA
+ 3.556ns 0.302751mA
+ 3.558ns 0.301711mA
+ 3.56ns 0.300674mA
+ 3.562ns 0.29964mA
+ 3.564ns 0.29861mA
+ 3.566ns 0.297584mA
+ 3.568ns 0.296561mA
+ 3.57ns 0.295542mA
+ 3.572ns 0.294526mA
+ 3.574ns 0.293514mA
+ 3.576ns 0.292505mA
+ 3.578ns 0.2915mA
+ 3.58ns 0.290498mA
+ 3.582ns 0.2895mA
+ 3.584ns 0.288504mA
+ 3.586ns 0.287513mA
+ 3.588ns 0.286525mA
+ 3.59ns 0.28554mA
+ 3.592ns 0.284559mA
+ 3.594ns 0.283581mA
+ 3.596ns 0.282606mA
+ 3.598ns 0.281635mA
+ 3.6ns 0.280667mA
+ 3.602ns 0.279702mA
+ 3.604ns 0.278741mA
+ 3.606ns 0.277782mA
+ 3.608ns 0.276828mA
+ 3.61ns 0.275876mA
+ 3.612ns 0.274928mA
+ 3.614ns 0.273983mA
+ 3.616ns 0.273041mA
+ 3.618ns 0.272103mA
+ 3.62ns 0.271168mA
+ 3.622ns 0.270236mA
+ 3.624ns 0.269307mA
+ 3.626ns 0.268381mA
+ 3.628ns 0.267459mA
+ 3.63ns 0.26654mA
+ 3.632ns 0.265624mA
+ 3.634ns 0.26471mA
+ 3.636ns 0.263801mA
+ 3.638ns 0.262894mA
+ 3.64ns 0.26199mA
+ 3.642ns 0.26109mA
+ 3.644ns 0.260192mA
+ 3.646ns 0.259298mA
+ 3.648ns 0.258407mA
+ 3.65ns 0.257519mA
+ 3.652ns 0.256634mA
+ 3.654ns 0.255752mA
+ 3.656ns 0.254873mA
+ 3.658ns 0.253997mA
+ 3.66ns 0.253123mA
+ 3.662ns 0.252253mA
+ 3.664ns 0.251386mA
+ 3.666ns 0.250522mA
+ 3.668ns 0.249661mA
+ 3.67ns 0.248803mA
+ 3.672ns 0.247948mA
+ 3.674ns 0.247096mA
+ 3.676ns 0.246247mA
+ 3.678ns 0.2454mA
+ 3.68ns 0.244557mA
+ 3.682ns 0.243716mA
+ 3.684ns 0.242878mA
+ 3.686ns 0.242044mA
+ 3.688ns 0.241212mA
+ 3.69ns 0.240383mA
+ 3.692ns 0.239556mA
+ 3.694ns 0.238733mA
+ 3.696ns 0.237912mA
+ 3.698ns 0.237095mA
+ 3.7ns 0.23628mA
+ 3.702ns 0.235468mA
+ 3.704ns 0mA
I237 448 0 PWL 0 0
+ 0.502ns 0mA
+ 0.504ns 0.00512289mA
+ 0.506ns 0.0126989mA
+ 0.508ns 0.0202746mA
+ 0.51ns 0.0278506mA
+ 0.512ns 0.0354263mA
+ 0.514ns 0.043002mA
+ 0.516ns 0.050578mA
+ 0.518ns 0.0581537mA
+ 0.52ns 0.0657297mA
+ 0.522ns 0.0733054mA
+ 0.524ns 0.0808814mA
+ 0.526ns 0.0884572mA
+ 0.528ns 0.0960329mA
+ 0.53ns 0.103609mA
+ 0.532ns 0.111185mA
+ 0.534ns 0.118761mA
+ 0.536ns 0.126336mA
+ 0.538ns 0.133912mA
+ 0.54ns 0.141488mA
+ 0.542ns 0.149064mA
+ 0.544ns 0.15664mA
+ 0.546ns 0.164215mA
+ 0.548ns 0.171791mA
+ 0.55ns 0.179367mA
+ 0.552ns 0.186943mA
+ 0.554ns 0.194519mA
+ 0.556ns 0.202095mA
+ 0.558ns 0.209671mA
+ 0.56ns 0.217246mA
+ 0.562ns 0.224822mA
+ 0.564ns 0.232398mA
+ 0.566ns 0.239974mA
+ 0.568ns 0.24755mA
+ 0.57ns 0.255126mA
+ 0.572ns 0.262701mA
+ 0.574ns 0.270277mA
+ 0.576ns 0.277853mA
+ 0.578ns 0.285429mA
+ 0.58ns 0.293005mA
+ 0.582ns 0.300581mA
+ 0.584ns 0.308157mA
+ 0.586ns 0.315732mA
+ 0.588ns 0.323308mA
+ 0.59ns 0.330884mA
+ 0.592ns 0.33846mA
+ 0.594ns 0.346036mA
+ 0.596ns 0.353611mA
+ 0.598ns 0.361187mA
+ 0.6ns 0.368763mA
+ 0.602ns 0.376339mA
+ 0.604ns 0.383915mA
+ 0.606ns 0.391491mA
+ 0.608ns 0.399067mA
+ 0.61ns 0.406642mA
+ 0.612ns 0.414218mA
+ 0.614ns 0.421794mA
+ 0.616ns 0.42937mA
+ 0.618ns 0.436946mA
+ 0.62ns 0.444521mA
+ 0.622ns 0.452097mA
+ 0.624ns 0.459673mA
+ 0.626ns 0.467249mA
+ 0.628ns 0.474825mA
+ 0.63ns 0.482401mA
+ 0.632ns 0.489977mA
+ 0.634ns 0.497552mA
+ 0.636ns 0.505128mA
+ 0.638ns 0.512704mA
+ 0.64ns 0.52028mA
+ 0.642ns 0.527856mA
+ 0.644ns 0.535432mA
+ 0.646ns 0.543007mA
+ 0.648ns 0.543623mA
+ 0.65ns 0.541264mA
+ 0.652ns 0.538915mA
+ 0.654ns 0.536577mA
+ 0.656ns 0.534248mA
+ 0.658ns 0.53193mA
+ 0.66ns 0.529622mA
+ 0.662ns 0.527324mA
+ 0.664ns 0.525036mA
+ 0.666ns 0.522757mA
+ 0.668ns 0.520489mA
+ 0.67ns 0.51823mA
+ 0.672ns 0.515982mA
+ 0.674ns 0.513743mA
+ 0.676ns 0.511513mA
+ 0.678ns 0.509294mA
+ 0.68ns 0.507084mA
+ 0.682ns 0.504884mA
+ 0.684ns 0.502693mA
+ 0.686ns 0.500511mA
+ 0.688ns 0.49834mA
+ 0.69ns 0.496177mA
+ 0.692ns 0.494024mA
+ 0.694ns 0.49188mA
+ 0.696ns 0.489746mA
+ 0.698ns 0.487621mA
+ 0.7ns 0.485505mA
+ 0.702ns 0.483398mA
+ 0.704ns 0.4813mA
+ 0.706ns 0.479212mA
+ 0.708ns 0.477133mA
+ 0.71ns 0.475062mA
+ 0.712ns 0.473001mA
+ 0.714ns 0.470948mA
+ 0.716ns 0.468904mA
+ 0.718ns 0.46687mA
+ 0.72ns 0.464844mA
+ 0.722ns 0.462827mA
+ 0.724ns 0.460818mA
+ 0.726ns 0.458819mA
+ 0.728ns 0.456828mA
+ 0.73ns 0.454845mA
+ 0.732ns 0.452872mA
+ 0.734ns 0.450906mA
+ 0.736ns 0.44895mA
+ 0.738ns 0.447002mA
+ 0.74ns 0.445062mA
+ 0.742ns 0.443131mA
+ 0.744ns 0.441208mA
+ 0.746ns 0.439293mA
+ 0.748ns 0.437387mA
+ 0.75ns 0.435489mA
+ 0.752ns 0.433599mA
+ 0.754ns 0.431717mA
+ 0.756ns 0.429844mA
+ 0.758ns 0.427979mA
+ 0.76ns 0.426121mA
+ 0.762ns 0.424272mA
+ 0.764ns 0.422431mA
+ 0.766ns 0.420598mA
+ 0.768ns 0.418773mA
+ 0.77ns 0.416956mA
+ 0.772ns 0.415146mA
+ 0.774ns 0.413345mA
+ 0.776ns 0.411551mA
+ 0.778ns 0.409765mA
+ 0.78ns 0.407987mA
+ 0.782ns 0.406217mA
+ 0.784ns 0.404454mA
+ 0.786ns 0.402699mA
+ 0.788ns 0.400951mA
+ 0.79ns 0.399211mA
+ 0.792ns 0.397479mA
+ 0.794ns 0.395754mA
+ 0.796ns 0.394037mA
+ 0.798ns 0.392327mA
+ 0.8ns 0.390624mA
+ 0.802ns 0.388929mA
+ 0.804ns 0.387241mA
+ 0.806ns 0.385561mA
+ 0.808ns 0.383888mA
+ 0.81ns 0.382222mA
+ 0.812ns 0.380563mA
+ 0.814ns 0.378911mA
+ 0.816ns 0.377267mA
+ 0.818ns 0.37563mA
+ 0.82ns 0.374mA
+ 0.822ns 0.372377mA
+ 0.824ns 0.370761mA
+ 0.826ns 0.369152mA
+ 0.828ns 0.36755mA
+ 0.83ns 0.365955mA
+ 0.832ns 0.364367mA
+ 0.834ns 0.362786mA
+ 0.836ns 0.361211mA
+ 0.838ns 0.359644mA
+ 0.84ns 0.358083mA
+ 0.842ns 0.356529mA
+ 0.844ns 0.354982mA
+ 0.846ns 0.353441mA
+ 0.848ns 0.351908mA
+ 0.85ns 0.35038mA
+ 0.852ns 0.34886mA
+ 0.854ns 0.347346mA
+ 0.856ns 0.345839mA
+ 0.858ns 0.344338mA
+ 0.86ns 0.342843mA
+ 0.862ns 0.341356mA
+ 0.864ns 0.339874mA
+ 0.866ns 0.338399mA
+ 0.868ns 0.336931mA
+ 0.87ns 0.335469mA
+ 0.872ns 0.334013mA
+ 0.874ns 0.332563mA
+ 0.876ns 0.33112mA
+ 0.878ns 0.329683mA
+ 0.88ns 0.328252mA
+ 0.882ns 0.326828mA
+ 0.884ns 0.325409mA
+ 0.886ns 0.323997mA
+ 0.888ns 0.322591mA
+ 0.89ns 0.321191mA
+ 0.892ns 0.319797mA
+ 0.894ns 0.318409mA
+ 0.896ns 0.317028mA
+ 0.898ns 0.315652mA
+ 0.9ns 0.314282mA
+ 0.902ns 0.312918mA
+ 0.904ns 0.31156mA
+ 0.906ns 0.310208mA
+ 0.908ns 0.308862mA
+ 0.91ns 0.307521mA
+ 0.912ns 0.306187mA
+ 0.914ns 0.304858mA
+ 0.916ns 0.303535mA
+ 0.918ns 0.302218mA
+ 0.92ns 0.300906mA
+ 0.922ns 0.2996mA
+ 0.924ns 0.2983mA
+ 0.926ns 0.297005mA
+ 0.928ns 0.295716mA
+ 0.93ns 0.294433mA
+ 0.932ns 0.293155mA
+ 0.934ns 0.291883mA
+ 0.936ns 0.290616mA
+ 0.938ns 0.289355mA
+ 0.94ns 0.288099mA
+ 0.942ns 0.286849mA
+ 0.944ns 0.285604mA
+ 0.946ns 0.284365mA
+ 0.948ns 0.28313mA
+ 0.95ns 0.281902mA
+ 0.952ns 0.280678mA
+ 0.954ns 0.27946mA
+ 0.956ns 0.278247mA
+ 0.958ns 0.27704mA
+ 0.96ns 0.275837mA
+ 0.962ns 0.27464mA
+ 0.964ns 0.273448mA
+ 0.966ns 0.272262mA
+ 0.968ns 0.27108mA
+ 0.97ns 0.269904mA
+ 0.972ns 0.268732mA
+ 0.974ns 0.267566mA
+ 0.976ns 0.266405mA
+ 0.978ns 0.265249mA
+ 0.98ns 0.264097mA
+ 0.982ns 0.262951mA
+ 0.984ns 0.26181mA
+ 0.986ns 0.260674mA
+ 0.988ns 0.259542mA
+ 0.99ns 0.258416mA
+ 0.992ns 0.257295mA
+ 0.994ns 0.256178mA
+ 0.996ns 0.255066mA
+ 0.998ns 0.253959mA
+ 1ns 0.252857mA
+ 1.002ns 0.251759mA
+ 1.004ns 0.250667mA
+ 1.006ns 0.249579mA
+ 1.008ns 0.248496mA
+ 1.01ns 0.247417mA
+ 1.012ns 0.246344mA
+ 1.014ns 0.245274mA
+ 1.016ns 0.24421mA
+ 1.018ns 0.24315mA
+ 1.02ns 0.242095mA
+ 1.022ns 0.241044mA
+ 1.024ns 0.239998mA
+ 1.026ns 0.238956mA
+ 1.028ns 0.237919mA
+ 1.03ns 0.236887mA
+ 1.032ns 0.235858mA
+ 1.034ns 0.234835mA
+ 1.036ns 0.233816mA
+ 1.038ns 0mA
I238 450 0 PWL 0 0
+ 0.52ns 0mA
+ 0.522ns 0.00507251mA
+ 0.524ns 0.0126145mA
+ 0.526ns 0.0201563mA
+ 0.528ns 0.0276981mA
+ 0.53ns 0.0352401mA
+ 0.532ns 0.0427819mA
+ 0.534ns 0.0503239mA
+ 0.536ns 0.0578657mA
+ 0.538ns 0.0654077mA
+ 0.54ns 0.0729495mA
+ 0.542ns 0.0804915mA
+ 0.544ns 0.0880333mA
+ 0.546ns 0.0955751mA
+ 0.548ns 0.103117mA
+ 0.55ns 0.110659mA
+ 0.552ns 0.118201mA
+ 0.554ns 0.125743mA
+ 0.556ns 0.133285mA
+ 0.558ns 0.140827mA
+ 0.56ns 0.148368mA
+ 0.562ns 0.15591mA
+ 0.564ns 0.163452mA
+ 0.566ns 0.170994mA
+ 0.568ns 0.178536mA
+ 0.57ns 0.186078mA
+ 0.572ns 0.19362mA
+ 0.574ns 0.201161mA
+ 0.576ns 0.208704mA
+ 0.578ns 0.216245mA
+ 0.58ns 0.223787mA
+ 0.582ns 0.231329mA
+ 0.584ns 0.238871mA
+ 0.586ns 0.246413mA
+ 0.588ns 0.253955mA
+ 0.59ns 0.261497mA
+ 0.592ns 0.269038mA
+ 0.594ns 0.27658mA
+ 0.596ns 0.284122mA
+ 0.598ns 0.291664mA
+ 0.6ns 0.299206mA
+ 0.602ns 0.306748mA
+ 0.604ns 0.31429mA
+ 0.606ns 0.321832mA
+ 0.608ns 0.329374mA
+ 0.61ns 0.336915mA
+ 0.612ns 0.344457mA
+ 0.614ns 0.351999mA
+ 0.616ns 0.359541mA
+ 0.618ns 0.367083mA
+ 0.62ns 0.374625mA
+ 0.622ns 0.382167mA
+ 0.624ns 0.389709mA
+ 0.626ns 0.397251mA
+ 0.628ns 0.404792mA
+ 0.63ns 0.412334mA
+ 0.632ns 0.419876mA
+ 0.634ns 0.427418mA
+ 0.636ns 0.43496mA
+ 0.638ns 0.442502mA
+ 0.64ns 0.450044mA
+ 0.642ns 0.457586mA
+ 0.644ns 0.465128mA
+ 0.646ns 0.472669mA
+ 0.648ns 0.480211mA
+ 0.65ns 0.487753mA
+ 0.652ns 0.495295mA
+ 0.654ns 0.502837mA
+ 0.656ns 0.510379mA
+ 0.658ns 0.517921mA
+ 0.66ns 0.525463mA
+ 0.662ns 0.533005mA
+ 0.664ns 0.540546mA
+ 0.666ns 0.543139mA
+ 0.668ns 0.54079mA
+ 0.67ns 0.538452mA
+ 0.672ns 0.536124mA
+ 0.674ns 0.533805mA
+ 0.676ns 0.531497mA
+ 0.678ns 0.529199mA
+ 0.68ns 0.526911mA
+ 0.682ns 0.524632mA
+ 0.684ns 0.522364mA
+ 0.686ns 0.520105mA
+ 0.688ns 0.517856mA
+ 0.69ns 0.515616mA
+ 0.692ns 0.513387mA
+ 0.694ns 0.511167mA
+ 0.696ns 0.508956mA
+ 0.698ns 0.506756mA
+ 0.7ns 0.504564mA
+ 0.702ns 0.502383mA
+ 0.704ns 0.50021mA
+ 0.706ns 0.498047mA
+ 0.708ns 0.495894mA
+ 0.71ns 0.493749mA
+ 0.712ns 0.491614mA
+ 0.714ns 0.489488mA
+ 0.716ns 0.487372mA
+ 0.718ns 0.485264mA
+ 0.72ns 0.483166mA
+ 0.722ns 0.481076mA
+ 0.724ns 0.478996mA
+ 0.726ns 0.476925mA
+ 0.728ns 0.474862mA
+ 0.73ns 0.472809mA
+ 0.732ns 0.470765mA
+ 0.734ns 0.468729mA
+ 0.736ns 0.466702mA
+ 0.738ns 0.464684mA
+ 0.74ns 0.462674mA
+ 0.742ns 0.460674mA
+ 0.744ns 0.458682mA
+ 0.746ns 0.456698mA
+ 0.748ns 0.454723mA
+ 0.75ns 0.452757mA
+ 0.752ns 0.450799mA
+ 0.754ns 0.44885mA
+ 0.756ns 0.446909mA
+ 0.758ns 0.444976mA
+ 0.76ns 0.443052mA
+ 0.762ns 0.441136mA
+ 0.764ns 0.439228mA
+ 0.766ns 0.437329mA
+ 0.768ns 0.435438mA
+ 0.77ns 0.433555mA
+ 0.772ns 0.43168mA
+ 0.774ns 0.429813mA
+ 0.776ns 0.427955mA
+ 0.778ns 0.426104mA
+ 0.78ns 0.424261mA
+ 0.782ns 0.422427mA
+ 0.784ns 0.4206mA
+ 0.786ns 0.418781mA
+ 0.788ns 0.41697mA
+ 0.79ns 0.415167mA
+ 0.792ns 0.413372mA
+ 0.794ns 0.411584mA
+ 0.796ns 0.409804mA
+ 0.798ns 0.408032mA
+ 0.8ns 0.406268mA
+ 0.802ns 0.404511mA
+ 0.804ns 0.402762mA
+ 0.806ns 0.40102mA
+ 0.808ns 0.399286mA
+ 0.81ns 0.397559mA
+ 0.812ns 0.39584mA
+ 0.814ns 0.394128mA
+ 0.816ns 0.392424mA
+ 0.818ns 0.390727mA
+ 0.82ns 0.389037mA
+ 0.822ns 0.387354mA
+ 0.824ns 0.385679mA
+ 0.826ns 0.384012mA
+ 0.828ns 0.382351mA
+ 0.83ns 0.380697mA
+ 0.832ns 0.379051mA
+ 0.834ns 0.377412mA
+ 0.836ns 0.37578mA
+ 0.838ns 0.374155mA
+ 0.84ns 0.372537mA
+ 0.842ns 0.370926mA
+ 0.844ns 0.369322mA
+ 0.846ns 0.367725mA
+ 0.848ns 0.366134mA
+ 0.85ns 0.364551mA
+ 0.852ns 0.362974mA
+ 0.854ns 0.361405mA
+ 0.856ns 0.359842mA
+ 0.858ns 0.358286mA
+ 0.86ns 0.356736mA
+ 0.862ns 0.355193mA
+ 0.864ns 0.353657mA
+ 0.866ns 0.352128mA
+ 0.868ns 0.350605mA
+ 0.87ns 0.349089mA
+ 0.872ns 0.347579mA
+ 0.874ns 0.346076mA
+ 0.876ns 0.34458mA
+ 0.878ns 0.343089mA
+ 0.88ns 0.341606mA
+ 0.882ns 0.340128mA
+ 0.884ns 0.338657mA
+ 0.886ns 0.337193mA
+ 0.888ns 0.335735mA
+ 0.89ns 0.334283mA
+ 0.892ns 0.332837mA
+ 0.894ns 0.331398mA
+ 0.896ns 0.329965mA
+ 0.898ns 0.328538mA
+ 0.9ns 0.327117mA
+ 0.902ns 0.325702mA
+ 0.904ns 0.324294mA
+ 0.906ns 0.322891mA
+ 0.908ns 0.321495mA
+ 0.91ns 0.320104mA
+ 0.912ns 0.31872mA
+ 0.914ns 0.317342mA
+ 0.916ns 0.315969mA
+ 0.918ns 0.314603mA
+ 0.92ns 0.313242mA
+ 0.922ns 0.311888mA
+ 0.924ns 0.310539mA
+ 0.926ns 0.309196mA
+ 0.928ns 0.307859mA
+ 0.93ns 0.306527mA
+ 0.932ns 0.305202mA
+ 0.934ns 0.303882mA
+ 0.936ns 0.302568mA
+ 0.938ns 0.301259mA
+ 0.94ns 0.299956mA
+ 0.942ns 0.298659mA
+ 0.944ns 0.297367mA
+ 0.946ns 0.296081mA
+ 0.948ns 0.294801mA
+ 0.95ns 0.293526mA
+ 0.952ns 0.292256mA
+ 0.954ns 0.290992mA
+ 0.956ns 0.289734mA
+ 0.958ns 0.288481mA
+ 0.96ns 0.287233mA
+ 0.962ns 0.285991mA
+ 0.964ns 0.284754mA
+ 0.966ns 0.283523mA
+ 0.968ns 0.282297mA
+ 0.97ns 0.281076mA
+ 0.972ns 0.27986mA
+ 0.974ns 0.27865mA
+ 0.976ns 0.277445mA
+ 0.978ns 0.276245mA
+ 0.98ns 0.27505mA
+ 0.982ns 0.273861mA
+ 0.984ns 0.272676mA
+ 0.986ns 0.271497mA
+ 0.988ns 0.270323mA
+ 0.99ns 0.269154mA
+ 0.992ns 0.26799mA
+ 0.994ns 0.266831mA
+ 0.996ns 0.265677mA
+ 0.998ns 0.264528mA
+ 1ns 0.263384mA
+ 1.002ns 0.262244mA
+ 1.004ns 0.26111mA
+ 1.006ns 0.259981mA
+ 1.008ns 0.258857mA
+ 1.01ns 0.257737mA
+ 1.012ns 0.256622mA
+ 1.014ns 0.255513mA
+ 1.016ns 0.254407mA
+ 1.018ns 0.253307mA
+ 1.02ns 0.252212mA
+ 1.022ns 0.251121mA
+ 1.024ns 0.250035mA
+ 1.026ns 0.248953mA
+ 1.028ns 0.247877mA
+ 1.03ns 0.246805mA
+ 1.032ns 0.245737mA
+ 1.034ns 0.244674mA
+ 1.036ns 0.243616mA
+ 1.038ns 0.242563mA
+ 1.04ns 0.241514mA
+ 1.042ns 0.240469mA
+ 1.044ns 0.239429mA
+ 1.046ns 0.238393mA
+ 1.048ns 0.237362mA
+ 1.05ns 0.236336mA
+ 1.052ns 0.235314mA
+ 1.054ns 0.234296mA
+ 1.056ns 0.233283mA
+ 1.058ns 0mA
I239 451 0 PWL 0 0
+ 7.65ns 0mA
+ 7.652ns 0.00628372mA
+ 7.654ns 0.0176807mA
+ 7.656ns 0.029075mA
+ 7.658ns 0.0404693mA
+ 7.66ns 0.0518636mA
+ 7.662ns 0.0632606mA
+ 7.664ns 0.074655mA
+ 7.666ns 0.0860493mA
+ 7.668ns 0.0803308mA
+ 7.67ns 0.0674043mA
+ 7.672ns 0.0565574mA
+ 7.674ns 0.0474537mA
+ 7.676ns 0.0398167mA
+ 7.678ns 0.0334085mA
+ 7.68ns 0.0280303mA
+ 7.682ns 0.0235187mA
+ 7.684ns 0mA
I240 459 0 PWL 0 0
+ 7.58ns 0mA
+ 7.582ns 0.000232109mA
+ 7.584ns 0.00119491mA
+ 7.586ns 0.00215771mA
+ 7.588ns 0.00312074mA
+ 7.59ns 0.00408353mA
+ 7.592ns 0.00504633mA
+ 7.594ns 0.00600913mA
+ 7.596ns 0.00697216mA
+ 7.598ns 0.00793496mA
+ 7.6ns 0.00889776mA
+ 7.602ns 0.00986079mA
+ 7.604ns 0.0108236mA
+ 7.606ns 0.0117864mA
+ 7.608ns 0.0127494mA
+ 7.61ns 0.0137122mA
+ 7.612ns 0.014675mA
+ 7.614ns 0.0156378mA
+ 7.616ns 0.0166008mA
+ 7.618ns 0.0175636mA
+ 7.62ns 0.0185264mA
+ 7.622ns 0.0194895mA
+ 7.624ns 0.0204523mA
+ 7.626ns 0.0214151mA
+ 7.628ns 0.0223781mA
+ 7.63ns 0.0233409mA
+ 7.632ns 0.0243037mA
+ 7.634ns 0.0252667mA
+ 7.636ns 0.0262295mA
+ 7.638ns 0.0271923mA
+ 7.64ns 0.0281551mA
+ 7.642ns 0.0291181mA
+ 7.644ns 0.0300809mA
+ 7.646ns 0.0310437mA
+ 7.648ns 0.0320068mA
+ 7.65ns 0.0329696mA
+ 7.652ns 0.0339324mA
+ 7.654ns 0.0348954mA
+ 7.656ns 0.0358582mA
+ 7.658ns 0.036821mA
+ 7.66ns 0.0377838mA
+ 7.662ns 0.0387468mA
+ 7.664ns 0.0397096mA
+ 7.666ns 0.0406724mA
+ 7.668ns 0.0416354mA
+ 7.67ns 0.0425982mA
+ 7.672ns 0.043561mA
+ 7.674ns 0.0445241mA
+ 7.676ns 0.0454869mA
+ 7.678ns 0.0464497mA
+ 7.68ns 0.0474127mA
+ 7.682ns 0.0483755mA
+ 7.684ns 0.0493383mA
+ 7.686ns 0.0503011mA
+ 7.688ns 0.0512641mA
+ 7.69ns 0.0522269mA
+ 7.692ns 0.0531897mA
+ 7.694ns 0.0541527mA
+ 7.696ns 0.0532875mA
+ 7.698ns 0.0519947mA
+ 7.7ns 0.0507329mA
+ 7.702ns 0.0495021mA
+ 7.704ns 0.0483011mA
+ 7.706ns 0.0471292mA
+ 7.708ns 0.0459855mA
+ 7.71ns 0.0448698mA
+ 7.712ns 0.0437812mA
+ 7.714ns 0.0427187mA
+ 7.716ns 0.0416822mA
+ 7.718ns 0.0406709mA
+ 7.72ns 0.0396839mA
+ 7.722ns 0.038721mA
+ 7.724ns 0.0377816mA
+ 7.726ns 0.0368646mA
+ 7.728ns 0.0359702mA
+ 7.73ns 0.0350974mA
+ 7.732ns 0.0342458mA
+ 7.734ns 0.0334147mA
+ 7.736ns 0.0326039mA
+ 7.738ns 0.0318128mA
+ 7.74ns 0.0310407mA
+ 7.742ns 0.0302875mA
+ 7.744ns 0.0295526mA
+ 7.746ns 0.0288354mA
+ 7.748ns 0.0281357mA
+ 7.75ns 0.027453mA
+ 7.752ns 0.0267868mA
+ 7.754ns 0.0261367mA
+ 7.756ns 0.0255025mA
+ 7.758ns 0.0248837mA
+ 7.76ns 0.0242797mA
+ 7.762ns 0.0236905mA
+ 7.764ns 0.0231157mA
+ 7.766ns 0.0225546mA
+ 7.768ns 0.0220073mA
+ 7.77ns 0.0214733mA
+ 7.772ns 0.020952mA
+ 7.774ns 0.0204436mA
+ 7.776ns 0.0199475mA
+ 7.778ns 0.0194634mA
+ 7.78ns 0.018991mA
+ 7.782ns 0.0185302mA
+ 7.784ns 0.0180805mA
+ 7.786ns 0.0176416mA
+ 7.788ns 0.0172135mA
+ 7.79ns 0.0167958mA
+ 7.792ns 0.0163881mA
+ 7.794ns 0.0159904mA
+ 7.796ns 0.0156023mA
+ 7.798ns 0.0152237mA
+ 7.8ns 0.0148541mA
+ 7.802ns 0.0144936mA
+ 7.804ns 0.0141419mA
+ 7.806ns 0.0137986mA
+ 7.808ns 0mA
I241 464 0 PWL 0 0
+ 7.56ns 0mA
+ 7.562ns 0.00114279mA
+ 7.564ns 0.00514857mA
+ 7.566ns 0.00915436mA
+ 7.568ns 0.0131601mA
+ 7.57ns 0.0171669mA
+ 7.572ns 0.0211727mA
+ 7.574ns 0.0251785mA
+ 7.576ns 0.0291852mA
+ 7.578ns 0.033191mA
+ 7.58ns 0.0371968mA
+ 7.582ns 0.0412035mA
+ 7.584ns 0.0395989mA
+ 7.586ns 0.0347808mA
+ 7.588ns 0.0305479mA
+ 7.59ns 0.0268308mA
+ 7.592ns 0.0235659mA
+ 7.594ns 0.0206983mA
+ 7.596ns 0.0181789mA
+ 7.598ns 0.0159666mA
+ 7.6ns 0.0140235mA
+ 7.602ns 0.0123164mA
+ 7.604ns 0.0108175mA
+ 7.606ns 0mA
I242 468 0 PWL 0 0
+ 0.15ns 0mA
+ 0.152ns 0.00747998mA
+ 0.154ns 0.0187709mA
+ 0.156ns 0.0300617mA
+ 0.158ns 0.0413526mA
+ 0.16ns 0.0526435mA
+ 0.162ns 0.0639344mA
+ 0.164ns 0.0752253mA
+ 0.166ns 0.086516mA
+ 0.168ns 0.0721975mA
+ 0.17ns 0.0602483mA
+ 0.172ns 0.0502763mA
+ 0.174ns 0.0419545mA
+ 0.176ns 0.0350098mA
+ 0.178ns 0.0292145mA
+ 0.18ns 0.0243783mA
+ 0.182ns 0mA
+ 5.15ns 0mA
+ 5.152ns 0.00748023mA
+ 5.154ns 0.018773mA
+ 5.156ns 0.0300631mA
+ 5.158ns 0.0413531mA
+ 5.16ns 0.0526432mA
+ 5.162ns 0.063936mA
+ 5.164ns 0.075226mA
+ 5.166ns 0.0865161mA
+ 5.168ns 0.0721954mA
+ 5.17ns 0.0602473mA
+ 5.172ns 0.0502761mA
+ 5.174ns 0.0419531mA
+ 5.176ns 0.0350092mA
+ 5.178ns 0.0292143mA
+ 5.18ns 0.0243785mA
+ 5.182ns 0mA
I243 469 0 PWL 0 0
+ 3.142ns 0mA
+ 3.144ns 0.00244671mA
+ 3.146ns 0.00716465mA
+ 3.148ns 0.011882mA
+ 3.15ns 0.0166mA
+ 3.152ns 0.0213173mA
+ 3.154ns 0.0260353mA
+ 3.156ns 0.0307532mA
+ 3.158ns 0.0354706mA
+ 3.16ns 0.0401886mA
+ 3.162ns 0.0449059mA
+ 3.164ns 0.0496239mA
+ 3.166ns 0.0543418mA
+ 3.168ns 0.0590592mA
+ 3.17ns 0.0637771mA
+ 3.172ns 0.0684951mA
+ 3.174ns 0.0732125mA
+ 3.176ns 0.0779304mA
+ 3.178ns 0.0826478mA
+ 3.18ns 0.0873657mA
+ 3.182ns 0.0920837mA
+ 3.184ns 0.0968011mA
+ 3.186ns 0.101519mA
+ 3.188ns 0.106236mA
+ 3.19ns 0.110954mA
+ 3.192ns 0.115672mA
+ 3.194ns 0.12039mA
+ 3.196ns 0.125108mA
+ 3.198ns 0.129825mA
+ 3.2ns 0.134543mA
+ 3.202ns 0.139261mA
+ 3.204ns 0.143978mA
+ 3.206ns 0.148696mA
+ 3.208ns 0.153414mA
+ 3.21ns 0.158131mA
+ 3.212ns 0.162849mA
+ 3.214ns 0.167567mA
+ 3.216ns 0.172285mA
+ 3.218ns 0.177003mA
+ 3.22ns 0.18172mA
+ 3.222ns 0.186438mA
+ 3.224ns 0.191155mA
+ 3.226ns 0.195873mA
+ 3.228ns 0.200591mA
+ 3.23ns 0.205309mA
+ 3.232ns 0.210027mA
+ 3.234ns 0.214744mA
+ 3.236ns 0.219462mA
+ 3.238ns 0.22418mA
+ 3.24ns 0.228897mA
+ 3.242ns 0.233615mA
+ 3.244ns 0.238333mA
+ 3.246ns 0.243051mA
+ 3.248ns 0.247768mA
+ 3.25ns 0.252486mA
+ 3.252ns 0.257204mA
+ 3.254ns 0.261921mA
+ 3.256ns 0.266639mA
+ 3.258ns 0.271357mA
+ 3.26ns 0.276074mA
+ 3.262ns 0.280792mA
+ 3.264ns 0.28551mA
+ 3.266ns 0.290228mA
+ 3.268ns 0.294946mA
+ 3.27ns 0.299663mA
+ 3.272ns 0.304381mA
+ 3.274ns 0.309099mA
+ 3.276ns 0.313816mA
+ 3.278ns 0.318534mA
+ 3.28ns 0.323252mA
+ 3.282ns 0.32797mA
+ 3.284ns 0.332687mA
+ 3.286ns 0.337405mA
+ 3.288ns 0.342123mA
+ 3.29ns 0.34684mA
+ 3.292ns 0.351558mA
+ 3.294ns 0.356276mA
+ 3.296ns 0.360993mA
+ 3.298ns 0.365711mA
+ 3.3ns 0.370429mA
+ 3.302ns 0.375147mA
+ 3.304ns 0.379865mA
+ 3.306ns 0.384582mA
+ 3.308ns 0.3893mA
+ 3.31ns 0.394018mA
+ 3.312ns 0.398735mA
+ 3.314ns 0.403453mA
+ 3.316ns 0.408171mA
+ 3.318ns 0.412889mA
+ 3.32ns 0.417607mA
+ 3.322ns 0.422324mA
+ 3.324ns 0.427042mA
+ 3.326ns 0.431759mA
+ 3.328ns 0.436477mA
+ 3.33ns 0.441195mA
+ 3.332ns 0.445913mA
+ 3.334ns 0.44559mA
+ 3.336ns 0.444013mA
+ 3.338ns 0.442442mA
+ 3.34ns 0.440876mA
+ 3.342ns 0.439316mA
+ 3.344ns 0.437762mA
+ 3.346ns 0.436213mA
+ 3.348ns 0.434669mA
+ 3.35ns 0.433131mA
+ 3.352ns 0.431598mA
+ 3.354ns 0.430071mA
+ 3.356ns 0.428549mA
+ 3.358ns 0.427033mA
+ 3.36ns 0.425521mA
+ 3.362ns 0.424016mA
+ 3.364ns 0.422515mA
+ 3.366ns 0.42102mA
+ 3.368ns 0.41953mA
+ 3.37ns 0.418046mA
+ 3.372ns 0.416566mA
+ 3.374ns 0.415092mA
+ 3.376ns 0.413623mA
+ 3.378ns 0.41216mA
+ 3.38ns 0.410701mA
+ 3.382ns 0.409248mA
+ 3.384ns 0.4078mA
+ 3.386ns 0.406357mA
+ 3.388ns 0.404919mA
+ 3.39ns 0.403486mA
+ 3.392ns 0.402058mA
+ 3.394ns 0.400635mA
+ 3.396ns 0.399217mA
+ 3.398ns 0.397805mA
+ 3.4ns 0.396397mA
+ 3.402ns 0.394994mA
+ 3.404ns 0.393597mA
+ 3.406ns 0.392204mA
+ 3.408ns 0.390816mA
+ 3.41ns 0.389433mA
+ 3.412ns 0.388055mA
+ 3.414ns 0.386681mA
+ 3.416ns 0.385313mA
+ 3.418ns 0.38395mA
+ 3.42ns 0.382591mA
+ 3.422ns 0.381237mA
+ 3.424ns 0.379888mA
+ 3.426ns 0.378543mA
+ 3.428ns 0.377204mA
+ 3.43ns 0.375869mA
+ 3.432ns 0.374539mA
+ 3.434ns 0.373214mA
+ 3.436ns 0.371893mA
+ 3.438ns 0.370577mA
+ 3.44ns 0.369265mA
+ 3.442ns 0.367959mA
+ 3.444ns 0.366657mA
+ 3.446ns 0.365359mA
+ 3.448ns 0.364066mA
+ 3.45ns 0.362778mA
+ 3.452ns 0.361494mA
+ 3.454ns 0.360215mA
+ 3.456ns 0.35894mA
+ 3.458ns 0.35767mA
+ 3.46ns 0.356404mA
+ 3.462ns 0.355143mA
+ 3.464ns 0.353886mA
+ 3.466ns 0.352634mA
+ 3.468ns 0.351386mA
+ 3.47ns 0.350142mA
+ 3.472ns 0.348903mA
+ 3.474ns 0.347669mA
+ 3.476ns 0.346438mA
+ 3.478ns 0.345212mA
+ 3.48ns 0.343991mA
+ 3.482ns 0.342773mA
+ 3.484ns 0.34156mA
+ 3.486ns 0.340351mA
+ 3.488ns 0.339147mA
+ 3.49ns 0.337947mA
+ 3.492ns 0.336751mA
+ 3.494ns 0.335559mA
+ 3.496ns 0.334372mA
+ 3.498ns 0.333188mA
+ 3.5ns 0.332009mA
+ 3.502ns 0.330834mA
+ 3.504ns 0.329663mA
+ 3.506ns 0.328497mA
+ 3.508ns 0.327334mA
+ 3.51ns 0.326176mA
+ 3.512ns 0.325022mA
+ 3.514ns 0.323871mA
+ 3.516ns 0.322725mA
+ 3.518ns 0.321583mA
+ 3.52ns 0.320445mA
+ 3.522ns 0.319311mA
+ 3.524ns 0.318181mA
+ 3.526ns 0.317055mA
+ 3.528ns 0.315933mA
+ 3.53ns 0.314815mA
+ 3.532ns 0.313701mA
+ 3.534ns 0.312591mA
+ 3.536ns 0.311485mA
+ 3.538ns 0.310382mA
+ 3.54ns 0.309284mA
+ 3.542ns 0.308189mA
+ 3.544ns 0.307099mA
+ 3.546ns 0.306012mA
+ 3.548ns 0.304929mA
+ 3.55ns 0.30385mA
+ 3.552ns 0.302774mA
+ 3.554ns 0.301703mA
+ 3.556ns 0.300635mA
+ 3.558ns 0.299571mA
+ 3.56ns 0.298511mA
+ 3.562ns 0.297455mA
+ 3.564ns 0.296402mA
+ 3.566ns 0.295353mA
+ 3.568ns 0.294308mA
+ 3.57ns 0.293266mA
+ 3.572ns 0.292228mA
+ 3.574ns 0.291194mA
+ 3.576ns 0.290164mA
+ 3.578ns 0.289137mA
+ 3.58ns 0.288113mA
+ 3.582ns 0.287094mA
+ 3.584ns 0.286078mA
+ 3.586ns 0.285065mA
+ 3.588ns 0.284057mA
+ 3.59ns 0.283051mA
+ 3.592ns 0.28205mA
+ 3.594ns 0.281051mA
+ 3.596ns 0.280057mA
+ 3.598ns 0.279066mA
+ 3.6ns 0.278078mA
+ 3.602ns 0.277094mA
+ 3.604ns 0.276113mA
+ 3.606ns 0.275136mA
+ 3.608ns 0.274162mA
+ 3.61ns 0.273192mA
+ 3.612ns 0.272225mA
+ 3.614ns 0.271262mA
+ 3.616ns 0.270302mA
+ 3.618ns 0.269345mA
+ 3.62ns 0.268392mA
+ 3.622ns 0.267442mA
+ 3.624ns 0.266496mA
+ 3.626ns 0.265552mA
+ 3.628ns 0.264613mA
+ 3.63ns 0.263676mA
+ 3.632ns 0.262743mA
+ 3.634ns 0.261813mA
+ 3.636ns 0.260887mA
+ 3.638ns 0.259963mA
+ 3.64ns 0.259043mA
+ 3.642ns 0.258127mA
+ 3.644ns 0.257213mA
+ 3.646ns 0.256303mA
+ 3.648ns 0.255396mA
+ 3.65ns 0.254492mA
+ 3.652ns 0.253591mA
+ 3.654ns 0.252694mA
+ 3.656ns 0.251799mA
+ 3.658ns 0.250908mA
+ 3.66ns 0.25002mA
+ 3.662ns 0.249135mA
+ 3.664ns 0.248254mA
+ 3.666ns 0.247375mA
+ 3.668ns 0.246499mA
+ 3.67ns 0.245627mA
+ 3.672ns 0.244758mA
+ 3.674ns 0.243892mA
+ 3.676ns 0.243028mA
+ 3.678ns 0.242168mA
+ 3.68ns 0.241311mA
+ 3.682ns 0.240457mA
+ 3.684ns 0.239606mA
+ 3.686ns 0.238758mA
+ 3.688ns 0.237913mA
+ 3.69ns 0.237071mA
+ 3.692ns 0.236232mA
+ 3.694ns 0.235396mA
+ 3.696ns 0.234563mA
+ 3.698ns 0.233733mA
+ 3.7ns 0.232906mA
+ 3.702ns 0.232081mA
+ 3.704ns 0.23126mA
+ 3.706ns 0.230441mA
+ 3.708ns 0.229626mA
+ 3.71ns 0.228813mA
+ 3.712ns 0.228003mA
+ 3.714ns 0.227196mA
+ 3.716ns 0.226392mA
+ 3.718ns 0.225591mA
+ 3.72ns 0.224793mA
+ 3.722ns 0.223997mA
+ 3.724ns 0.223204mA
+ 3.726ns 0.222414mA
+ 3.728ns 0.221627mA
+ 3.73ns 0.220843mA
+ 3.732ns 0.220061mA
+ 3.734ns 0.219282mA
+ 3.736ns 0.218506mA
+ 3.738ns 0.217733mA
+ 3.74ns 0.216962mA
+ 3.742ns 0.216194mA
+ 3.744ns 0.215429mA
+ 3.746ns 0.214667mA
+ 3.748ns 0.213907mA
+ 3.75ns 0.21315mA
+ 3.752ns 0.212395mA
+ 3.754ns 0.211644mA
+ 3.756ns 0.210895mA
+ 3.758ns 0.210148mA
+ 3.76ns 0.209405mA
+ 3.762ns 0.208663mA
+ 3.764ns 0.207925mA
+ 3.766ns 0.207189mA
+ 3.768ns 0.206456mA
+ 3.77ns 0.205725mA
+ 3.772ns 0.204997mA
+ 3.774ns 0.204271mA
+ 3.776ns 0.203548mA
+ 3.778ns 0.202828mA
+ 3.78ns 0.20211mA
+ 3.782ns 0.201395mA
+ 3.784ns 0.200682mA
+ 3.786ns 0.199972mA
+ 3.788ns 0.199264mA
+ 3.79ns 0.198559mA
+ 3.792ns 0.197856mA
+ 3.794ns 0.197156mA
+ 3.796ns 0.196458mA
+ 3.798ns 0.195762mA
+ 3.8ns 0.19507mA
+ 3.802ns 0.194379mA
+ 3.804ns 0.193691mA
+ 3.806ns 0.193006mA
+ 3.808ns 0.192323mA
+ 3.81ns 0.191642mA
+ 3.812ns 0.190964mA
+ 3.814ns 0.190288mA
+ 3.816ns 0.189614mA
+ 3.818ns 0.188943mA
+ 3.82ns 0mA
I244 471 0 PWL 0 0
+ 5.146ns 0mA
+ 5.148ns 0.00302936mA
+ 5.15ns 0.00727707mA
+ 5.152ns 0.0115248mA
+ 5.154ns 0.0157735mA
+ 5.156ns 0.0200212mA
+ 5.158ns 0.0242689mA
+ 5.16ns 0.0285166mA
+ 5.162ns 0.0327653mA
+ 5.164ns 0.037013mA
+ 5.166ns 0.0412607mA
+ 5.168ns 0.0455095mA
+ 5.17ns 0.0497572mA
+ 5.172ns 0.0540049mA
+ 5.174ns 0.0582536mA
+ 5.176ns 0.0625013mA
+ 5.178ns 0.066749mA
+ 5.18ns 0.0709967mA
+ 5.182ns 0.0752454mA
+ 5.184ns 0.0794931mA
+ 5.186ns 0.0837408mA
+ 5.188ns 0.0879896mA
+ 5.19ns 0.0922373mA
+ 5.192ns 0.096485mA
+ 5.194ns 0.100734mA
+ 5.196ns 0.104981mA
+ 5.198ns 0.109229mA
+ 5.2ns 0.113478mA
+ 5.202ns 0.117726mA
+ 5.204ns 0.121973mA
+ 5.206ns 0.126221mA
+ 5.208ns 0.13047mA
+ 5.21ns 0.131159mA
+ 5.212ns 0.128339mA
+ 5.214ns 0.125579mA
+ 5.216ns 0.122879mA
+ 5.218ns 0.120237mA
+ 5.22ns 0.117652mA
+ 5.222ns 0.115122mA
+ 5.224ns 0.112647mA
+ 5.226ns 0.110225mA
+ 5.228ns 0.107855mA
+ 5.23ns 0.105536mA
+ 5.232ns 0.103267mA
+ 5.234ns 0.101046mA
+ 5.236ns 0.0988732mA
+ 5.238ns 0.0967473mA
+ 5.24ns 0.0946667mA
+ 5.242ns 0.0926313mA
+ 5.244ns 0.0906396mA
+ 5.246ns 0.0886903mA
+ 5.248ns 0.0867833mA
+ 5.25ns 0.0849173mA
+ 5.252ns 0.0830914mA
+ 5.254ns 0.0813044mA
+ 5.256ns 0.0795562mA
+ 5.258ns 0.0778456mA
+ 5.26ns 0.0761714mA
+ 5.262ns 0.0745335mA
+ 5.264ns 0.0729309mA
+ 5.266ns 0.0713623mA
+ 5.268ns 0.0698278mA
+ 5.27ns 0.0683263mA
+ 5.272ns 0.0668571mA
+ 5.274ns 0.0654192mA
+ 5.276ns 0.0640125mA
+ 5.278ns 0.062636mA
+ 5.28ns 0.0612888mA
+ 5.282ns 0.0599709mA
+ 5.284ns 0.0586813mA
+ 5.286ns 0.0574192mA
+ 5.288ns 0.0561844mA
+ 5.29ns 0.0549763mA
+ 5.292ns 0.0537938mA
+ 5.294ns 0.052637mA
+ 5.296ns 0.0515051mA
+ 5.298ns 0.0503975mA
+ 5.3ns 0.0493135mA
+ 5.302ns 0.048253mA
+ 5.304ns 0mA
I245 473 0 PWL 0 0
+ 5.512ns 0mA
+ 5.514ns 0.00195362mA
+ 5.516ns 0.00949747mA
+ 5.518ns 0.0170395mA
+ 5.52ns 0.0245816mA
+ 5.522ns 0.0321236mA
+ 5.524ns 0.0396675mA
+ 5.526ns 0.0472095mA
+ 5.528ns 0.0547516mA
+ 5.53ns 0.0622954mA
+ 5.532ns 0.0698375mA
+ 5.534ns 0.0773795mA
+ 5.536ns 0.0849234mA
+ 5.538ns 0.0924654mA
+ 5.54ns 0.100007mA
+ 5.542ns 0.107551mA
+ 5.544ns 0.115093mA
+ 5.546ns 0.122635mA
+ 5.548ns 0.130177mA
+ 5.55ns 0.137721mA
+ 5.552ns 0.145263mA
+ 5.554ns 0.152805mA
+ 5.556ns 0.160349mA
+ 5.558ns 0.167891mA
+ 5.56ns 0.175433mA
+ 5.562ns 0.182977mA
+ 5.564ns 0.190519mA
+ 5.566ns 0.198061mA
+ 5.568ns 0.205603mA
+ 5.57ns 0.213147mA
+ 5.572ns 0.220689mA
+ 5.574ns 0.228231mA
+ 5.576ns 0.235775mA
+ 5.578ns 0.243317mA
+ 5.58ns 0.250859mA
+ 5.582ns 0.258403mA
+ 5.584ns 0.265945mA
+ 5.586ns 0.273487mA
+ 5.588ns 0.281031mA
+ 5.59ns 0.288573mA
+ 5.592ns 0.296115mA
+ 5.594ns 0.303657mA
+ 5.596ns 0.311201mA
+ 5.598ns 0.318743mA
+ 5.6ns 0.326285mA
+ 5.602ns 0.333829mA
+ 5.604ns 0.341371mA
+ 5.606ns 0.348913mA
+ 5.608ns 0.356457mA
+ 5.61ns 0.363999mA
+ 5.612ns 0.371541mA
+ 5.614ns 0.379083mA
+ 5.616ns 0.386627mA
+ 5.618ns 0.394169mA
+ 5.62ns 0.401711mA
+ 5.622ns 0.409255mA
+ 5.624ns 0.416797mA
+ 5.626ns 0.424339mA
+ 5.628ns 0.431883mA
+ 5.63ns 0.439425mA
+ 5.632ns 0.446967mA
+ 5.634ns 0.454511mA
+ 5.636ns 0.462053mA
+ 5.638ns 0.469595mA
+ 5.64ns 0.477137mA
+ 5.642ns 0.484681mA
+ 5.644ns 0.492223mA
+ 5.646ns 0.499765mA
+ 5.648ns 0.507309mA
+ 5.65ns 0.514851mA
+ 5.652ns 0.522393mA
+ 5.654ns 0.529937mA
+ 5.656ns 0.537479mA
+ 5.658ns 0.544525mA
+ 5.66ns 0.542164mA
+ 5.662ns 0.539812mA
+ 5.664ns 0.537472mA
+ 5.666ns 0.535141mA
+ 5.668ns 0.53282mA
+ 5.67ns 0.53051mA
+ 5.672ns 0.52821mA
+ 5.674ns 0.525919mA
+ 5.676ns 0.523639mA
+ 5.678ns 0.521368mA
+ 5.68ns 0.519107mA
+ 5.682ns 0.516856mA
+ 5.684ns 0.514615mA
+ 5.686ns 0.512384mA
+ 5.688ns 0.510162mA
+ 5.69ns 0.50795mA
+ 5.692ns 0.505747mA
+ 5.694ns 0.503554mA
+ 5.696ns 0.501371mA
+ 5.698ns 0.499197mA
+ 5.7ns 0.497032mA
+ 5.702ns 0.494877mA
+ 5.704ns 0.492731mA
+ 5.706ns 0.490594mA
+ 5.708ns 0.488467mA
+ 5.71ns 0.486349mA
+ 5.712ns 0.48424mA
+ 5.714ns 0.48214mA
+ 5.716ns 0.480049mA
+ 5.718ns 0.477968mA
+ 5.72ns 0.475895mA
+ 5.722ns 0.473831mA
+ 5.724ns 0.471777mA
+ 5.726ns 0.46973mA
+ 5.728ns 0.467694mA
+ 5.73ns 0.465666mA
+ 5.732ns 0.463647mA
+ 5.734ns 0.461636mA
+ 5.736ns 0.459634mA
+ 5.738ns 0.457641mA
+ 5.74ns 0.455656mA
+ 5.742ns 0.453681mA
+ 5.744ns 0.451713mA
+ 5.746ns 0.449754mA
+ 5.748ns 0.447804mA
+ 5.75ns 0.445862mA
+ 5.752ns 0.443929mA
+ 5.754ns 0.442004mA
+ 5.756ns 0.440087mA
+ 5.758ns 0.438179mA
+ 5.76ns 0.436278mA
+ 5.762ns 0.434387mA
+ 5.764ns 0.432503mA
+ 5.766ns 0.430627mA
+ 5.768ns 0.42876mA
+ 5.77ns 0.426901mA
+ 5.772ns 0.425049mA
+ 5.774ns 0.423206mA
+ 5.776ns 0.421371mA
+ 5.778ns 0.419544mA
+ 5.78ns 0.417724mA
+ 5.782ns 0.415913mA
+ 5.784ns 0.41411mA
+ 5.786ns 0.412314mA
+ 5.788ns 0.410526mA
+ 5.79ns 0.408746mA
+ 5.792ns 0.406973mA
+ 5.794ns 0.405208mA
+ 5.796ns 0.403451mA
+ 5.798ns 0.401702mA
+ 5.8ns 0.399959mA
+ 5.802ns 0.398225mA
+ 5.804ns 0.396498mA
+ 5.806ns 0.394779mA
+ 5.808ns 0.393067mA
+ 5.81ns 0.391362mA
+ 5.812ns 0.389665mA
+ 5.814ns 0.387975mA
+ 5.816ns 0.386293mA
+ 5.818ns 0.384617mA
+ 5.82ns 0.38295mA
+ 5.822ns 0.381289mA
+ 5.824ns 0.379636mA
+ 5.826ns 0.377989mA
+ 5.828ns 0.37635mA
+ 5.83ns 0.374718mA
+ 5.832ns 0.373093mA
+ 5.834ns 0.371475mA
+ 5.836ns 0.369864mA
+ 5.838ns 0.36826mA
+ 5.84ns 0.366663mA
+ 5.842ns 0.365073mA
+ 5.844ns 0.36349mA
+ 5.846ns 0.361913mA
+ 5.848ns 0.360344mA
+ 5.85ns 0.358782mA
+ 5.852ns 0.357225mA
+ 5.854ns 0.355676mA
+ 5.856ns 0.354134mA
+ 5.858ns 0.352598mA
+ 5.86ns 0.351069mA
+ 5.862ns 0.349547mA
+ 5.864ns 0.348031mA
+ 5.866ns 0.346521mA
+ 5.868ns 0.345019mA
+ 5.87ns 0.343523mA
+ 5.872ns 0.342033mA
+ 5.874ns 0.340549mA
+ 5.876ns 0.339073mA
+ 5.878ns 0.337602mA
+ 5.88ns 0.336138mA
+ 5.882ns 0.33468mA
+ 5.884ns 0.333229mA
+ 5.886ns 0.331784mA
+ 5.888ns 0.330345mA
+ 5.89ns 0.328913mA
+ 5.892ns 0.327486mA
+ 5.894ns 0.326066mA
+ 5.896ns 0.324652mA
+ 5.898ns 0.323244mA
+ 5.9ns 0.321842mA
+ 5.902ns 0.320446mA
+ 5.904ns 0.319056mA
+ 5.906ns 0.317673mA
+ 5.908ns 0.316295mA
+ 5.91ns 0.314923mA
+ 5.912ns 0.313558mA
+ 5.914ns 0.312198mA
+ 5.916ns 0.310844mA
+ 5.918ns 0.309496mA
+ 5.92ns 0.308154mA
+ 5.922ns 0.306817mA
+ 5.924ns 0.305487mA
+ 5.926ns 0.304162mA
+ 5.928ns 0.302843mA
+ 5.93ns 0.301529mA
+ 5.932ns 0.300222mA
+ 5.934ns 0.29892mA
+ 5.936ns 0.297624mA
+ 5.938ns 0.296333mA
+ 5.94ns 0.295048mA
+ 5.942ns 0.293768mA
+ 5.944ns 0.292494mA
+ 5.946ns 0.291225mA
+ 5.948ns 0.289963mA
+ 5.95ns 0.288705mA
+ 5.952ns 0.287453mA
+ 5.954ns 0.286206mA
+ 5.956ns 0.284965mA
+ 5.958ns 0.283729mA
+ 5.96ns 0.282499mA
+ 5.962ns 0.281274mA
+ 5.964ns 0.280053mA
+ 5.966ns 0.278839mA
+ 5.968ns 0.27763mA
+ 5.97ns 0.276426mA
+ 5.972ns 0.275227mA
+ 5.974ns 0.274033mA
+ 5.976ns 0.272845mA
+ 5.978ns 0.271661mA
+ 5.98ns 0.270483mA
+ 5.982ns 0.26931mA
+ 5.984ns 0.268142mA
+ 5.986ns 0.266979mA
+ 5.988ns 0.265822mA
+ 5.99ns 0.264669mA
+ 5.992ns 0.263521mA
+ 5.994ns 0.262378mA
+ 5.996ns 0.26124mA
+ 5.998ns 0.260107mA
+ 6ns 0.258979mA
+ 6.002ns 0.257856mA
+ 6.004ns 0.256737mA
+ 6.006ns 0.255624mA
+ 6.008ns 0.254515mA
+ 6.01ns 0.253411mA
+ 6.012ns 0.252312mA
+ 6.014ns 0.251218mA
+ 6.016ns 0.250129mA
+ 6.018ns 0.249044mA
+ 6.02ns 0.247964mA
+ 6.022ns 0.246888mA
+ 6.024ns 0.245817mA
+ 6.026ns 0.244751mA
+ 6.028ns 0.24369mA
+ 6.03ns 0.242633mA
+ 6.032ns 0.241581mA
+ 6.034ns 0.240533mA
+ 6.036ns 0.23949mA
+ 6.038ns 0.238451mA
+ 6.04ns 0.237417mA
+ 6.042ns 0.236387mA
+ 6.044ns 0.235362mA
+ 6.046ns 0.234341mA
+ 6.048ns 0.233325mA
+ 6.05ns 0mA
+ 8.012ns 0mA
+ 8.014ns 0.00195362mA
+ 8.016ns 0.00949567mA
+ 8.018ns 0.0170377mA
+ 8.02ns 0.0245834mA
+ 8.022ns 0.0321254mA
+ 8.024ns 0.0396675mA
+ 8.026ns 0.0472095mA
+ 8.028ns 0.0547516mA
+ 8.03ns 0.0622936mA
+ 8.032ns 0.0698357mA
+ 8.034ns 0.0773813mA
+ 8.036ns 0.0849234mA
+ 8.038ns 0.0924654mA
+ 8.04ns 0.100007mA
+ 8.042ns 0.10755mA
+ 8.044ns 0.115092mA
+ 8.046ns 0.122634mA
+ 8.048ns 0.130179mA
+ 8.05ns 0.137721mA
+ 8.052ns 0.145263mA
+ 8.054ns 0.152805mA
+ 8.056ns 0.160347mA
+ 8.058ns 0.16789mA
+ 8.06ns 0.175435mA
+ 8.062ns 0.182977mA
+ 8.064ns 0.190519mA
+ 8.066ns 0.198061mA
+ 8.068ns 0.205603mA
+ 8.07ns 0.213145mA
+ 8.072ns 0.220687mA
+ 8.074ns 0.228233mA
+ 8.076ns 0.235775mA
+ 8.078ns 0.243317mA
+ 8.08ns 0.250859mA
+ 8.082ns 0.258401mA
+ 8.084ns 0.265943mA
+ 8.086ns 0.273489mA
+ 8.088ns 0.281031mA
+ 8.09ns 0.288573mA
+ 8.092ns 0.296115mA
+ 8.094ns 0.303657mA
+ 8.096ns 0.311199mA
+ 8.098ns 0.318741mA
+ 8.1ns 0.326287mA
+ 8.102ns 0.333829mA
+ 8.104ns 0.341371mA
+ 8.106ns 0.348913mA
+ 8.108ns 0.356455mA
+ 8.11ns 0.363997mA
+ 8.112ns 0.371543mA
+ 8.114ns 0.379085mA
+ 8.116ns 0.386627mA
+ 8.118ns 0.394169mA
+ 8.12ns 0.401711mA
+ 8.122ns 0.409253mA
+ 8.124ns 0.416795mA
+ 8.126ns 0.424341mA
+ 8.128ns 0.431883mA
+ 8.13ns 0.439425mA
+ 8.132ns 0.446967mA
+ 8.134ns 0.454509mA
+ 8.136ns 0.462051mA
+ 8.138ns 0.469593mA
+ 8.14ns 0.477139mA
+ 8.142ns 0.484681mA
+ 8.144ns 0.492223mA
+ 8.146ns 0.499765mA
+ 8.148ns 0.507307mA
+ 8.15ns 0.514849mA
+ 8.152ns 0.522395mA
+ 8.154ns 0.529937mA
+ 8.156ns 0.537479mA
+ 8.158ns 0.544525mA
+ 8.16ns 0.542164mA
+ 8.162ns 0.539813mA
+ 8.164ns 0.537472mA
+ 8.166ns 0.535141mA
+ 8.168ns 0.53282mA
+ 8.17ns 0.53051mA
+ 8.172ns 0.52821mA
+ 8.174ns 0.52592mA
+ 8.176ns 0.523639mA
+ 8.178ns 0.521368mA
+ 8.18ns 0.519107mA
+ 8.182ns 0.516856mA
+ 8.184ns 0.514615mA
+ 8.186ns 0.512384mA
+ 8.188ns 0.510162mA
+ 8.19ns 0.50795mA
+ 8.192ns 0.505747mA
+ 8.194ns 0.503554mA
+ 8.196ns 0.501371mA
+ 8.198ns 0.499197mA
+ 8.2ns 0.497032mA
+ 8.202ns 0.494877mA
+ 8.204ns 0.49273mA
+ 8.206ns 0.490594mA
+ 8.208ns 0.488467mA
+ 8.21ns 0.486349mA
+ 8.212ns 0.48424mA
+ 8.214ns 0.48214mA
+ 8.216ns 0.48005mA
+ 8.218ns 0.477967mA
+ 8.22ns 0.475895mA
+ 8.222ns 0.473831mA
+ 8.224ns 0.471777mA
+ 8.226ns 0.469731mA
+ 8.228ns 0.467694mA
+ 8.23ns 0.465666mA
+ 8.232ns 0.463646mA
+ 8.234ns 0.461636mA
+ 8.236ns 0.459634mA
+ 8.238ns 0.457641mA
+ 8.24ns 0.455657mA
+ 8.242ns 0.453681mA
+ 8.244ns 0.451713mA
+ 8.246ns 0.449754mA
+ 8.248ns 0.447804mA
+ 8.25ns 0.445862mA
+ 8.252ns 0.443929mA
+ 8.254ns 0.442004mA
+ 8.256ns 0.440088mA
+ 8.258ns 0.438178mA
+ 8.26ns 0.436278mA
+ 8.262ns 0.434387mA
+ 8.264ns 0.432503mA
+ 8.266ns 0.430628mA
+ 8.268ns 0.42876mA
+ 8.27ns 0.4269mA
+ 8.272ns 0.425049mA
+ 8.274ns 0.423206mA
+ 8.276ns 0.421371mA
+ 8.278ns 0.419544mA
+ 8.28ns 0.417725mA
+ 8.282ns 0.415914mA
+ 8.284ns 0.414109mA
+ 8.286ns 0.412314mA
+ 8.288ns 0.410526mA
+ 8.29ns 0.408746mA
+ 8.292ns 0.406973mA
+ 8.294ns 0.405209mA
+ 8.296ns 0.403451mA
+ 8.298ns 0.401701mA
+ 8.3ns 0.399959mA
+ 8.302ns 0.398225mA
+ 8.304ns 0.396498mA
+ 8.306ns 0.394779mA
+ 8.308ns 0.393067mA
+ 8.31ns 0.391362mA
+ 8.312ns 0.389665mA
+ 8.314ns 0.387975mA
+ 8.316ns 0.386293mA
+ 8.318ns 0.384618mA
+ 8.32ns 0.38295mA
+ 8.322ns 0.381289mA
+ 8.324ns 0.379635mA
+ 8.326ns 0.377989mA
+ 8.328ns 0.37635mA
+ 8.33ns 0.374718mA
+ 8.332ns 0.373093mA
+ 8.334ns 0.371475mA
+ 8.336ns 0.369864mA
+ 8.338ns 0.36826mA
+ 8.34ns 0.366663mA
+ 8.342ns 0.365073mA
+ 8.344ns 0.36349mA
+ 8.346ns 0.361914mA
+ 8.348ns 0.360344mA
+ 8.35ns 0.358781mA
+ 8.352ns 0.357225mA
+ 8.354ns 0.355676mA
+ 8.356ns 0.354134mA
+ 8.358ns 0.352598mA
+ 8.36ns 0.351069mA
+ 8.362ns 0.349546mA
+ 8.364ns 0.348031mA
+ 8.366ns 0.346521mA
+ 8.368ns 0.345019mA
+ 8.37ns 0.343523mA
+ 8.372ns 0.342033mA
+ 8.374ns 0.34055mA
+ 8.376ns 0.339072mA
+ 8.378ns 0.337602mA
+ 8.38ns 0.336138mA
+ 8.382ns 0.33468mA
+ 8.384ns 0.333229mA
+ 8.386ns 0.331784mA
+ 8.388ns 0.330345mA
+ 8.39ns 0.328912mA
+ 8.392ns 0.327486mA
+ 8.394ns 0.326066mA
+ 8.396ns 0.324652mA
+ 8.398ns 0.323244mA
+ 8.4ns 0.321842mA
+ 8.402ns 0.320446mA
+ 8.404ns 0.319056mA
+ 8.406ns 0.317673mA
+ 8.408ns 0.316295mA
+ 8.41ns 0.314924mA
+ 8.412ns 0.313558mA
+ 8.414ns 0.312198mA
+ 8.416ns 0.310844mA
+ 8.418ns 0.309496mA
+ 8.42ns 0.308154mA
+ 8.422ns 0.306817mA
+ 8.424ns 0.305487mA
+ 8.426ns 0.304162mA
+ 8.428ns 0.302843mA
+ 8.43ns 0.301529mA
+ 8.432ns 0.300222mA
+ 8.434ns 0.29892mA
+ 8.436ns 0.297624mA
+ 8.438ns 0.296333mA
+ 8.44ns 0.295048mA
+ 8.442ns 0.293768mA
+ 8.444ns 0.292494mA
+ 8.446ns 0.291225mA
+ 8.448ns 0.289963mA
+ 8.45ns 0.288705mA
+ 8.452ns 0.287453mA
+ 8.454ns 0.286206mA
+ 8.456ns 0.284965mA
+ 8.458ns 0.283729mA
+ 8.46ns 0.282499mA
+ 8.462ns 0.281274mA
+ 8.464ns 0.280054mA
+ 8.466ns 0.278839mA
+ 8.468ns 0.27763mA
+ 8.47ns 0.276426mA
+ 8.472ns 0.275227mA
+ 8.474ns 0.274033mA
+ 8.476ns 0.272845mA
+ 8.478ns 0.271662mA
+ 8.48ns 0.270483mA
+ 8.482ns 0.26931mA
+ 8.484ns 0.268142mA
+ 8.486ns 0.266979mA
+ 8.488ns 0.265822mA
+ 8.49ns 0.264669mA
+ 8.492ns 0.263521mA
+ 8.494ns 0.262378mA
+ 8.496ns 0.26124mA
+ 8.498ns 0.260107mA
+ 8.5ns 0.258979mA
+ 8.502ns 0.257856mA
+ 8.504ns 0.256738mA
+ 8.506ns 0.255624mA
+ 8.508ns 0.254515mA
+ 8.51ns 0.253411mA
+ 8.512ns 0.252312mA
+ 8.514ns 0.251218mA
+ 8.516ns 0.250129mA
+ 8.518ns 0.249044mA
+ 8.52ns 0.247964mA
+ 8.522ns 0.246888mA
+ 8.524ns 0.245817mA
+ 8.526ns 0.244751mA
+ 8.528ns 0.24369mA
+ 8.53ns 0.242633mA
+ 8.532ns 0.241581mA
+ 8.534ns 0.240533mA
+ 8.536ns 0.23949mA
+ 8.538ns 0.238451mA
+ 8.54ns 0.237417mA
+ 8.542ns 0.236387mA
+ 8.544ns 0.235362mA
+ 8.546ns 0.234341mA
+ 8.548ns 0.233325mA
+ 8.55ns 0mA
I246 474 0 PWL 0 0
+ 5.514ns 0mA
+ 5.516ns 0.00719872mA
+ 5.518ns 0.0149391mA
+ 5.52ns 0.0226795mA
+ 5.522ns 0.0304199mA
+ 5.524ns 0.0381622mA
+ 5.526ns 0.0459026mA
+ 5.528ns 0.053643mA
+ 5.53ns 0.0613852mA
+ 5.532ns 0.0691256mA
+ 5.534ns 0.076866mA
+ 5.536ns 0.0846083mA
+ 5.538ns 0.0923487mA
+ 5.54ns 0.100089mA
+ 5.542ns 0.107831mA
+ 5.544ns 0.115572mA
+ 5.546ns 0.123312mA
+ 5.548ns 0.131053mA
+ 5.55ns 0.138795mA
+ 5.552ns 0.146535mA
+ 5.554ns 0.154276mA
+ 5.556ns 0.162018mA
+ 5.558ns 0.169758mA
+ 5.56ns 0.177499mA
+ 5.562ns 0.185241mA
+ 5.564ns 0.192981mA
+ 5.566ns 0.200722mA
+ 5.568ns 0.208462mA
+ 5.57ns 0.216204mA
+ 5.572ns 0.223945mA
+ 5.574ns 0.231685mA
+ 5.576ns 0.239427mA
+ 5.578ns 0.247168mA
+ 5.58ns 0.254908mA
+ 5.582ns 0.26265mA
+ 5.584ns 0.270391mA
+ 5.586ns 0.278131mA
+ 5.588ns 0.285874mA
+ 5.59ns 0.293614mA
+ 5.592ns 0.301354mA
+ 5.594ns 0.309095mA
+ 5.596ns 0.316837mA
+ 5.598ns 0.324577mA
+ 5.6ns 0.332318mA
+ 5.602ns 0.34006mA
+ 5.604ns 0.3478mA
+ 5.606ns 0.355541mA
+ 5.608ns 0.363283mA
+ 5.61ns 0.371023mA
+ 5.612ns 0.378764mA
+ 5.614ns 0.386504mA
+ 5.616ns 0.394246mA
+ 5.618ns 0.401987mA
+ 5.62ns 0.409727mA
+ 5.622ns 0.41747mA
+ 5.624ns 0.42521mA
+ 5.626ns 0.43295mA
+ 5.628ns 0.440693mA
+ 5.63ns 0.448433mA
+ 5.632ns 0.456173mA
+ 5.634ns 0.463916mA
+ 5.636ns 0.471656mA
+ 5.638ns 0.479396mA
+ 5.64ns 0.487137mA
+ 5.642ns 0.494879mA
+ 5.644ns 0.50262mA
+ 5.646ns 0.51036mA
+ 5.648ns 0.518102mA
+ 5.65ns 0.525843mA
+ 5.652ns 0.533583mA
+ 5.654ns 0.541325mA
+ 5.656ns 0.549066mA
+ 5.658ns 0.548693mA
+ 5.66ns 0.546305mA
+ 5.662ns 0.543926mA
+ 5.664ns 0.541559mA
+ 5.666ns 0.539201mA
+ 5.668ns 0.536854mA
+ 5.67ns 0.534517mA
+ 5.672ns 0.53219mA
+ 5.674ns 0.529873mA
+ 5.676ns 0.527566mA
+ 5.678ns 0.52527mA
+ 5.68ns 0.522983mA
+ 5.682ns 0.520706mA
+ 5.684ns 0.51844mA
+ 5.686ns 0.516183mA
+ 5.688ns 0.513935mA
+ 5.69ns 0.511698mA
+ 5.692ns 0.509471mA
+ 5.694ns 0.507253mA
+ 5.696ns 0.505044mA
+ 5.698ns 0.502846mA
+ 5.7ns 0.500657mA
+ 5.702ns 0.498477mA
+ 5.704ns 0.496307mA
+ 5.706ns 0.494147mA
+ 5.708ns 0.491995mA
+ 5.71ns 0.489854mA
+ 5.712ns 0.487721mA
+ 5.714ns 0.485598mA
+ 5.716ns 0.483484mA
+ 5.718ns 0.481379mA
+ 5.72ns 0.479283mA
+ 5.722ns 0.477197mA
+ 5.724ns 0.47512mA
+ 5.726ns 0.473051mA
+ 5.728ns 0.470992mA
+ 5.73ns 0.468941mA
+ 5.732ns 0.4669mA
+ 5.734ns 0.464867mA
+ 5.736ns 0.462843mA
+ 5.738ns 0.460829mA
+ 5.74ns 0.458822mA
+ 5.742ns 0.456825mA
+ 5.744ns 0.454836mA
+ 5.746ns 0.452856mA
+ 5.748ns 0.450884mA
+ 5.75ns 0.448922mA
+ 5.752ns 0.446967mA
+ 5.754ns 0.445021mA
+ 5.756ns 0.443084mA
+ 5.758ns 0.441155mA
+ 5.76ns 0.439234mA
+ 5.762ns 0.437322mA
+ 5.764ns 0.435418mA
+ 5.766ns 0.433522mA
+ 5.768ns 0.431635mA
+ 5.77ns 0.429756mA
+ 5.772ns 0.427885mA
+ 5.774ns 0.426022mA
+ 5.776ns 0.424168mA
+ 5.778ns 0.422321mA
+ 5.78ns 0.420482mA
+ 5.782ns 0.418652mA
+ 5.784ns 0.416829mA
+ 5.786ns 0.415014mA
+ 5.788ns 0.413208mA
+ 5.79ns 0.411409mA
+ 5.792ns 0.409618mA
+ 5.794ns 0.407834mA
+ 5.796ns 0.406059mA
+ 5.798ns 0.404291mA
+ 5.8ns 0.402531mA
+ 5.802ns 0.400779mA
+ 5.804ns 0.399034mA
+ 5.806ns 0.397296mA
+ 5.808ns 0.395567mA
+ 5.81ns 0.393845mA
+ 5.812ns 0.39213mA
+ 5.814ns 0.390423mA
+ 5.816ns 0.388723mA
+ 5.818ns 0.387031mA
+ 5.82ns 0.385346mA
+ 5.822ns 0.383668mA
+ 5.824ns 0.381998mA
+ 5.826ns 0.380335mA
+ 5.828ns 0.378679mA
+ 5.83ns 0.37703mA
+ 5.832ns 0.375389mA
+ 5.834ns 0.373754mA
+ 5.836ns 0.372127mA
+ 5.838ns 0.370507mA
+ 5.84ns 0.368894mA
+ 5.842ns 0.367288mA
+ 5.844ns 0.365689mA
+ 5.846ns 0.364097mA
+ 5.848ns 0.362512mA
+ 5.85ns 0.360934mA
+ 5.852ns 0.359362mA
+ 5.854ns 0.357797mA
+ 5.856ns 0.35624mA
+ 5.858ns 0.354689mA
+ 5.86ns 0.353144mA
+ 5.862ns 0.351607mA
+ 5.864ns 0.350076mA
+ 5.866ns 0.348552mA
+ 5.868ns 0.347035mA
+ 5.87ns 0.345524mA
+ 5.872ns 0.344019mA
+ 5.874ns 0.342522mA
+ 5.876ns 0.34103mA
+ 5.878ns 0.339545mA
+ 5.88ns 0.338067mA
+ 5.882ns 0.336595mA
+ 5.884ns 0.33513mA
+ 5.886ns 0.333671mA
+ 5.888ns 0.332218mA
+ 5.89ns 0.330772mA
+ 5.892ns 0.329332mA
+ 5.894ns 0.327898mA
+ 5.896ns 0.32647mA
+ 5.898ns 0.325049mA
+ 5.9ns 0.323634mA
+ 5.902ns 0.322225mA
+ 5.904ns 0.320821mA
+ 5.906ns 0.319425mA
+ 5.908ns 0.318034mA
+ 5.91ns 0.316649mA
+ 5.912ns 0.315271mA
+ 5.914ns 0.313898mA
+ 5.916ns 0.312532mA
+ 5.918ns 0.311171mA
+ 5.92ns 0.309816mA
+ 5.922ns 0.308467mA
+ 5.924ns 0.307124mA
+ 5.926ns 0.305787mA
+ 5.928ns 0.304456mA
+ 5.93ns 0.30313mA
+ 5.932ns 0.30181mA
+ 5.934ns 0.300496mA
+ 5.936ns 0.299188mA
+ 5.938ns 0.297885mA
+ 5.94ns 0.296588mA
+ 5.942ns 0.295297mA
+ 5.944ns 0.294011mA
+ 5.946ns 0.292731mA
+ 5.948ns 0.291457mA
+ 5.95ns 0.290187mA
+ 5.952ns 0.288924mA
+ 5.954ns 0.287666mA
+ 5.956ns 0.286413mA
+ 5.958ns 0.285167mA
+ 5.96ns 0.283925mA
+ 5.962ns 0.282689mA
+ 5.964ns 0.281458mA
+ 5.966ns 0.280233mA
+ 5.968ns 0.279013mA
+ 5.97ns 0.277797mA
+ 5.972ns 0.276588mA
+ 5.974ns 0.275384mA
+ 5.976ns 0.274185mA
+ 5.978ns 0.272991mA
+ 5.98ns 0.271802mA
+ 5.982ns 0.270619mA
+ 5.984ns 0.269441mA
+ 5.986ns 0.268268mA
+ 5.988ns 0.2671mA
+ 5.99ns 0.265936mA
+ 5.992ns 0.264779mA
+ 5.994ns 0.263626mA
+ 5.996ns 0.262478mA
+ 5.998ns 0.261335mA
+ 6ns 0.260197mA
+ 6.002ns 0.259064mA
+ 6.004ns 0.257936mA
+ 6.006ns 0.256813mA
+ 6.008ns 0.255695mA
+ 6.01ns 0.254582mA
+ 6.012ns 0.253473mA
+ 6.014ns 0.25237mA
+ 6.016ns 0.251271mA
+ 6.018ns 0.250177mA
+ 6.02ns 0.249088mA
+ 6.022ns 0.248003mA
+ 6.024ns 0.246923mA
+ 6.026ns 0.245848mA
+ 6.028ns 0.244778mA
+ 6.03ns 0.243712mA
+ 6.032ns 0.242651mA
+ 6.034ns 0.241594mA
+ 6.036ns 0.240542mA
+ 6.038ns 0.239495mA
+ 6.04ns 0.238452mA
+ 6.042ns 0.237414mA
+ 6.044ns 0.23638mA
+ 6.046ns 0mA
I247 475 0 PWL 0 0
+ 0.15ns 0mA
+ 0.152ns 0.0105693mA
+ 0.154ns 0.0214743mA
+ 0.156ns 0.0323793mA
+ 0.158ns 0.0432843mA
+ 0.16ns 0.0541894mA
+ 0.162ns 0.0650944mA
+ 0.164ns 0.0759994mA
+ 0.166ns 0.065792mA
+ 0.168ns 0.0541501mA
+ 0.17ns 0.0445678mA
+ 0.172ns 0.0366809mA
+ 0.174ns 0.0301893mA
+ 0.176ns 0.0248464mA
+ 0.178ns 0.0204489mA
+ 0.18ns 0mA
I248 478 0 PWL 0 0
+ 3.018ns 0mA
+ 3.02ns 0.000380163mA
+ 3.022ns 0.00809749mA
+ 3.024ns 0.0158148mA
+ 3.026ns 0.0235312mA
+ 3.028ns 0.0312486mA
+ 3.03ns 0.038965mA
+ 3.032ns 0.0466823mA
+ 3.034ns 0.0543996mA
+ 3.036ns 0.062116mA
+ 3.038ns 0.0698334mA
+ 3.04ns 0.0775498mA
+ 3.042ns 0.0852671mA
+ 3.044ns 0.0929844mA
+ 3.046ns 0.100701mA
+ 3.048ns 0.108418mA
+ 3.05ns 0.116135mA
+ 3.052ns 0.123852mA
+ 3.054ns 0.131569mA
+ 3.056ns 0.139286mA
+ 3.058ns 0.147003mA
+ 3.06ns 0.154719mA
+ 3.062ns 0.162437mA
+ 3.064ns 0.170154mA
+ 3.066ns 0.17787mA
+ 3.068ns 0.185588mA
+ 3.07ns 0.193304mA
+ 3.072ns 0.201022mA
+ 3.074ns 0.208739mA
+ 3.076ns 0.216455mA
+ 3.078ns 0.224173mA
+ 3.08ns 0.23189mA
+ 3.082ns 0.239606mA
+ 3.084ns 0.247324mA
+ 3.086ns 0.25504mA
+ 3.088ns 0.262757mA
+ 3.09ns 0.270475mA
+ 3.092ns 0.278191mA
+ 3.094ns 0.285908mA
+ 3.096ns 0.293625mA
+ 3.098ns 0.301342mA
+ 3.1ns 0.30906mA
+ 3.102ns 0.316776mA
+ 3.104ns 0.324493mA
+ 3.106ns 0.33221mA
+ 3.108ns 0.339927mA
+ 3.11ns 0.347644mA
+ 3.112ns 0.355361mA
+ 3.114ns 0.363078mA
+ 3.116ns 0.370794mA
+ 3.118ns 0.378512mA
+ 3.12ns 0.386229mA
+ 3.122ns 0.393946mA
+ 3.124ns 0.401663mA
+ 3.126ns 0.40938mA
+ 3.128ns 0.417097mA
+ 3.13ns 0.424814mA
+ 3.132ns 0.43253mA
+ 3.134ns 0.440248mA
+ 3.136ns 0.447965mA
+ 3.138ns 0.455681mA
+ 3.14ns 0.463399mA
+ 3.142ns 0.471115mA
+ 3.144ns 0.478832mA
+ 3.146ns 0.48655mA
+ 3.148ns 0.494266mA
+ 3.15ns 0.501984mA
+ 3.152ns 0.5097mA
+ 3.154ns 0.517417mA
+ 3.156ns 0.525135mA
+ 3.158ns 0.532851mA
+ 3.16ns 0.540568mA
+ 3.162ns 0.548285mA
+ 3.164ns 0.548919mA
+ 3.166ns 0.546527mA
+ 3.168ns 0.544147mA
+ 3.17ns 0.541776mA
+ 3.172ns 0.539415mA
+ 3.174ns 0.537066mA
+ 3.176ns 0.534726mA
+ 3.178ns 0.532396mA
+ 3.18ns 0.530077mA
+ 3.182ns 0.527767mA
+ 3.184ns 0.525468mA
+ 3.186ns 0.523179mA
+ 3.188ns 0.5209mA
+ 3.19ns 0.51863mA
+ 3.192ns 0.516371mA
+ 3.194ns 0.514121mA
+ 3.196ns 0.511881mA
+ 3.198ns 0.509652mA
+ 3.2ns 0.507431mA
+ 3.202ns 0.50522mA
+ 3.204ns 0.503019mA
+ 3.206ns 0.500828mA
+ 3.208ns 0.498646mA
+ 3.21ns 0.496474mA
+ 3.212ns 0.494311mA
+ 3.214ns 0.492157mA
+ 3.216ns 0.490013mA
+ 3.218ns 0.487878mA
+ 3.22ns 0.485753mA
+ 3.222ns 0.483636mA
+ 3.224ns 0.481529mA
+ 3.226ns 0.479431mA
+ 3.228ns 0.477343mA
+ 3.23ns 0.475263mA
+ 3.232ns 0.473192mA
+ 3.234ns 0.471131mA
+ 3.236ns 0.469078mA
+ 3.238ns 0.467035mA
+ 3.24ns 0.465mA
+ 3.242ns 0.462974mA
+ 3.244ns 0.460957mA
+ 3.246ns 0.458949mA
+ 3.248ns 0.456949mA
+ 3.25ns 0.454959mA
+ 3.252ns 0.452976mA
+ 3.254ns 0.451003mA
+ 3.256ns 0.449038mA
+ 3.258ns 0.447082mA
+ 3.26ns 0.445134mA
+ 3.262ns 0.443194mA
+ 3.264ns 0.441263mA
+ 3.266ns 0.439341mA
+ 3.268ns 0.437427mA
+ 3.27ns 0.435521mA
+ 3.272ns 0.433624mA
+ 3.274ns 0.431735mA
+ 3.276ns 0.429854mA
+ 3.278ns 0.427981mA
+ 3.28ns 0.426116mA
+ 3.282ns 0.42426mA
+ 3.284ns 0.422411mA
+ 3.286ns 0.420571mA
+ 3.288ns 0.418739mA
+ 3.29ns 0.416914mA
+ 3.292ns 0.415098mA
+ 3.294ns 0.413289mA
+ 3.296ns 0.411489mA
+ 3.298ns 0.409696mA
+ 3.3ns 0.407911mA
+ 3.302ns 0.406134mA
+ 3.304ns 0.404364mA
+ 3.306ns 0.402603mA
+ 3.308ns 0.400848mA
+ 3.31ns 0.399102mA
+ 3.312ns 0.397363mA
+ 3.314ns 0.395632mA
+ 3.316ns 0.393908mA
+ 3.318ns 0.392192mA
+ 3.32ns 0.390483mA
+ 3.322ns 0.388782mA
+ 3.324ns 0.387088mA
+ 3.326ns 0.385402mA
+ 3.328ns 0.383722mA
+ 3.33ns 0.38205mA
+ 3.332ns 0.380386mA
+ 3.334ns 0.378729mA
+ 3.336ns 0.377079mA
+ 3.338ns 0.375436mA
+ 3.34ns 0.3738mA
+ 3.342ns 0.372171mA
+ 3.344ns 0.37055mA
+ 3.346ns 0.368935mA
+ 3.348ns 0.367328mA
+ 3.35ns 0.365727mA
+ 3.352ns 0.364134mA
+ 3.354ns 0.362547mA
+ 3.356ns 0.360968mA
+ 3.358ns 0.359395mA
+ 3.36ns 0.357829mA
+ 3.362ns 0.35627mA
+ 3.364ns 0.354718mA
+ 3.366ns 0.353172mA
+ 3.368ns 0.351634mA
+ 3.37ns 0.350102mA
+ 3.372ns 0.348576mA
+ 3.374ns 0.347057mA
+ 3.376ns 0.345545mA
+ 3.378ns 0.34404mA
+ 3.38ns 0.342541mA
+ 3.382ns 0.341048mA
+ 3.384ns 0.339562mA
+ 3.386ns 0.338083mA
+ 3.388ns 0.33661mA
+ 3.39ns 0.335143mA
+ 3.392ns 0.333683mA
+ 3.394ns 0.332229mA
+ 3.396ns 0.330781mA
+ 3.398ns 0.32934mA
+ 3.4ns 0.327905mA
+ 3.402ns 0.326477mA
+ 3.404ns 0.325054mA
+ 3.406ns 0.323638mA
+ 3.408ns 0.322228mA
+ 3.41ns 0.320824mA
+ 3.412ns 0.319426mA
+ 3.414ns 0.318034mA
+ 3.416ns 0.316648mA
+ 3.418ns 0.315269mA
+ 3.42ns 0.313895mA
+ 3.422ns 0.312527mA
+ 3.424ns 0.311166mA
+ 3.426ns 0.30981mA
+ 3.428ns 0.30846mA
+ 3.43ns 0.307116mA
+ 3.432ns 0.305778mA
+ 3.434ns 0.304446mA
+ 3.436ns 0.303119mA
+ 3.438ns 0.301798mA
+ 3.44ns 0.300483mA
+ 3.442ns 0.299174mA
+ 3.444ns 0.297871mA
+ 3.446ns 0.296573mA
+ 3.448ns 0.29528mA
+ 3.45ns 0.293994mA
+ 3.452ns 0.292713mA
+ 3.454ns 0.291437mA
+ 3.456ns 0.290168mA
+ 3.458ns 0.288903mA
+ 3.46ns 0.287644mA
+ 3.462ns 0.286391mA
+ 3.464ns 0.285143mA
+ 3.466ns 0.283901mA
+ 3.468ns 0.282664mA
+ 3.47ns 0.281432mA
+ 3.472ns 0.280206mA
+ 3.474ns 0.278985mA
+ 3.476ns 0.277769mA
+ 3.478ns 0.276559mA
+ 3.48ns 0.275354mA
+ 3.482ns 0.274154mA
+ 3.484ns 0.27296mA
+ 3.486ns 0.27177mA
+ 3.488ns 0.270586mA
+ 3.49ns 0.269407mA
+ 3.492ns 0.268233mA
+ 3.494ns 0.267064mA
+ 3.496ns 0.265901mA
+ 3.498ns 0.264742mA
+ 3.5ns 0.263589mA
+ 3.502ns 0.26244mA
+ 3.504ns 0.261296mA
+ 3.506ns 0.260158mA
+ 3.508ns 0.259024mA
+ 3.51ns 0.257896mA
+ 3.512ns 0.256772mA
+ 3.514ns 0.255653mA
+ 3.516ns 0.254539mA
+ 3.518ns 0.25343mA
+ 3.52ns 0.252326mA
+ 3.522ns 0.251226mA
+ 3.524ns 0.250132mA
+ 3.526ns 0.249042mA
+ 3.528ns 0.247956mA
+ 3.53ns 0.246876mA
+ 3.532ns 0.2458mA
+ 3.534ns 0.244729mA
+ 3.536ns 0.243663mA
+ 3.538ns 0.242601mA
+ 3.54ns 0.241544mA
+ 3.542ns 0.240492mA
+ 3.544ns 0.239444mA
+ 3.546ns 0.2384mA
+ 3.548ns 0.237361mA
+ 3.55ns 0.236327mA
+ 3.552ns 0mA
I249 479 0 PWL 0 0
+ 7.998ns 0mA
+ 8ns 0.00406092mA
+ 8.002ns 0.0116351mA
+ 8.004ns 0.0192093mA
+ 8.006ns 0.0267835mA
+ 8.008ns 0.0343613mA
+ 8.01ns 0.0419355mA
+ 8.012ns 0.0495097mA
+ 8.014ns 0.0570838mA
+ 8.016ns 0.064658mA
+ 8.018ns 0.0722322mA
+ 8.02ns 0.07981mA
+ 8.022ns 0.0873842mA
+ 8.024ns 0.0949584mA
+ 8.026ns 0.102533mA
+ 8.028ns 0.110107mA
+ 8.03ns 0.117681mA
+ 8.032ns 0.125255mA
+ 8.034ns 0.132833mA
+ 8.036ns 0.140407mA
+ 8.038ns 0.147981mA
+ 8.04ns 0.155556mA
+ 8.042ns 0.16313mA
+ 8.044ns 0.170704mA
+ 8.046ns 0.178278mA
+ 8.048ns 0.185856mA
+ 8.05ns 0.19343mA
+ 8.052ns 0.201004mA
+ 8.054ns 0.208578mA
+ 8.056ns 0.216153mA
+ 8.058ns 0.223727mA
+ 8.06ns 0.231305mA
+ 8.062ns 0.238879mA
+ 8.064ns 0.246453mA
+ 8.066ns 0.254027mA
+ 8.068ns 0.261601mA
+ 8.07ns 0.269176mA
+ 8.072ns 0.27675mA
+ 8.074ns 0.284328mA
+ 8.076ns 0.291902mA
+ 8.078ns 0.299476mA
+ 8.08ns 0.30705mA
+ 8.082ns 0.314624mA
+ 8.084ns 0.322198mA
+ 8.086ns 0.329776mA
+ 8.088ns 0.33735mA
+ 8.09ns 0.344925mA
+ 8.092ns 0.352499mA
+ 8.094ns 0.360073mA
+ 8.096ns 0.367647mA
+ 8.098ns 0.375221mA
+ 8.1ns 0.382799mA
+ 8.102ns 0.390373mA
+ 8.104ns 0.397948mA
+ 8.106ns 0.405522mA
+ 8.108ns 0.413096mA
+ 8.11ns 0.42067mA
+ 8.112ns 0.428248mA
+ 8.114ns 0.435822mA
+ 8.116ns 0.443396mA
+ 8.118ns 0.45097mA
+ 8.12ns 0.458545mA
+ 8.122ns 0.466119mA
+ 8.124ns 0.473693mA
+ 8.126ns 0.481271mA
+ 8.128ns 0.488845mA
+ 8.13ns 0.496419mA
+ 8.132ns 0.503993mA
+ 8.134ns 0.511568mA
+ 8.136ns 0.519142mA
+ 8.138ns 0.526716mA
+ 8.14ns 0.534294mA
+ 8.142ns 0.541868mA
+ 8.144ns 0.543971mA
+ 8.146ns 0.541611mA
+ 8.148ns 0.539262mA
+ 8.15ns 0.536922mA
+ 8.152ns 0.534592mA
+ 8.154ns 0.532273mA
+ 8.156ns 0.529964mA
+ 8.158ns 0.527665mA
+ 8.16ns 0.525376mA
+ 8.162ns 0.523097mA
+ 8.164ns 0.520828mA
+ 8.166ns 0.518567mA
+ 8.168ns 0.516318mA
+ 8.17ns 0.514078mA
+ 8.172ns 0.511848mA
+ 8.174ns 0.509627mA
+ 8.176ns 0.507417mA
+ 8.178ns 0.505214mA
+ 8.18ns 0.503023mA
+ 8.182ns 0.500841mA
+ 8.184ns 0.498668mA
+ 8.186ns 0.496505mA
+ 8.188ns 0.494351mA
+ 8.19ns 0.492206mA
+ 8.192ns 0.49007mA
+ 8.194ns 0.487944mA
+ 8.196ns 0.485827mA
+ 8.198ns 0.48372mA
+ 8.2ns 0.481621mA
+ 8.202ns 0.479532mA
+ 8.204ns 0.477451mA
+ 8.206ns 0.475379mA
+ 8.208ns 0.473317mA
+ 8.21ns 0.471264mA
+ 8.212ns 0.469219mA
+ 8.214ns 0.467184mA
+ 8.216ns 0.465157mA
+ 8.218ns 0.463138mA
+ 8.22ns 0.461129mA
+ 8.222ns 0.459129mA
+ 8.224ns 0.457137mA
+ 8.226ns 0.455154mA
+ 8.228ns 0.453179mA
+ 8.23ns 0.451213mA
+ 8.232ns 0.449255mA
+ 8.234ns 0.447306mA
+ 8.236ns 0.445365mA
+ 8.238ns 0.443433mA
+ 8.24ns 0.44151mA
+ 8.242ns 0.439594mA
+ 8.244ns 0.437686mA
+ 8.246ns 0.435788mA
+ 8.248ns 0.433897mA
+ 8.25ns 0.432015mA
+ 8.252ns 0.43014mA
+ 8.254ns 0.428274mA
+ 8.256ns 0.426416mA
+ 8.258ns 0.424566mA
+ 8.26ns 0.422724mA
+ 8.262ns 0.42089mA
+ 8.264ns 0.419064mA
+ 8.266ns 0.417246mA
+ 8.268ns 0.415436mA
+ 8.27ns 0.413633mA
+ 8.272ns 0.411838mA
+ 8.274ns 0.410052mA
+ 8.276ns 0.408273mA
+ 8.278ns 0.406502mA
+ 8.28ns 0.404738mA
+ 8.282ns 0.402982mA
+ 8.284ns 0.401233mA
+ 8.286ns 0.399492mA
+ 8.288ns 0.397759mA
+ 8.29ns 0.396034mA
+ 8.292ns 0.394316mA
+ 8.294ns 0.392605mA
+ 8.296ns 0.390901mA
+ 8.298ns 0.389205mA
+ 8.3ns 0.387516mA
+ 8.302ns 0.385835mA
+ 8.304ns 0.384161mA
+ 8.306ns 0.382495mA
+ 8.308ns 0.380835mA
+ 8.31ns 0.379182mA
+ 8.312ns 0.377537mA
+ 8.314ns 0.375899mA
+ 8.316ns 0.374269mA
+ 8.318ns 0.372645mA
+ 8.32ns 0.371028mA
+ 8.322ns 0.369419mA
+ 8.324ns 0.367815mA
+ 8.326ns 0.366219mA
+ 8.328ns 0.364631mA
+ 8.33ns 0.363049mA
+ 8.332ns 0.361474mA
+ 8.334ns 0.359905mA
+ 8.336ns 0.358343mA
+ 8.338ns 0.356789mA
+ 8.34ns 0.355241mA
+ 8.342ns 0.353699mA
+ 8.344ns 0.352165mA
+ 8.346ns 0.350637mA
+ 8.348ns 0.349116mA
+ 8.35ns 0.347601mA
+ 8.352ns 0.346092mA
+ 8.354ns 0.344591mA
+ 8.356ns 0.343096mA
+ 8.358ns 0.341607mA
+ 8.36ns 0.340125mA
+ 8.362ns 0.338649mA
+ 8.364ns 0.33718mA
+ 8.366ns 0.335717mA
+ 8.368ns 0.334261mA
+ 8.37ns 0.33281mA
+ 8.372ns 0.331366mA
+ 8.374ns 0.329929mA
+ 8.376ns 0.328497mA
+ 8.378ns 0.327072mA
+ 8.38ns 0.325653mA
+ 8.382ns 0.32424mA
+ 8.384ns 0.322833mA
+ 8.386ns 0.321432mA
+ 8.388ns 0.320037mA
+ 8.39ns 0.318649mA
+ 8.392ns 0.317266mA
+ 8.394ns 0.31589mA
+ 8.396ns 0.314519mA
+ 8.398ns 0.313155mA
+ 8.4ns 0.311796mA
+ 8.402ns 0.310443mA
+ 8.404ns 0.309096mA
+ 8.406ns 0.307755mA
+ 8.408ns 0.306419mA
+ 8.41ns 0.30509mA
+ 8.412ns 0.303766mA
+ 8.414ns 0.302448mA
+ 8.416ns 0.301136mA
+ 8.418ns 0.299829mA
+ 8.42ns 0.298528mA
+ 8.422ns 0.297233mA
+ 8.424ns 0.295943mA
+ 8.426ns 0.294659mA
+ 8.428ns 0.29338mA
+ 8.43ns 0.292108mA
+ 8.432ns 0.29084mA
+ 8.434ns 0.289578mA
+ 8.436ns 0.288322mA
+ 8.438ns 0.287071mA
+ 8.44ns 0.285826mA
+ 8.442ns 0.284585mA
+ 8.444ns 0.28335mA
+ 8.446ns 0.282121mA
+ 8.448ns 0.280897mA
+ 8.45ns 0.279678mA
+ 8.452ns 0.278465mA
+ 8.454ns 0.277256mA
+ 8.456ns 0.276053mA
+ 8.458ns 0.274855mA
+ 8.46ns 0.273663mA
+ 8.462ns 0.272475mA
+ 8.464ns 0.271293mA
+ 8.466ns 0.270116mA
+ 8.468ns 0.268944mA
+ 8.47ns 0.267777mA
+ 8.472ns 0.266615mA
+ 8.474ns 0.265458mA
+ 8.476ns 0.264306mA
+ 8.478ns 0.26316mA
+ 8.48ns 0.262017mA
+ 8.482ns 0.26088mA
+ 8.484ns 0.259749mA
+ 8.486ns 0.258622mA
+ 8.488ns 0.257499mA
+ 8.49ns 0.256382mA
+ 8.492ns 0.25527mA
+ 8.494ns 0.254162mA
+ 8.496ns 0.253059mA
+ 8.498ns 0.251961mA
+ 8.5ns 0.250868mA
+ 8.502ns 0.249779mA
+ 8.504ns 0.248696mA
+ 8.506ns 0.247617mA
+ 8.508ns 0.246542mA
+ 8.51ns 0.245472mA
+ 8.512ns 0.244407mA
+ 8.514ns 0.243346mA
+ 8.516ns 0.242291mA
+ 8.518ns 0.241239mA
+ 8.52ns 0.240192mA
+ 8.522ns 0.23915mA
+ 8.524ns 0.238112mA
+ 8.526ns 0.237079mA
+ 8.528ns 0.236051mA
+ 8.53ns 0.235026mA
+ 8.532ns 0.234007mA
+ 8.534ns 0mA
I250 481 0 PWL 0 0
+ 0.512ns 0mA
+ 0.514ns 0.00479681mA
+ 0.516ns 0.0124827mA
+ 0.518ns 0.0201683mA
+ 0.52ns 0.0278541mA
+ 0.522ns 0.0355397mA
+ 0.524ns 0.0432256mA
+ 0.526ns 0.0509112mA
+ 0.528ns 0.0585968mA
+ 0.53ns 0.0662827mA
+ 0.532ns 0.0739683mA
+ 0.534ns 0.0816541mA
+ 0.536ns 0.0893398mA
+ 0.538ns 0.0970256mA
+ 0.54ns 0.104711mA
+ 0.542ns 0.112397mA
+ 0.544ns 0.120083mA
+ 0.546ns 0.127768mA
+ 0.548ns 0.135454mA
+ 0.55ns 0.14314mA
+ 0.552ns 0.150826mA
+ 0.554ns 0.158511mA
+ 0.556ns 0.166197mA
+ 0.558ns 0.173883mA
+ 0.56ns 0.181568mA
+ 0.562ns 0.189254mA
+ 0.564ns 0.19694mA
+ 0.566ns 0.204626mA
+ 0.568ns 0.212311mA
+ 0.57ns 0.219997mA
+ 0.572ns 0.227683mA
+ 0.574ns 0.235368mA
+ 0.576ns 0.243054mA
+ 0.578ns 0.25074mA
+ 0.58ns 0.258426mA
+ 0.582ns 0.266111mA
+ 0.584ns 0.273797mA
+ 0.586ns 0.281483mA
+ 0.588ns 0.289168mA
+ 0.59ns 0.296854mA
+ 0.592ns 0.30454mA
+ 0.594ns 0.312226mA
+ 0.596ns 0.319911mA
+ 0.598ns 0.327597mA
+ 0.6ns 0.335283mA
+ 0.602ns 0.342969mA
+ 0.604ns 0.350654mA
+ 0.606ns 0.35834mA
+ 0.608ns 0.366026mA
+ 0.61ns 0.373711mA
+ 0.612ns 0.381397mA
+ 0.614ns 0.389083mA
+ 0.616ns 0.396769mA
+ 0.618ns 0.404454mA
+ 0.62ns 0.41214mA
+ 0.622ns 0.419826mA
+ 0.624ns 0.427511mA
+ 0.626ns 0.435197mA
+ 0.628ns 0.442883mA
+ 0.63ns 0.450569mA
+ 0.632ns 0.458254mA
+ 0.634ns 0.46594mA
+ 0.636ns 0.473626mA
+ 0.638ns 0.481311mA
+ 0.64ns 0.488997mA
+ 0.642ns 0.496683mA
+ 0.644ns 0.504369mA
+ 0.646ns 0.512054mA
+ 0.648ns 0.51974mA
+ 0.65ns 0.527426mA
+ 0.652ns 0.535111mA
+ 0.654ns 0.542797mA
+ 0.656ns 0.550483mA
+ 0.658ns 0.549587mA
+ 0.66ns 0.547187mA
+ 0.662ns 0.544797mA
+ 0.664ns 0.542418mA
+ 0.666ns 0.540049mA
+ 0.668ns 0.537691mA
+ 0.67ns 0.535343mA
+ 0.672ns 0.533005mA
+ 0.674ns 0.530677mA
+ 0.676ns 0.528359mA
+ 0.678ns 0.526052mA
+ 0.68ns 0.523755mA
+ 0.682ns 0.521467mA
+ 0.684ns 0.51919mA
+ 0.686ns 0.516923mA
+ 0.688ns 0.514665mA
+ 0.69ns 0.512417mA
+ 0.692ns 0.51018mA
+ 0.694ns 0.507952mA
+ 0.696ns 0.505733mA
+ 0.698ns 0.503525mA
+ 0.7ns 0.501325mA
+ 0.702ns 0.499136mA
+ 0.704ns 0.496956mA
+ 0.706ns 0.494786mA
+ 0.708ns 0.492625mA
+ 0.71ns 0.490474mA
+ 0.712ns 0.488332mA
+ 0.714ns 0.486199mA
+ 0.716ns 0.484076mA
+ 0.718ns 0.481961mA
+ 0.72ns 0.479857mA
+ 0.722ns 0.477761mA
+ 0.724ns 0.475674mA
+ 0.726ns 0.473597mA
+ 0.728ns 0.471529mA
+ 0.73ns 0.469469mA
+ 0.732ns 0.467419mA
+ 0.734ns 0.465378mA
+ 0.736ns 0.463345mA
+ 0.738ns 0.461322mA
+ 0.74ns 0.459307mA
+ 0.742ns 0.457301mA
+ 0.744ns 0.455304mA
+ 0.746ns 0.453315mA
+ 0.748ns 0.451335mA
+ 0.75ns 0.449364mA
+ 0.752ns 0.447402mA
+ 0.754ns 0.445448mA
+ 0.756ns 0.443502mA
+ 0.758ns 0.441565mA
+ 0.76ns 0.439637mA
+ 0.762ns 0.437717mA
+ 0.764ns 0.435805mA
+ 0.766ns 0.433902mA
+ 0.768ns 0.432007mA
+ 0.77ns 0.43012mA
+ 0.772ns 0.428242mA
+ 0.774ns 0.426371mA
+ 0.776ns 0.424509mA
+ 0.778ns 0.422655mA
+ 0.78ns 0.420809mA
+ 0.782ns 0.418971mA
+ 0.784ns 0.417142mA
+ 0.786ns 0.41532mA
+ 0.788ns 0.413506mA
+ 0.79ns 0.4117mA
+ 0.792ns 0.409902mA
+ 0.794ns 0.408112mA
+ 0.796ns 0.406329mA
+ 0.798ns 0.404554mA
+ 0.8ns 0.402788mA
+ 0.802ns 0.401028mA
+ 0.804ns 0.399277mA
+ 0.806ns 0.397533mA
+ 0.808ns 0.395797mA
+ 0.81ns 0.394068mA
+ 0.812ns 0.392347mA
+ 0.814ns 0.390634mA
+ 0.816ns 0.388927mA
+ 0.818ns 0.387229mA
+ 0.82ns 0.385538mA
+ 0.822ns 0.383854mA
+ 0.824ns 0.382177mA
+ 0.826ns 0.380508mA
+ 0.828ns 0.378846mA
+ 0.83ns 0.377192mA
+ 0.832ns 0.375544mA
+ 0.834ns 0.373904mA
+ 0.836ns 0.372271mA
+ 0.838ns 0.370645mA
+ 0.84ns 0.369026mA
+ 0.842ns 0.367414mA
+ 0.844ns 0.36581mA
+ 0.846ns 0.364212mA
+ 0.848ns 0.362621mA
+ 0.85ns 0.361038mA
+ 0.852ns 0.359461mA
+ 0.854ns 0.357891mA
+ 0.856ns 0.356328mA
+ 0.858ns 0.354771mA
+ 0.86ns 0.353222mA
+ 0.862ns 0.351679mA
+ 0.864ns 0.350143mA
+ 0.866ns 0.348614mA
+ 0.868ns 0.347091mA
+ 0.87ns 0.345575mA
+ 0.872ns 0.344066mA
+ 0.874ns 0.342563mA
+ 0.876ns 0.341067mA
+ 0.878ns 0.339577mA
+ 0.88ns 0.338094mA
+ 0.882ns 0.336617mA
+ 0.884ns 0.335147mA
+ 0.886ns 0.333683mA
+ 0.888ns 0.332226mA
+ 0.89ns 0.330775mA
+ 0.892ns 0.32933mA
+ 0.894ns 0.327892mA
+ 0.896ns 0.32646mA
+ 0.898ns 0.325034mA
+ 0.9ns 0.323614mA
+ 0.902ns 0.322201mA
+ 0.904ns 0.320793mA
+ 0.906ns 0.319392mA
+ 0.908ns 0.317997mA
+ 0.91ns 0.316608mA
+ 0.912ns 0.315225mA
+ 0.914ns 0.313849mA
+ 0.916ns 0.312478mA
+ 0.918ns 0.311113mA
+ 0.92ns 0.309754mA
+ 0.922ns 0.308401mA
+ 0.924ns 0.307054mA
+ 0.926ns 0.305713mA
+ 0.928ns 0.304378mA
+ 0.93ns 0.303048mA
+ 0.932ns 0.301725mA
+ 0.934ns 0.300407mA
+ 0.936ns 0.299095mA
+ 0.938ns 0.297788mA
+ 0.94ns 0.296488mA
+ 0.942ns 0.295193mA
+ 0.944ns 0.293903mA
+ 0.946ns 0.292619mA
+ 0.948ns 0.291341mA
+ 0.95ns 0.290069mA
+ 0.952ns 0.288802mA
+ 0.954ns 0.28754mA
+ 0.956ns 0.286285mA
+ 0.958ns 0.285034mA
+ 0.96ns 0.283789mA
+ 0.962ns 0.28255mA
+ 0.964ns 0.281315mA
+ 0.966ns 0.280087mA
+ 0.968ns 0.278863mA
+ 0.97ns 0.277645mA
+ 0.972ns 0.276432mA
+ 0.974ns 0.275225mA
+ 0.976ns 0.274023mA
+ 0.978ns 0.272826mA
+ 0.98ns 0.271634mA
+ 0.982ns 0.270448mA
+ 0.984ns 0.269267mA
+ 0.986ns 0.26809mA
+ 0.988ns 0.266919mA
+ 0.99ns 0.265754mA
+ 0.992ns 0.264593mA
+ 0.994ns 0.263437mA
+ 0.996ns 0.262286mA
+ 0.998ns 0.261141mA
+ 1ns 0.26mA
+ 1.002ns 0.258864mA
+ 1.004ns 0.257734mA
+ 1.006ns 0.256608mA
+ 1.008ns 0.255487mA
+ 1.01ns 0.254371mA
+ 1.012ns 0.25326mA
+ 1.014ns 0.252154mA
+ 1.016ns 0.251052mA
+ 1.018ns 0.249956mA
+ 1.02ns 0.248864mA
+ 1.022ns 0.247777mA
+ 1.024ns 0.246695mA
+ 1.026ns 0.245617mA
+ 1.028ns 0.244544mA
+ 1.03ns 0.243476mA
+ 1.032ns 0.242413mA
+ 1.034ns 0.241354mA
+ 1.036ns 0.2403mA
+ 1.038ns 0.23925mA
+ 1.04ns 0.238205mA
+ 1.042ns 0.237164mA
+ 1.044ns 0.236128mA
+ 1.046ns 0mA
+ 8.012ns 0mA
+ 8.014ns 0.00479819mA
+ 8.016ns 0.0124833mA
+ 8.018ns 0.0201685mA
+ 8.02ns 0.0278573mA
+ 8.022ns 0.0355425mA
+ 8.024ns 0.0432277mA
+ 8.026ns 0.0509128mA
+ 8.028ns 0.058598mA
+ 8.03ns 0.0662831mA
+ 8.032ns 0.0739683mA
+ 8.034ns 0.0816571mA
+ 8.036ns 0.0893423mA
+ 8.038ns 0.0970274mA
+ 8.04ns 0.104713mA
+ 8.042ns 0.112398mA
+ 8.044ns 0.120083mA
+ 8.046ns 0.127768mA
+ 8.048ns 0.135457mA
+ 8.05ns 0.143142mA
+ 8.052ns 0.150827mA
+ 8.054ns 0.158512mA
+ 8.056ns 0.166198mA
+ 8.058ns 0.173883mA
+ 8.06ns 0.181572mA
+ 8.062ns 0.189257mA
+ 8.064ns 0.196942mA
+ 8.066ns 0.204627mA
+ 8.068ns 0.212312mA
+ 8.07ns 0.219997mA
+ 8.072ns 0.227682mA
+ 8.074ns 0.235371mA
+ 8.076ns 0.243056mA
+ 8.078ns 0.250742mA
+ 8.08ns 0.258427mA
+ 8.082ns 0.266112mA
+ 8.084ns 0.273797mA
+ 8.086ns 0.281486mA
+ 8.088ns 0.289171mA
+ 8.09ns 0.296856mA
+ 8.092ns 0.304541mA
+ 8.094ns 0.312227mA
+ 8.096ns 0.319912mA
+ 8.098ns 0.327597mA
+ 8.1ns 0.335286mA
+ 8.102ns 0.342971mA
+ 8.104ns 0.350656mA
+ 8.106ns 0.358341mA
+ 8.108ns 0.366026mA
+ 8.11ns 0.373712mA
+ 8.112ns 0.3814mA
+ 8.114ns 0.389086mA
+ 8.116ns 0.396771mA
+ 8.118ns 0.404456mA
+ 8.12ns 0.412141mA
+ 8.122ns 0.419826mA
+ 8.124ns 0.427511mA
+ 8.126ns 0.4352mA
+ 8.128ns 0.442885mA
+ 8.13ns 0.45057mA
+ 8.132ns 0.458256mA
+ 8.134ns 0.465941mA
+ 8.136ns 0.473626mA
+ 8.138ns 0.481311mA
+ 8.14ns 0.489mA
+ 8.142ns 0.496685mA
+ 8.144ns 0.50437mA
+ 8.146ns 0.512055mA
+ 8.148ns 0.519741mA
+ 8.15ns 0.527426mA
+ 8.152ns 0.535115mA
+ 8.154ns 0.5428mA
+ 8.156ns 0.550485mA
+ 8.158ns 0.549587mA
+ 8.16ns 0.547187mA
+ 8.162ns 0.544797mA
+ 8.164ns 0.542418mA
+ 8.166ns 0.540048mA
+ 8.168ns 0.53769mA
+ 8.17ns 0.535342mA
+ 8.172ns 0.533004mA
+ 8.174ns 0.530677mA
+ 8.176ns 0.528359mA
+ 8.178ns 0.526051mA
+ 8.18ns 0.523754mA
+ 8.182ns 0.521467mA
+ 8.184ns 0.51919mA
+ 8.186ns 0.516922mA
+ 8.188ns 0.514665mA
+ 8.19ns 0.512417mA
+ 8.192ns 0.510179mA
+ 8.194ns 0.507951mA
+ 8.196ns 0.505733mA
+ 8.198ns 0.503524mA
+ 8.2ns 0.501325mA
+ 8.202ns 0.499136mA
+ 8.204ns 0.496955mA
+ 8.206ns 0.494785mA
+ 8.208ns 0.492624mA
+ 8.21ns 0.490473mA
+ 8.212ns 0.488331mA
+ 8.214ns 0.486199mA
+ 8.216ns 0.484076mA
+ 8.218ns 0.481961mA
+ 8.22ns 0.479856mA
+ 8.222ns 0.47776mA
+ 8.224ns 0.475674mA
+ 8.226ns 0.473597mA
+ 8.228ns 0.471529mA
+ 8.23ns 0.469469mA
+ 8.232ns 0.467418mA
+ 8.234ns 0.465377mA
+ 8.236ns 0.463345mA
+ 8.238ns 0.461321mA
+ 8.24ns 0.459307mA
+ 8.242ns 0.457301mA
+ 8.244ns 0.455303mA
+ 8.246ns 0.453315mA
+ 8.248ns 0.451335mA
+ 8.25ns 0.449364mA
+ 8.252ns 0.447402mA
+ 8.254ns 0.445448mA
+ 8.256ns 0.443502mA
+ 8.258ns 0.441565mA
+ 8.26ns 0.439636mA
+ 8.262ns 0.437716mA
+ 8.264ns 0.435805mA
+ 8.266ns 0.433902mA
+ 8.268ns 0.432007mA
+ 8.27ns 0.430119mA
+ 8.272ns 0.428241mA
+ 8.274ns 0.426371mA
+ 8.276ns 0.424509mA
+ 8.278ns 0.422655mA
+ 8.28ns 0.420809mA
+ 8.282ns 0.418971mA
+ 8.284ns 0.417141mA
+ 8.286ns 0.415319mA
+ 8.288ns 0.413505mA
+ 8.29ns 0.4117mA
+ 8.292ns 0.409902mA
+ 8.294ns 0.408111mA
+ 8.296ns 0.406328mA
+ 8.298ns 0.404554mA
+ 8.3ns 0.402787mA
+ 8.302ns 0.401028mA
+ 8.304ns 0.399277mA
+ 8.306ns 0.397533mA
+ 8.308ns 0.395797mA
+ 8.31ns 0.394068mA
+ 8.312ns 0.392347mA
+ 8.314ns 0.390633mA
+ 8.316ns 0.388927mA
+ 8.318ns 0.387229mA
+ 8.32ns 0.385538mA
+ 8.322ns 0.383854mA
+ 8.324ns 0.382177mA
+ 8.326ns 0.380508mA
+ 8.328ns 0.378846mA
+ 8.33ns 0.377191mA
+ 8.332ns 0.375544mA
+ 8.334ns 0.373904mA
+ 8.336ns 0.37227mA
+ 8.338ns 0.370644mA
+ 8.34ns 0.369026mA
+ 8.342ns 0.367414mA
+ 8.344ns 0.36581mA
+ 8.346ns 0.364212mA
+ 8.348ns 0.362621mA
+ 8.35ns 0.361037mA
+ 8.352ns 0.35946mA
+ 8.354ns 0.35789mA
+ 8.356ns 0.356327mA
+ 8.358ns 0.354771mA
+ 8.36ns 0.353222mA
+ 8.362ns 0.351678mA
+ 8.364ns 0.350142mA
+ 8.366ns 0.348613mA
+ 8.368ns 0.347091mA
+ 8.37ns 0.345575mA
+ 8.372ns 0.344066mA
+ 8.374ns 0.342563mA
+ 8.376ns 0.341066mA
+ 8.378ns 0.339577mA
+ 8.38ns 0.338094mA
+ 8.382ns 0.336617mA
+ 8.384ns 0.335147mA
+ 8.386ns 0.333683mA
+ 8.388ns 0.332225mA
+ 8.39ns 0.330774mA
+ 8.392ns 0.32933mA
+ 8.394ns 0.327891mA
+ 8.396ns 0.326459mA
+ 8.398ns 0.325034mA
+ 8.4ns 0.323614mA
+ 8.402ns 0.3222mA
+ 8.404ns 0.320793mA
+ 8.406ns 0.319392mA
+ 8.408ns 0.317997mA
+ 8.41ns 0.316608mA
+ 8.412ns 0.315225mA
+ 8.414ns 0.313849mA
+ 8.416ns 0.312477mA
+ 8.418ns 0.311112mA
+ 8.42ns 0.309754mA
+ 8.422ns 0.308401mA
+ 8.424ns 0.307054mA
+ 8.426ns 0.305713mA
+ 8.428ns 0.304377mA
+ 8.43ns 0.303048mA
+ 8.432ns 0.301724mA
+ 8.434ns 0.300406mA
+ 8.436ns 0.299094mA
+ 8.438ns 0.297788mA
+ 8.44ns 0.296488mA
+ 8.442ns 0.295192mA
+ 8.444ns 0.293903mA
+ 8.446ns 0.292619mA
+ 8.448ns 0.291341mA
+ 8.45ns 0.290069mA
+ 8.452ns 0.288802mA
+ 8.454ns 0.28754mA
+ 8.456ns 0.286284mA
+ 8.458ns 0.285034mA
+ 8.46ns 0.283789mA
+ 8.462ns 0.282549mA
+ 8.464ns 0.281315mA
+ 8.466ns 0.280087mA
+ 8.468ns 0.278863mA
+ 8.47ns 0.277645mA
+ 8.472ns 0.276432mA
+ 8.474ns 0.275225mA
+ 8.476ns 0.274023mA
+ 8.478ns 0.272826mA
+ 8.48ns 0.271634mA
+ 8.482ns 0.270447mA
+ 8.484ns 0.269266mA
+ 8.486ns 0.26809mA
+ 8.488ns 0.266919mA
+ 8.49ns 0.265753mA
+ 8.492ns 0.264593mA
+ 8.494ns 0.263437mA
+ 8.496ns 0.262286mA
+ 8.498ns 0.26114mA
+ 8.5ns 0.26mA
+ 8.502ns 0.258864mA
+ 8.504ns 0.257734mA
+ 8.506ns 0.256608mA
+ 8.508ns 0.255487mA
+ 8.51ns 0.254371mA
+ 8.512ns 0.25326mA
+ 8.514ns 0.252154mA
+ 8.516ns 0.251052mA
+ 8.518ns 0.249956mA
+ 8.52ns 0.248864mA
+ 8.522ns 0.247777mA
+ 8.524ns 0.246694mA
+ 8.526ns 0.245617mA
+ 8.528ns 0.244544mA
+ 8.53ns 0.243476mA
+ 8.532ns 0.242413mA
+ 8.534ns 0.241353mA
+ 8.536ns 0.240299mA
+ 8.538ns 0.23925mA
+ 8.54ns 0.238205mA
+ 8.542ns 0.237164mA
+ 8.544ns 0.236128mA
+ 8.546ns 0mA
I251 482 0 PWL 0 0
+ 5.518ns 0mA
+ 5.52ns 0.000711926mA
+ 5.522ns 0.00837524mA
+ 5.524ns 0.0160404mA
+ 5.526ns 0.0237037mA
+ 5.528ns 0.031367mA
+ 5.53ns 0.0390321mA
+ 5.532ns 0.0466954mA
+ 5.534ns 0.0543588mA
+ 5.536ns 0.0620239mA
+ 5.538ns 0.0696872mA
+ 5.54ns 0.0773505mA
+ 5.542ns 0.0850156mA
+ 5.544ns 0.092679mA
+ 5.546ns 0.100342mA
+ 5.548ns 0.108006mA
+ 5.55ns 0.115671mA
+ 5.552ns 0.123334mA
+ 5.554ns 0.130997mA
+ 5.556ns 0.138662mA
+ 5.558ns 0.146326mA
+ 5.56ns 0.153989mA
+ 5.562ns 0.161654mA
+ 5.564ns 0.169318mA
+ 5.566ns 0.176981mA
+ 5.568ns 0.184644mA
+ 5.57ns 0.192309mA
+ 5.572ns 0.199973mA
+ 5.574ns 0.207636mA
+ 5.576ns 0.215301mA
+ 5.578ns 0.222964mA
+ 5.58ns 0.230628mA
+ 5.582ns 0.238293mA
+ 5.584ns 0.245956mA
+ 5.586ns 0.253619mA
+ 5.588ns 0.261285mA
+ 5.59ns 0.268948mA
+ 5.592ns 0.276611mA
+ 5.594ns 0.284274mA
+ 5.596ns 0.29194mA
+ 5.598ns 0.299603mA
+ 5.6ns 0.307266mA
+ 5.602ns 0.314931mA
+ 5.604ns 0.322595mA
+ 5.606ns 0.330258mA
+ 5.608ns 0.337923mA
+ 5.61ns 0.345586mA
+ 5.612ns 0.35325mA
+ 5.614ns 0.360913mA
+ 5.616ns 0.368578mA
+ 5.618ns 0.376242mA
+ 5.62ns 0.383905mA
+ 5.622ns 0.39157mA
+ 5.624ns 0.399233mA
+ 5.626ns 0.406897mA
+ 5.628ns 0.414562mA
+ 5.63ns 0.422225mA
+ 5.632ns 0.429888mA
+ 5.634ns 0.437553mA
+ 5.636ns 0.445217mA
+ 5.638ns 0.45288mA
+ 5.64ns 0.460543mA
+ 5.642ns 0.468209mA
+ 5.644ns 0.475872mA
+ 5.646ns 0.483535mA
+ 5.648ns 0.4912mA
+ 5.65ns 0.498864mA
+ 5.652ns 0.506527mA
+ 5.654ns 0.514192mA
+ 5.656ns 0.521855mA
+ 5.658ns 0.529519mA
+ 5.66ns 0.537182mA
+ 5.662ns 0.544847mA
+ 5.664ns 0.550997mA
+ 5.666ns 0.548591mA
+ 5.668ns 0.546196mA
+ 5.67ns 0.543811mA
+ 5.672ns 0.541437mA
+ 5.674ns 0.539072mA
+ 5.676ns 0.536719mA
+ 5.678ns 0.534375mA
+ 5.68ns 0.532042mA
+ 5.682ns 0.529719mA
+ 5.684ns 0.527406mA
+ 5.686ns 0.525103mA
+ 5.688ns 0.52281mA
+ 5.69ns 0.520527mA
+ 5.692ns 0.518255mA
+ 5.694ns 0.515991mA
+ 5.696ns 0.513739mA
+ 5.698ns 0.511496mA
+ 5.7ns 0.509262mA
+ 5.702ns 0.507038mA
+ 5.704ns 0.504824mA
+ 5.706ns 0.50262mA
+ 5.708ns 0.500425mA
+ 5.71ns 0.49824mA
+ 5.712ns 0.496065mA
+ 5.714ns 0.493899mA
+ 5.716ns 0.491742mA
+ 5.718ns 0.489595mA
+ 5.72ns 0.487457mA
+ 5.722ns 0.485329mA
+ 5.724ns 0.48321mA
+ 5.726ns 0.481099mA
+ 5.728ns 0.478999mA
+ 5.73ns 0.476908mA
+ 5.732ns 0.474825mA
+ 5.734ns 0.472752mA
+ 5.736ns 0.470688mA
+ 5.738ns 0.468632mA
+ 5.74ns 0.466586mA
+ 5.742ns 0.464549mA
+ 5.744ns 0.46252mA
+ 5.746ns 0.4605mA
+ 5.748ns 0.45849mA
+ 5.75ns 0.456488mA
+ 5.752ns 0.454495mA
+ 5.754ns 0.45251mA
+ 5.756ns 0.450534mA
+ 5.758ns 0.448567mA
+ 5.76ns 0.446608mA
+ 5.762ns 0.444658mA
+ 5.764ns 0.442716mA
+ 5.766ns 0.440783mA
+ 5.768ns 0.438858mA
+ 5.77ns 0.436942mA
+ 5.772ns 0.435034mA
+ 5.774ns 0.433134mA
+ 5.776ns 0.431243mA
+ 5.778ns 0.42936mA
+ 5.78ns 0.427485mA
+ 5.782ns 0.425619mA
+ 5.784ns 0.42376mA
+ 5.786ns 0.42191mA
+ 5.788ns 0.420067mA
+ 5.79ns 0.418233mA
+ 5.792ns 0.416407mA
+ 5.794ns 0.414589mA
+ 5.796ns 0.412778mA
+ 5.798ns 0.410976mA
+ 5.8ns 0.409181mA
+ 5.802ns 0.407395mA
+ 5.804ns 0.405616mA
+ 5.806ns 0.403844mA
+ 5.808ns 0.402081mA
+ 5.81ns 0.400325mA
+ 5.812ns 0.398577mA
+ 5.814ns 0.396837mA
+ 5.816ns 0.395104mA
+ 5.818ns 0.393378mA
+ 5.82ns 0.391661mA
+ 5.822ns 0.38995mA
+ 5.824ns 0.388248mA
+ 5.826ns 0.386552mA
+ 5.828ns 0.384864mA
+ 5.83ns 0.383184mA
+ 5.832ns 0.38151mA
+ 5.834ns 0.379844mA
+ 5.836ns 0.378186mA
+ 5.838ns 0.376534mA
+ 5.84ns 0.37489mA
+ 5.842ns 0.373253mA
+ 5.844ns 0.371623mA
+ 5.846ns 0.37mA
+ 5.848ns 0.368385mA
+ 5.85ns 0.366776mA
+ 5.852ns 0.365174mA
+ 5.854ns 0.36358mA
+ 5.856ns 0.361992mA
+ 5.858ns 0.360411mA
+ 5.86ns 0.358838mA
+ 5.862ns 0.357271mA
+ 5.864ns 0.35571mA
+ 5.866ns 0.354157mA
+ 5.868ns 0.352611mA
+ 5.87ns 0.351071mA
+ 5.872ns 0.349538mA
+ 5.874ns 0.348011mA
+ 5.876ns 0.346492mA
+ 5.878ns 0.344979mA
+ 5.88ns 0.343472mA
+ 5.882ns 0.341972mA
+ 5.884ns 0.340479mA
+ 5.886ns 0.338992mA
+ 5.888ns 0.337512mA
+ 5.89ns 0.336038mA
+ 5.892ns 0.33457mA
+ 5.894ns 0.33311mA
+ 5.896ns 0.331655mA
+ 5.898ns 0.330206mA
+ 5.9ns 0.328765mA
+ 5.902ns 0.327329mA
+ 5.904ns 0.325899mA
+ 5.906ns 0.324476mA
+ 5.908ns 0.323059mA
+ 5.91ns 0.321648mA
+ 5.912ns 0.320244mA
+ 5.914ns 0.318846mA
+ 5.916ns 0.317453mA
+ 5.918ns 0.316067mA
+ 5.92ns 0.314687mA
+ 5.922ns 0.313313mA
+ 5.924ns 0.311944mA
+ 5.926ns 0.310582mA
+ 5.928ns 0.309226mA
+ 5.93ns 0.307875mA
+ 5.932ns 0.306531mA
+ 5.934ns 0.305192mA
+ 5.936ns 0.30386mA
+ 5.938ns 0.302532mA
+ 5.94ns 0.301211mA
+ 5.942ns 0.299896mA
+ 5.944ns 0.298586mA
+ 5.946ns 0.297282mA
+ 5.948ns 0.295984mA
+ 5.95ns 0.294692mA
+ 5.952ns 0.293405mA
+ 5.954ns 0.292124mA
+ 5.956ns 0.290848mA
+ 5.958ns 0.289578mA
+ 5.96ns 0.288313mA
+ 5.962ns 0.287054mA
+ 5.964ns 0.2858mA
+ 5.966ns 0.284552mA
+ 5.968ns 0.28331mA
+ 5.97ns 0.282072mA
+ 5.972ns 0.280841mA
+ 5.974ns 0.279614mA
+ 5.976ns 0.278393mA
+ 5.978ns 0.277177mA
+ 5.98ns 0.275967mA
+ 5.982ns 0.274762mA
+ 5.984ns 0.273562mA
+ 5.986ns 0.272367mA
+ 5.988ns 0.271178mA
+ 5.99ns 0.269993mA
+ 5.992ns 0.268814mA
+ 5.994ns 0.26764mA
+ 5.996ns 0.266471mA
+ 5.998ns 0.265308mA
+ 6ns 0.264149mA
+ 6.002ns 0.262996mA
+ 6.004ns 0.261847mA
+ 6.006ns 0.260704mA
+ 6.008ns 0.259565mA
+ 6.01ns 0.258431mA
+ 6.012ns 0.257303mA
+ 6.014ns 0.256179mA
+ 6.016ns 0.255061mA
+ 6.018ns 0.253947mA
+ 6.02ns 0.252838mA
+ 6.022ns 0.251734mA
+ 6.024ns 0.250634mA
+ 6.026ns 0.24954mA
+ 6.028ns 0.24845mA
+ 6.03ns 0.247365mA
+ 6.032ns 0.246284mA
+ 6.034ns 0.245209mA
+ 6.036ns 0.244138mA
+ 6.038ns 0.243072mA
+ 6.04ns 0.24201mA
+ 6.042ns 0.240953mA
+ 6.044ns 0.239901mA
+ 6.046ns 0.238853mA
+ 6.048ns 0.23781mA
+ 6.05ns 0.236772mA
+ 6.052ns 0.235738mA
+ 6.054ns 0mA
I252 483 0 PWL 0 0
+ 5.52ns 0mA
+ 5.522ns 0.00628804mA
+ 5.524ns 0.0139956mA
+ 5.526ns 0.0217014mA
+ 5.528ns 0.0294072mA
+ 5.53ns 0.0371148mA
+ 5.532ns 0.0448205mA
+ 5.534ns 0.0525263mA
+ 5.536ns 0.0602339mA
+ 5.538ns 0.0679397mA
+ 5.54ns 0.0756455mA
+ 5.542ns 0.0833531mA
+ 5.544ns 0.0910588mA
+ 5.546ns 0.0987646mA
+ 5.548ns 0.10647mA
+ 5.55ns 0.114178mA
+ 5.552ns 0.121884mA
+ 5.554ns 0.129589mA
+ 5.556ns 0.137297mA
+ 5.558ns 0.145003mA
+ 5.56ns 0.152709mA
+ 5.562ns 0.160416mA
+ 5.564ns 0.168122mA
+ 5.566ns 0.175828mA
+ 5.568ns 0.183534mA
+ 5.57ns 0.191241mA
+ 5.572ns 0.198947mA
+ 5.574ns 0.206653mA
+ 5.576ns 0.21436mA
+ 5.578ns 0.222066mA
+ 5.58ns 0.229772mA
+ 5.582ns 0.237479mA
+ 5.584ns 0.245185mA
+ 5.586ns 0.252891mA
+ 5.588ns 0.260599mA
+ 5.59ns 0.268304mA
+ 5.592ns 0.27601mA
+ 5.594ns 0.283716mA
+ 5.596ns 0.291423mA
+ 5.598ns 0.299129mA
+ 5.6ns 0.306835mA
+ 5.602ns 0.314543mA
+ 5.604ns 0.322248mA
+ 5.606ns 0.329954mA
+ 5.608ns 0.337662mA
+ 5.61ns 0.345368mA
+ 5.612ns 0.353073mA
+ 5.614ns 0.360779mA
+ 5.616ns 0.368487mA
+ 5.618ns 0.376192mA
+ 5.62ns 0.383898mA
+ 5.622ns 0.391606mA
+ 5.624ns 0.399312mA
+ 5.626ns 0.407017mA
+ 5.628ns 0.414725mA
+ 5.63ns 0.422431mA
+ 5.632ns 0.430136mA
+ 5.634ns 0.437844mA
+ 5.636ns 0.44555mA
+ 5.638ns 0.453256mA
+ 5.64ns 0.460961mA
+ 5.642ns 0.468669mA
+ 5.644ns 0.476375mA
+ 5.646ns 0.48408mA
+ 5.648ns 0.491788mA
+ 5.65ns 0.499494mA
+ 5.652ns 0.5072mA
+ 5.654ns 0.514907mA
+ 5.656ns 0.522613mA
+ 5.658ns 0.530319mA
+ 5.66ns 0.538025mA
+ 5.662ns 0.545732mA
+ 5.664ns 0.5499mA
+ 5.666ns 0.547503mA
+ 5.668ns 0.545117mA
+ 5.67ns 0.542742mA
+ 5.672ns 0.540377mA
+ 5.674ns 0.538022mA
+ 5.676ns 0.535678mA
+ 5.678ns 0.533343mA
+ 5.68ns 0.531019mA
+ 5.682ns 0.528705mA
+ 5.684ns 0.526401mA
+ 5.686ns 0.524108mA
+ 5.688ns 0.521823mA
+ 5.69ns 0.519549mA
+ 5.692ns 0.517286mA
+ 5.694ns 0.515031mA
+ 5.696ns 0.512787mA
+ 5.698ns 0.510552mA
+ 5.7ns 0.508327mA
+ 5.702ns 0.506112mA
+ 5.704ns 0.503907mA
+ 5.706ns 0.501711mA
+ 5.708ns 0.499524mA
+ 5.71ns 0.497348mA
+ 5.712ns 0.495181mA
+ 5.714ns 0.493022mA
+ 5.716ns 0.490874mA
+ 5.718ns 0.488735mA
+ 5.72ns 0.486605mA
+ 5.722ns 0.484485mA
+ 5.724ns 0.482374mA
+ 5.726ns 0.480271mA
+ 5.728ns 0.478178mA
+ 5.73ns 0.476095mA
+ 5.732ns 0.47402mA
+ 5.734ns 0.471954mA
+ 5.736ns 0.469898mA
+ 5.738ns 0.46785mA
+ 5.74ns 0.465811mA
+ 5.742ns 0.463781mA
+ 5.744ns 0.46176mA
+ 5.746ns 0.459748mA
+ 5.748ns 0.457744mA
+ 5.75ns 0.45575mA
+ 5.752ns 0.453764mA
+ 5.754ns 0.451786mA
+ 5.756ns 0.449817mA
+ 5.758ns 0.447857mA
+ 5.76ns 0.445905mA
+ 5.762ns 0.443962mA
+ 5.764ns 0.442027mA
+ 5.766ns 0.440101mA
+ 5.768ns 0.438183mA
+ 5.77ns 0.436274mA
+ 5.772ns 0.434372mA
+ 5.774ns 0.432479mA
+ 5.776ns 0.430595mA
+ 5.778ns 0.428718mA
+ 5.78ns 0.42685mA
+ 5.782ns 0.42499mA
+ 5.784ns 0.423138mA
+ 5.786ns 0.421293mA
+ 5.788ns 0.419458mA
+ 5.79ns 0.41763mA
+ 5.792ns 0.415809mA
+ 5.794ns 0.413998mA
+ 5.796ns 0.412193mA
+ 5.798ns 0.410397mA
+ 5.8ns 0.408608mA
+ 5.802ns 0.406828mA
+ 5.804ns 0.405055mA
+ 5.806ns 0.40329mA
+ 5.808ns 0.401532mA
+ 5.81ns 0.399782mA
+ 5.812ns 0.39804mA
+ 5.814ns 0.396305mA
+ 5.816ns 0.394578mA
+ 5.818ns 0.392859mA
+ 5.82ns 0.391147mA
+ 5.822ns 0.389442mA
+ 5.824ns 0.387745mA
+ 5.826ns 0.386055mA
+ 5.828ns 0.384373mA
+ 5.83ns 0.382698mA
+ 5.832ns 0.38103mA
+ 5.834ns 0.379369mA
+ 5.836ns 0.377716mA
+ 5.838ns 0.37607mA
+ 5.84ns 0.374431mA
+ 5.842ns 0.372799mA
+ 5.844ns 0.371175mA
+ 5.846ns 0.369557mA
+ 5.848ns 0.367946mA
+ 5.85ns 0.366343mA
+ 5.852ns 0.364746mA
+ 5.854ns 0.363157mA
+ 5.856ns 0.361574mA
+ 5.858ns 0.359998mA
+ 5.86ns 0.358429mA
+ 5.862ns 0.356867mA
+ 5.864ns 0.355312mA
+ 5.866ns 0.353763mA
+ 5.868ns 0.352222mA
+ 5.87ns 0.350687mA
+ 5.872ns 0.349158mA
+ 5.874ns 0.347637mA
+ 5.876ns 0.346122mA
+ 5.878ns 0.344613mA
+ 5.88ns 0.343111mA
+ 5.882ns 0.341616mA
+ 5.884ns 0.340127mA
+ 5.886ns 0.338645mA
+ 5.888ns 0.337169mA
+ 5.89ns 0.3357mA
+ 5.892ns 0.334236mA
+ 5.894ns 0.33278mA
+ 5.896ns 0.33133mA
+ 5.898ns 0.329885mA
+ 5.9ns 0.328448mA
+ 5.902ns 0.327016mA
+ 5.904ns 0.325591mA
+ 5.906ns 0.324172mA
+ 5.908ns 0.322759mA
+ 5.91ns 0.321353mA
+ 5.912ns 0.319952mA
+ 5.914ns 0.318558mA
+ 5.916ns 0.31717mA
+ 5.918ns 0.315787mA
+ 5.92ns 0.314411mA
+ 5.922ns 0.313041mA
+ 5.924ns 0.311676mA
+ 5.926ns 0.310318mA
+ 5.928ns 0.308966mA
+ 5.93ns 0.307619mA
+ 5.932ns 0.306278mA
+ 5.934ns 0.304943mA
+ 5.936ns 0.303614mA
+ 5.938ns 0.302291mA
+ 5.94ns 0.300974mA
+ 5.942ns 0.299662mA
+ 5.944ns 0.298356mA
+ 5.946ns 0.297056mA
+ 5.948ns 0.295761mA
+ 5.95ns 0.294472mA
+ 5.952ns 0.293188mA
+ 5.954ns 0.291911mA
+ 5.956ns 0.290638mA
+ 5.958ns 0.289372mA
+ 5.96ns 0.288111mA
+ 5.962ns 0.286855mA
+ 5.964ns 0.285605mA
+ 5.966ns 0.28436mA
+ 5.968ns 0.283121mA
+ 5.97ns 0.281887mA
+ 5.972ns 0.280658mA
+ 5.974ns 0.279435mA
+ 5.976ns 0.278217mA
+ 5.978ns 0.277004mA
+ 5.98ns 0.275797mA
+ 5.982ns 0.274595mA
+ 5.984ns 0.273398mA
+ 5.986ns 0.272207mA
+ 5.988ns 0.27102mA
+ 5.99ns 0.269839mA
+ 5.992ns 0.268663mA
+ 5.994ns 0.267492mA
+ 5.996ns 0.266326mA
+ 5.998ns 0.265166mA
+ 6ns 0.26401mA
+ 6.002ns 0.262859mA
+ 6.004ns 0.261713mA
+ 6.006ns 0.260573mA
+ 6.008ns 0.259437mA
+ 6.01ns 0.258306mA
+ 6.012ns 0.257181mA
+ 6.014ns 0.25606mA
+ 6.016ns 0.254944mA
+ 6.018ns 0.253832mA
+ 6.02ns 0.252726mA
+ 6.022ns 0.251625mA
+ 6.024ns 0.250528mA
+ 6.026ns 0.249436mA
+ 6.028ns 0.248349mA
+ 6.03ns 0.247266mA
+ 6.032ns 0.246189mA
+ 6.034ns 0.245116mA
+ 6.036ns 0.244048mA
+ 6.038ns 0.242984mA
+ 6.04ns 0.241925mA
+ 6.042ns 0.24087mA
+ 6.044ns 0.23982mA
+ 6.046ns 0.238775mA
+ 6.048ns 0.237735mA
+ 6.05ns 0.236698mA
+ 6.052ns 0.235667mA
+ 6.054ns 0mA
I253 484 0 PWL 0 0
+ 0.134ns 0mA
+ 0.136ns 0.00135192mA
+ 0.138ns 0.00577268mA
+ 0.14ns 0.0101934mA
+ 0.142ns 0.0146142mA
+ 0.144ns 0.0190349mA
+ 0.146ns 0.0234557mA
+ 0.148ns 0.0278764mA
+ 0.15ns 0.0322972mA
+ 0.152ns 0.0367179mA
+ 0.154ns 0.0411387mA
+ 0.156ns 0.0455594mA
+ 0.158ns 0.0499802mA
+ 0.16ns 0.054401mA
+ 0.162ns 0.0588217mA
+ 0.164ns 0.0632424mA
+ 0.166ns 0.0676632mA
+ 0.168ns 0.072084mA
+ 0.17ns 0.0765047mA
+ 0.172ns 0.0809255mA
+ 0.174ns 0.0853462mA
+ 0.176ns 0.089767mA
+ 0.178ns 0.0941877mA
+ 0.18ns 0.0986085mA
+ 0.182ns 0.103029mA
+ 0.184ns 0.10745mA
+ 0.186ns 0.107862mA
+ 0.188ns 0.104353mA
+ 0.19ns 0.100958mA
+ 0.192ns 0.097673mA
+ 0.194ns 0.0944952mA
+ 0.196ns 0.0914208mA
+ 0.198ns 0.0884464mA
+ 0.2ns 0.0855687mA
+ 0.202ns 0.0827847mA
+ 0.204ns 0.0800912mA
+ 0.206ns 0.0774853mA
+ 0.208ns 0.0749642mA
+ 0.21ns 0.0725251mA
+ 0.212ns 0.0701654mA
+ 0.214ns 0.0678824mA
+ 0.216ns 0.0656737mA
+ 0.218ns 0.0635368mA
+ 0.22ns 0.0614694mA
+ 0.222ns 0.0594693mA
+ 0.224ns 0.0575343mA
+ 0.226ns 0.0556622mA
+ 0.228ns 0.053851mA
+ 0.23ns 0.0520987mA
+ 0.232ns 0.0504034mA
+ 0.234ns 0.0487633mA
+ 0.236ns 0.0471765mA
+ 0.238ns 0.0456414mA
+ 0.24ns 0.0441562mA
+ 0.242ns 0.0427193mA
+ 0.244ns 0.0413292mA
+ 0.246ns 0.0399842mA
+ 0.248ns 0.0386831mA
+ 0.25ns 0.0374243mA
+ 0.252ns 0mA
+ 5.134ns 0mA
+ 5.136ns 0.00135238mA
+ 5.138ns 0.00577282mA
+ 5.14ns 0.0101932mA
+ 5.142ns 0.0146147mA
+ 5.144ns 0.0190352mA
+ 5.146ns 0.0234556mA
+ 5.148ns 0.0278771mA
+ 5.15ns 0.0322975mA
+ 5.152ns 0.0367179mA
+ 5.154ns 0.0411394mA
+ 5.156ns 0.0455599mA
+ 5.158ns 0.0499803mA
+ 5.16ns 0.0544007mA
+ 5.162ns 0.0588222mA
+ 5.164ns 0.0632426mA
+ 5.166ns 0.0676631mA
+ 5.168ns 0.0720846mA
+ 5.17ns 0.076505mA
+ 5.172ns 0.0809254mA
+ 5.174ns 0.0853469mA
+ 5.176ns 0.0897673mA
+ 5.178ns 0.0941878mA
+ 5.18ns 0.0986082mA
+ 5.182ns 0.10303mA
+ 5.184ns 0.10745mA
+ 5.186ns 0.107862mA
+ 5.188ns 0.104352mA
+ 5.19ns 0.100957mA
+ 5.192ns 0.097673mA
+ 5.194ns 0.0944947mA
+ 5.196ns 0.0914206mA
+ 5.198ns 0.0884464mA
+ 5.2ns 0.0855683mA
+ 5.202ns 0.0827844mA
+ 5.204ns 0.0800911mA
+ 5.206ns 0.0774855mA
+ 5.208ns 0.0749639mA
+ 5.21ns 0.072525mA
+ 5.212ns 0.0701654mA
+ 5.214ns 0.0678821mA
+ 5.216ns 0.0656735mA
+ 5.218ns 0.0635368mA
+ 5.22ns 0.0614691mA
+ 5.222ns 0.0594691mA
+ 5.224ns 0.0575342mA
+ 5.226ns 0.0556623mA
+ 5.228ns 0.0538508mA
+ 5.23ns 0.0520986mA
+ 5.232ns 0.0504035mA
+ 5.234ns 0.0487631mA
+ 5.236ns 0.0471764mA
+ 5.238ns 0.0456414mA
+ 5.24ns 0.044156mA
+ 5.242ns 0.0427192mA
+ 5.244ns 0.0413292mA
+ 5.246ns 0.039984mA
+ 5.248ns 0.038683mA
+ 5.25ns 0.0374242mA
+ 5.252ns 0mA
.op
.tran 0.002n 10n uic=2
.plot tran V(19) V(20) V(21)
